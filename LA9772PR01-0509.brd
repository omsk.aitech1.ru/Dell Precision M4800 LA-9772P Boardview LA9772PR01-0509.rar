# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCKED#: length 4.9
  TOP w0.102: U9.45 27.75,155.33 R518.2 27.77,154.75 v1(27.75,154.72)
  BOTTOM w0.102: Q326.1 26.73,153.96 27.12,154.35 v2(27.12,154.72) v1(27.75,154.72)
DP1_MUX_REXT: length 5.3
  TOP w0.102: U629.34 33.19,155.8 33.16,155.76 32.52,155.76 31.96,156.32 31.96,156.54 31.76,156.74 31.76,157.74 R96.2 32.2,158.28 v2(32.22,158.29)
DP_A_MXM_AUX_Q: length 52.7
  IN2 w0.127: v1(211.31,61.17) 212.84,62.7 215.96,62.7 217.15,61.5 223.02,61.5 227.06,65.54 235.31,65.54 239.3,69.53 242.22,69.53 v1(244.38,67.37)
  BOTTOM w0.102: R2193.2 211.32,61.19 v1(211.31,61.17) ; Q340.2 243.35,76.5 243.35,76.31 243.75,75.92 243.75,75.14 243.45,74.85 243.05,74.85 242.71,75.19 242.71,75.25 Q340.5 v2(242.5,72.83) 242.5,70.19 243.67,69.02 243.67,68.59 244.32,67.94 Q339.3 244.63,67.62 v1(244.38,67.37)
DP_CFG0: length 4.6
  TOP w0.102: U9.44 26.92,154.93 R64.2 R61.2 27.29,153.07 v2(26.79,152.58)
DP_CFG1: length 4.6
  TOP w0.102: U9.29 19.66,153.32 19.2,152.86 19.2,151.38 R72.2 R73.2 v2(20.35,150.4)
DP_MB_P14: length 25.9
  TOP w0.102: v1(263.28,140.63) 264.02,141.36 264.02,144.32 v2(266.15,146.45) 266.73,147.04 267.75,147.04 268.69,147.98 268.69,154.68 JDP1.14
  BOTTOM w0.102: R801.2 260.79,141.16 261.31,140.64 263.27,140.64 v1(263.28,140.63)
DP_RP_CEXT: length 5.3
  BOTTOM w0.102: U22.2 238.58,90.5 238.16,90.92 236.42,90.92 C87.1 235.01,91.4 v2(234.88,91.53)
DP_RP_CFG0: length 3.1
  BOTTOM w0.102: R76.2 239.67,91.4 R77.1 239.82,91.25 239.82,90.14 240.08,89.89 U22.5
DP_RP_CFG1: length 6.6
  BOTTOM w0.102: U22.40 236.86,84.64 236.85,84.66 235.4,84.66 234.98,84.24 v2(234.98,82.6) 234.98,81.79 235.05,81.73 R79.1 R78.2
DP_RP_PEQ: length 4.2
  BOTTOM w0.102: U22.4 239.58,89.88 239.53,89.93 239.53,90.76 239.36,90.92 238.48,90.92 238,91.4 R80.2 R81.1
DP_RP_REXT: length 2.4
  BOTTOM w0.102: R75.2 241.99,91.02 v2(241.49,90.52) 241.08,90.11 U22.7
DPC_CA_DET: length 45.8
  TOP w0.102: Q110.2 83.11,131.21 82.83,131.49 81.68,131.49 C1174.1 80.06,131.86 79.74,132.18 D88.2 79.26,133.44 v2(76,130.18) 74.1,128.28 74.1,125.41 74.53,124.98 v1(74.46,124.98) ; v1(75.97,113.74) 75.97,113.59 77.36,112.2 U20.1 81.24,112.2 R492.2 82.43,113.24 82.43,114.31 82.13,114.62 80.96,114.62 80.49,114.15 U20.4
  IN2 w0.127: v1(74.46,124.98) 75.07,124.98 77.53,122.51 77.53,120.74 74.1,117.31 74.1,114.95 74.79,114.26 75.45,114.26 v1(75.97,113.74)
  BOTTOM w0.102: v1(74.46,124.98) 74.53,124.98 74.2,125.31 JDOCK1.6
DPC_CA_DET#: length 33.8
  TOP w0.102: v1(81.15,132.97) 81.15,132.99 81.83,133.68 83.05,133.68 v2(83.57,134.2) 83.7,134.33 83.94,134.33 84.31,133.96 84.31,133.77 R1532.2 84.77,133.18 83.97,132.38 83.32,132.38 83.11,132.6 Q110.5 Q110.6 ; U20.13 74.41,112.85 v1(75.27,113.7) ; v1(74.53,115.12) 74.2,114.8 U20.10
  IN1 w0.109: v1(74.53,115.12) 74.53,114.44 v1(75.27,113.7)
  IN2 w0.127: v1(74.53,115.12) 74.96,115.12 78.65,118.81 78.65,126.25 80.04,127.65 80.04,131.86 v1(81.15,132.97)
DPC_DOCK_AUX: length 2.4
  TOP w0.102: C387.1 81.05,113.38 80.65,113.38 80.12,112.85 U20.2
DPC_DOCK_AUX#: length 2.2
  TOP w0.102: U20.5 80.43,114.8 80.78,115.15 C388.1
DPC_DOCK_LANE_C_N0: length 1.2
  BOTTOM w0.102: C438.1 74.59,135.48 74.59,135.36 R2173.2
DPC_DOCK_LANE_C_N1: length 1.2
  BOTTOM w0.102: R2175.2 76.62,135.36 76.62,135.48 C440.1
DPC_DOCK_LANE_C_N2: length 1.2
  BOTTOM w0.102: R2177.2 78.65,135.36 78.65,135.48 C442.1
DPC_DOCK_LANE_C_N3: length 1.2
  BOTTOM w0.102: C444.1 80.69,135.48 80.69,135.36 R2179.2
DPC_DOCK_LANE_C_P0: length 1.2
  BOTTOM w0.102: C431.1 74.32,135.48 74.32,135.36 R2172.2
DPC_DOCK_LANE_C_P1: length 1.2
  BOTTOM w0.102: R2174.2 76.35,135.36 76.35,135.48 C439.1
DPC_DOCK_LANE_C_P2: length 1.2
  BOTTOM w0.102: R2176.2 78.39,135.36 78.39,135.48 C441.1
DPC_DOCK_LANE_C_P3: length 1.2
  BOTTOM w0.102: R2178.2 80.42,135.36 80.42,135.48 C443.1
DPC_DOCK_LANE_N0_R: length 8.4
  BOTTOM w0.102: R2173.1 74.58,133.69 v3(74.58,131.56) 74.58,131.23 75.58,130.23 75.58,127.32 75.7,127.2 JDOCK1.12
DPC_DOCK_LANE_N1_R: length 8.2
  BOTTOM w0.102: JDOCK1.18 77.2,127.21 77.08,127.33 77.08,132.23 76.62,132.7 v3(76.62,133.02) 76.62,133.69 R2175.1
DPC_DOCK_LANE_N2_R: length 8
  BOTTOM w0.102: JDOCK1.24 78.7,127.24 78.58,127.35 v3(78.58,131.46) 78.58,132.22 78.65,132.28 78.65,133.69 R2177.1
DPC_DOCK_LANE_N3_R: length 8.2
  BOTTOM w0.102: JDOCK1.30 80.2,127.21 80.08,127.33 80.08,131.15 v3(80.34,131.41) 80.68,131.75 80.68,133.69 R2179.1
DPC_DOCK_LANE_P0_R: length 8.4
  BOTTOM w0.102: R2172.1 74.32,133.7 v3(74.32,133.03) 74.32,131.12 75.32,130.12 75.32,127.29 75.2,127.17 JDOCK1.10
DPC_DOCK_LANE_P1_R: length 8.2
  BOTTOM w0.102: R2174.1 76.35,133.7 76.35,132.59 76.82,132.12 v3(76.82,131.39) 76.82,127.32 76.7,127.2 JDOCK1.16
DPC_DOCK_LANE_P2_R: length 8
  BOTTOM w0.102: R2176.1 78.38,133.7 v3(78.38,132.98) 78.38,132.39 78.32,132.33 78.32,127.34 78.2,127.22 JDOCK1.22
DPC_DOCK_LANE_P3_R: length 8.2
  BOTTOM w0.102: R2178.1 80.41,133.7 v3(80.41,133.06) 80.41,131.86 79.82,131.26 79.82,127.32 79.7,127.2 JDOCK1.28
DPC_DOCK_SW_AUX: length 42.1
  TOP w0.102: v1(79.76,124.34) 79.8,124.31 79.8,123.42 79.66,123.28 78.7,123.28 74.8,119.38 73.74,119.38 70.95,116.59 70.95,115.35 71.23,115.07 71.79,115.07 72.72,114.15 U20.11 74.28,114.15 75.14,115.01 75.67,115.01 76.35,114.32 77.66,114.32 78.48,113.5 U20.3 ; Q113.1 v1(85.89,130.19)
  BOTTOM w0.102: v1(79.76,124.34) 79.97,124.55 79.97,124.73 80.23,124.99 81.17,124.99 81.31,125.13 81.31,125.28 81.2,125.4 JDOCK1.34 81.2,127.2 81.33,127.33 81.33,130.51 81.74,130.92 83.8,130.92 85.02,129.7 86.27,129.7 87.03,130.46 87.03,131.53 86.75,131.81 86.6,131.81 v2(85.89,131.09) v1(85.89,130.19)
DPC_DOCK_SW_AUX#: length 42.1
  TOP w0.102: Q113.4 87.19,133.52 v1(87.16,133.54) ; U20.6 78.51,115.45 77.62,114.55 76.45,114.55 75.76,115.24 75.13,115.24 74.27,116.1 U20.8 72.59,116.1 72.53,116.16 71.97,116.16 71.81,116.01 71.81,115.4 71.71,115.3 71.32,115.3 71.18,115.45 71.18,116.5 73.83,119.15 74.89,119.15 78.79,123.05 79.75,123.05 80.03,123.33 80.03,124.01 80.36,124.34 v1(80.4,124.34)
  BOTTOM w0.102: v1(87.16,133.54) 86.83,133.21 86.83,132.06 86.84,132.05 87.26,131.63 87.26,130.36 86.37,129.47 84.92,129.47 83.7,130.69 81.84,130.69 81.56,130.41 81.56,127.35 81.7,127.21 JDOCK1.36 81.7,125.42 81.54,125.26 81.54,125.19 81.54,125.04 81.27,124.76 80.32,124.76 80.2,124.64 80.2,124.45 80.3,124.34 v1(80.4,124.34)
DPC_GPU_HPD: length 45.5
  TOP w0.102: C696.1 R2160.1 82.63,128 v1(82.53,128.1)
  IN2 w0.127: v1(61.17,108.27) 64.07,111.16 68.13,111.16 70.24,113.27 76.23,113.27 78.14,115.17 78.14,117.94 78.9,118.7 78.9,124.88 82.13,128.1 v1(82.53,128.1)
  BOTTOM w0.102: JDOCK1.40 82.7,127.94 v1(82.53,128.1) ; v1(61.17,108.27) v2(61.17,107.54) 61.17,104.79 D18.2 61.63,103.76 U14.2
DPC_GPU_HPD_GATE: length 11.8
  TOP w0.102: JMXM1.302 56,97.55 55.6,97.94 55.6,99.3 55.88,99.58 56.96,99.58 57.18,99.35 60.68,99.35 60.89,99.57 v1(60.97,99.57)
  BOTTOM w0.102: v4(63.86,101.06) 63.27,100.48 U14.4 61.89,100.48 60.98,99.57 v1(60.97,99.57)
DPD_CA_DET: length 81.5
  TOP w0.102: v1(28.71,150.51) 28.71,150.54 v2(28.23,151.02) 27.63,151.62 26.42,151.62 25.94,151.14 25.94,150.23 25.74,150.02 24.43,150.02 C1332.1 R491.2 24.05,151.32 24.24,151.32 25,152.08 25,152.99 24.86,153.14 U9.42
  IN3 w0.127: v1(61.25,118.43) 61.18,118.49 61.18,131.04 57.84,134.38 57.36,134.38 56.86,134.88 51.74,134.88 49.4,137.22 44.46,137.22 44.33,137.09 41.61,137.09 38.71,139.99 37.37,139.99 34.71,142.66 34.71,144.33 31.3,147.73 31.3,147.99 30.18,149.11 29.68,149.11 28.71,150.07 v1(28.71,150.51)
  BOTTOM w0.102: v1(61.25,118.43) 62.81,118.43 64.72,116.52 73.47,116.52 74.2,117.26 JDOCK1.5
DPD_CPU_LANE_N0: length 137.7
  TOP w0.102: v1(45.25,156.5) 45.45,156.3 45.45,156.04 45.3,155.89 45.3,155.15 45.16,155.02 44.96,155.02 C516.1 ; JCPU1.P29 v1(78.12,53.75)
  IN1 w0.089: v1(78.12,53.75) 78.12,54.02 77.99,54.15 77.73,54.15 77.52,54.36 77.52,55.69 75.5,57.7 75.5,57.92 75.28,58.14 74.9,58.14 74.51,58.52 74.51,58.89 74.26,59.15 73.89,59.15 73.54,59.5 73.54,59.87 73.26,60.14 72.04,60.14 72.03,60.13 72.02,60.13
  IN1 w0.117: v1(45.25,156.5) 45.45,156.3 45.45,156.07 45.33,155.95 44.52,155.95 44.21,156.26 44.21,156.54 43.77,156.99 42.53,156.99 40.74,155.2 40.74,148.88 40.08,148.22 40.08,143.7 39.73,143.35 39.73,141.97 41.34,140.36 41.34,135.24 43.15,133.43 54.01,133.43 57.53,129.9 57.53,115.76 56.01,114.23 56.01,110.68 56.5,110.19 57.14,110.19 59.62,107.7 59.62,104.01 62.22,101.41 62.89,101.41 64.98,99.31 64.98,94.35 70.95,88.38 70.95,78.26 70.58,77.89 70.58,61.05 71.5,60.13 72.02,60.13
DPD_CPU_LANE_N0_C: length 5.7
  TOP w0.102: C516.2 43.37,155.02 42.75,155.02 42.39,154.66 40.64,154.66 39.68,153.71 39.3,153.71 39.21,153.8 U629.12
DPD_CPU_LANE_N1: length 131.1
  TOP w0.102: v1(42.83,156.25) 43.04,156.04 43.04,155.89 42.94,155.8 42.47,155.8 C518.1 ; v1(79.12,52.75) JCPU1.N28
  IN1 w0.089: v1(79.12,52.75) 79.12,52.84 79,52.96 79,53.14 78.91,53.23 78.77,53.23 78.53,53.46 78.53,55.89 77.27,57.16 76.87,57.16 75.53,58.49 75.53,58.96 75.35,59.14 74.9,59.14 74.53,59.51 74.53,59.88 74.25,60.16 73.88,60.16 73.52,60.52 73.52,60.89 73.26,61.15 72.01,61.15 72.01,61.14 71.99,61.14
  IN1 w0.117: v1(42.83,156.25) 42.96,156.12 42.96,154.87 41.48,153.39 41.48,148.58 40.95,148.05 40.95,141.97 42.09,140.82 42.09,135.55 43.46,134.17 54.31,134.17 58.27,130.21 58.27,112.31 58.63,111.94 58.63,111.31 60.5,109.44 60.5,107.77 60.89,107.38 60.89,103.79 62.49,102.18 63.15,102.18 65.72,99.62 65.72,94.65 71.71,88.65 71.71,77.8 71.32,77.4 71.32,61.57 71.74,61.14 71.99,61.14
DPD_CPU_LANE_N1_C: length 3.1
  TOP w0.102: C518.2 40.88,155.76 40.72,155.76 40.36,155.4 40.36,155.37 40.22,155.23 40.2,155.23 39.86,154.89 39.31,154.89 39.2,155 U629.15
DPD_CPU_LANE_N2: length 141.2
  TOP w0.102: JCPU1.P31 v1(76.12,53.75) ; v1(45.37,158.15) 45.58,157.95 45.58,157.8 45.47,157.69 44.96,157.69 C520.1
  IN1 w0.089: v1(76.12,53.75) 76.12,54 75.98,54.13 75.72,54.13 75.51,54.35 75.51,55.89 74.22,57.18 73.82,57.18 72.84,58.16 71.97,58.16 71.96,58.16 71.94,58.16
  IN1 w0.117: 71.94,58.16 71.68,58.16 71.68,58.15 71.39,58.15 69.11,60.43 69.11,78.83 69.43,79.15 69.43,85.45 63.22,91.66 63.22,95.15 60.92,97.45 60.92,98.12 60.15,98.9 60.15,99.73 57.89,102 57.89,106.3 55.47,108.72 55.19,108.72 54.36,109.55 54.36,115.67 56.06,117.38 56.06,129.3 54.15,131.21 47.78,131.21 47.05,131.93 42.46,131.93 39.82,134.56 39.82,139.6 37.29,142.13 37.29,149.31 38.91,150.93 38.91,157.03 41.54,159.66 43.69,159.66 44.49,158.85 44.49,158.17 44.97,157.69 45.39,157.69 45.57,157.87 45.57,157.96 v1(45.37,158.15)
DPD_CPU_LANE_N2_C: length 6
  TOP w0.102: C520.2 43.39,157.71 43.18,157.71 42.6,157.14 41.08,157.14 v3(40.17,156.23) 39.66,155.72 39.3,155.72 39.22,155.8 U629.17
DPD_CPU_LANE_N3: length 135.8
  TOP w0.102: C522.1 42.48,158.32 42.8,158.32 43.04,158.56 43.04,158.71 v1(42.83,158.91) ; JCPU1.N30 v1(77.12,52.75)
  IN1 w0.089: 72.02,59.13 72.03,59.13 72.04,59.15 72.11,59.15 72.12,59.16 73.27,59.16 73.5,58.93 73.5,58.52 73.86,58.16 74.25,58.16 74.51,57.89 74.51,57.53 74.88,57.16 75.24,57.16 76.5,55.9 76.5,53.38 76.75,53.13 77.03,53.13 77.12,53.05 v1(77.12,52.75)
  IN1 w0.117: 72.02,59.13 71.45,59.13 69.84,60.74 69.84,78.31 70.21,78.67 70.21,85.71 63.96,91.96 63.96,95.51 61.66,97.8 61.66,98.71 61.39,98.97 61.39,100.67 59.39,102.68 59.39,102.91 58.78,103.51 58.78,107.02 56.98,108.82 56.73,108.82 55.18,110.36 55.18,114.9 56.8,116.51 56.8,129.6 53.73,132.67 42.84,132.67 40.59,134.91 40.59,140.03 38.95,141.68 38.95,143.83 39.32,144.2 39.32,148.52 40.01,149.2 40.01,155.51 43.02,158.52 43.02,158.73 v1(42.83,158.91)
DPD_CPU_LANE_N3_C: length 3.6
  TOP w0.102: U629.20 39.23,157 39.33,156.89 39.52,156.89 39.62,157 39.62,157.5 39.86,157.75 39.86,157.76 40.24,158.14 40.25,158.14 40.44,158.33 40.9,158.33 C522.2
DPD_CPU_LANE_P0: length 137.8
  TOP w0.102: JCPU1.R29 78.12,54.75 v1(78.12,54.75) ; v1(45.88,156.5) 45.67,156.28 45.67,155.95 45.51,155.8 45.51,155.06 45.25,154.8 44.96,154.8 C515.1
  IN1 w0.089: 72.02,60.37 72.04,60.35 73.35,60.35 73.74,59.95 73.74,59.59 73.98,59.36 74.34,59.36 74.72,58.98 74.72,58.61 74.99,58.35 75.37,58.35 75.71,58 75.71,57.79 77.73,55.77 77.73,55.77 77.71,55.75 77.71,54.44 77.81,54.34 77.99,54.34 78.12,54.48 78.12,54.75 v1(78.12,54.75)
  IN1 w0.117: v1(45.88,156.5) 45.69,156.3 45.69,155.97 45.42,155.71 44.42,155.71 43.98,156.16 43.98,156.45 43.67,156.75 42.63,156.75 40.98,155.1 40.98,148.79 40.32,148.13 40.32,143.61 39.96,143.25 39.96,142.07 41.58,140.46 41.58,135.34 43.25,133.67 54.11,133.67 57.77,130 57.77,115.66 56.24,114.13 56.24,110.78 56.6,110.42 57.23,110.42 59.86,107.8 59.86,104.1 62.32,101.64 62.98,101.64 65.22,99.41 65.22,94.44 71.19,88.48 71.19,78.16 70.82,77.79 70.82,61.15 71.6,60.37 72.02,60.37
DPD_CPU_LANE_P0_C: length 5.7
  TOP w0.102: C515.2 43.37,154.8 42.84,154.8 42.48,154.44 40.72,154.44 39.77,153.49 39.34,153.49 39.25,153.4 U629.11
DPD_CPU_LANE_P1: length 131.1
  TOP w0.102: v1(43.47,156.25) 43.25,156.03 43.25,155.8 43.03,155.58 42.5,155.58 C517.1 ; v1(79.12,53.75) JCPU1.P28
  IN1 w0.089: 71.99,61.38 72,61.38 72.02,61.36 72.08,61.36 72.09,61.35 73.35,61.35 73.73,60.97 73.73,60.6 73.97,60.37 74.33,60.37 74.73,59.97 74.73,59.6 74.99,59.35 75.44,59.35 75.74,59.04 75.74,58.58 76.95,57.36 77.35,57.36 78.74,55.98 78.74,53.55 78.85,53.44 79.01,53.44 79.12,53.55 v1(79.12,53.75)
  IN1 w0.117: v1(43.47,156.25) 43.4,156.25 43.2,156.04 43.2,154.77 41.72,153.29 41.72,148.48 41.18,147.95 41.18,142.06 42.33,140.92 42.33,135.65 43.56,134.41 54.41,134.41 58.5,130.31 58.5,112.41 58.87,112.04 58.87,111.41 60.74,109.54 60.74,107.86 61.13,107.47 61.13,103.88 62.59,102.42 63.25,102.42 65.95,99.72 65.95,94.75 71.95,88.75 71.95,77.7 71.55,77.3 71.55,61.66 71.84,61.38 71.99,61.38
DPD_CPU_LANE_P1_C: length 3.1
  TOP w0.102: C517.2 40.92,155.55 40.81,155.55 40.57,155.31 40.57,155.28 v3(40.16,154.87) 39.97,154.67 39.3,154.67 39.23,154.6 U629.14
DPD_CPU_LANE_P2: length 141.2
  TOP w0.102: JCPU1.R31 v1(76.12,54.75) ; C519.1 44.96,157.47 45.56,157.47 45.79,157.71 45.79,157.94 v1(46.01,158.15)
  IN1 w0.089: 71.94,58.39 71.97,58.39 71.99,58.37 72.93,58.37 73.9,57.39 74.3,57.39 74.53,57.16 74.53,57.16 75.71,55.98 75.71,54.43 75.8,54.34 75.96,54.34 76.12,54.51 v1(76.12,54.75)
  IN1 w0.117: 71.94,58.39 71.59,58.39 71.59,58.39 71.49,58.39 69.35,60.53 69.35,78.73 69.67,79.06 69.67,85.54 63.46,91.76 63.46,95.25 61.16,97.55 61.16,98.22 60.38,98.99 60.38,99.83 58.12,102.09 58.12,106.4 55.57,108.95 55.29,108.95 54.59,109.65 54.59,115.58 56.3,117.28 56.3,129.39 54.25,131.44 47.87,131.44 47.15,132.17 42.55,132.17 40.06,134.66 40.06,139.69 37.52,142.23 37.52,149.21 39.15,150.84 39.15,156.93 41.64,159.42 43.59,159.42 44.26,158.76 44.26,158.07 44.87,157.46 45.49,157.46 45.8,157.77 45.8,157.95 v1(46.01,158.15)
DPD_CPU_LANE_P2_C: length 6
  TOP w0.102: C519.2 43.35,157.49 43.26,157.49 42.69,156.92 41.17,156.92 40.55,156.3 40.55,156.28 40.12,155.85 40.1,155.85 39.75,155.5 39.35,155.5 39.25,155.4 U629.16
DPD_CPU_LANE_P3: length 135.8
  TOP w0.102: v1(43.47,158.91) 43.25,158.7 43.25,158.47 42.89,158.11 42.48,158.11 C521.1 ; JCPU1.P30 v1(77.12,53.75)
  IN1 w0.089: v1(77.12,53.75) 77.12,53.45 77.01,53.34 76.84,53.34 76.71,53.47 76.71,55.99 75.32,57.37 74.97,57.37 74.72,57.61 74.72,57.98 74.33,58.37 73.95,58.37 73.71,58.61 73.71,59.01 73.35,59.37 72.02,59.37
  IN1 w0.117: v1(43.47,158.91) 43.26,158.7 43.26,158.42 40.24,155.41 40.24,149.1 39.56,148.42 39.56,144.1 39.18,143.73 39.18,141.77 40.83,140.13 40.83,135.01 42.93,132.9 53.83,132.9 57.03,129.7 57.03,116.41 55.42,114.8 55.42,110.46 56.83,109.05 57.08,109.05 59.02,107.11 59.02,103.61 59.62,103.01 59.62,102.78 61.63,100.77 61.63,99.07 61.9,98.8 61.9,97.9 64.19,95.6 64.19,92.06 70.44,85.81 70.44,78.57 70.08,78.21 70.08,60.84 71.55,59.37 72.02,59.37
DPD_CPU_LANE_P3_C: length 3.6
  TOP w0.102: C521.2 40.89,158.11 40.53,158.11 v3(40.21,157.79) 39.84,157.41 39.84,156.91 39.61,156.68 39.33,156.68 39.25,156.6 U629.19
DPD_DOCK_AUX: length 97
  TOP w0.102: U9.55 26.31,159.33 26.38,159.41 26.67,159.41 27.06,159.81 27.16,159.9 27.16,160.92 27.54,161.3 28.58,161.3 29.51,162.23 Q337.1 29.97,162.28 v1(30.16,162.09)
  IN3 w0.127: v1(62.79,127.16) 62.61,127.34 62.16,127.34 61.69,127.81 61.69,131.25 58.16,134.79 58.16,135.2 57.51,135.85 51.53,135.85 49.65,137.73 44.25,137.73 44.12,137.6 41.82,137.6 39.33,140.09 39.33,140.32 38.52,141.13 37.12,141.13 35.21,143.04 35.21,145.1 32.83,147.48 32.83,148.62 30.46,150.98 30.46,155.29 31.66,156.48 31.66,157.29 31.71,157.34 31.71,162.03 30.76,162.98 29.83,162.98 29.22,162.36 29.22,161 29.35,160.87 29.78,160.87 30.16,161.25 v1(30.16,162.09)
  BOTTOM w0.102: v1(62.79,127.16) 62.79,127.3 62.89,127.41 71.4,127.41 72.3,126.51 72.3,124.96 73.85,123.4 76.83,123.4 77.43,122.8 77.43,121.5 79.41,119.52 80.55,119.52 80.86,119.82 81.26,119.82 81.47,119.61 81.47,119.4 81.39,119.31 81.29,119.31 81.2,119.23 JDOCK1.33 ; v1(30.16,162.09) v2(30.74,162.09)
DPD_DOCK_AUX#: length 96.5
  TOP w0.102: U9.54 26.35,158.94 26.42,159.01 26.42,159.1 26.5,159.18 26.76,159.18 26.93,159.35 27.07,159.35 27.13,159.29 27.26,159.29 27.35,159.39 27.35,159.52 27.29,159.58 27.29,159.71 27.39,159.81 27.39,160.02 27.49,160.12 27.49,160.43 27.39,160.53 27.39,160.82 27.64,161.07 28.48,161.07 28.56,161 28.56,160.87 28.21,160.52 Q337.4 28.21,160.08 28.28,160.02 28.28,159.77 v1(28.21,159.7)
  IN3 w0.127: v1(28.21,159.7) 28.96,160.71 28.96,162.47 29.73,163.23 30.87,163.23 31.96,162.14 31.96,157.24 31.91,157.19 31.91,156.37 30.72,155.18 30.72,151.09 33.08,148.73 33.08,147.59 35.47,145.2 35.47,143.14 37.22,141.39 38.62,141.39 39.58,140.43 39.58,140.2 41.92,137.86 44.01,137.86 44.14,137.98 49.75,137.98 51.63,136.1 57.62,136.1 58.41,135.31 58.41,134.89 61.95,131.36 61.95,127.91 62.26,127.59 62.58,127.59 v1(62.79,127.8)
  BOTTOM w0.102: v1(62.79,127.8) 62.95,127.63 71.5,127.63 72.53,126.6 72.53,125.05 73.95,123.63 76.92,123.63 77.66,122.9 77.66,121.59 79.5,119.75 80.46,119.75 80.76,120.05 81.36,120.05 81.7,119.71 JDOCK1.35
DPD_DOCK_AUX_Q: length 26.3
  TOP w0.102: R2153.2 25.7,149.11 Q336.3 26.26,149.37 26.83,149.95 26.83,150.84 27.09,151.09 27.57,151.09 28.13,150.53 v1(28.13,150.51) ; 31.4,160.49 31.58,160.67 31.58,161.91 31.4,162.09 Q335.2 ; 31.4,160.49 Q335.5 ; 31.4,160.49 31.4,160.51 30.97,160.95 29.43,160.95 Q337.5 28.86,159.73 v1(28.89,159.7) ; Q337.2 28.86,162.27 28.38,161.78 26.78,161.78 v1(26.63,161.63)
  BOTTOM w0.102: v1(26.63,161.63) 26.96,161.63 v2(27.67,160.92) v1(28.89,159.7) 28.28,159.09 28.28,152.21 28.13,152.06 v1(28.13,150.51)
DPD_DOCK_LANE_N0: length 1.3
  BOTTOM w0.102: C367.1 75.04,111.3 74.75,111.59 74.75,111.76 R2165.1
DPD_DOCK_LANE_N0_R: length 5.8
  BOTTOM w0.102: R2165.2 74.76,113.47 74.76,113.98 75.15,114.37 75.15,116.24 75.56,116.64 75.56,117.24 75.7,117.38 JDOCK1.11
DPD_DOCK_LANE_N1: length 1.3
  BOTTOM w0.102: R2167.1 76.79,111.76 76.79,111.59 77.07,111.3 C369.1
DPD_DOCK_LANE_N1_R: length 5.6
  BOTTOM w0.102: R2167.2 76.79,113.47 76.79,116.18 77.06,116.44 77.06,117.27 77.2,117.41 JDOCK1.17
DPD_DOCK_LANE_N2: length 1.2
  BOTTOM w0.102: C425.1 79.16,111.3 78.82,111.64 78.82,111.76 R2169.1
DPD_DOCK_LANE_N2_R: length 5.6
  BOTTOM w0.102: R2169.2 78.82,113.47 78.82,113.79 78.55,114.07 78.55,117.23 78.7,117.39 JDOCK1.23
DPD_DOCK_LANE_N3: length 1.2
  BOTTOM w0.102: C427.1 81.16,111.3 80.85,111.61 80.85,111.76 R2171.1
DPD_DOCK_LANE_N3_R: length 5.8
  BOTTOM w0.102: R2171.2 80.86,113.47 80.86,115.29 80.06,116.09 80.06,117.25 80.2,117.39 JDOCK1.29
DPD_DOCK_LANE_P0: length 1.2
  BOTTOM w0.102: R2164.1 74.54,111.76 74.54,111.61 74.23,111.3 C366.1
DPD_DOCK_LANE_P0_R: length 5.8
  BOTTOM w0.102: R2164.2 74.54,113.49 74.54,114.07 74.94,114.46 74.94,116.33 75.34,116.73 75.34,117.23 75.2,117.38 JDOCK1.9
DPD_DOCK_LANE_P1: length 1.3
  BOTTOM w0.102: C368.1 76.28,111.3 76.57,111.59 76.57,111.76 R2166.1
DPD_DOCK_LANE_P1_R: length 5.6
  BOTTOM w0.102: JDOCK1.15 76.7,117.4 76.84,117.26 76.84,116.53 76.58,116.27 76.58,113.49 R2166.2
DPD_DOCK_LANE_P2: length 1.2
  BOTTOM w0.102: C424.1 78.29,111.3 78.6,111.61 78.6,111.76 R2168.1
DPD_DOCK_LANE_P2_R: length 5.6
  BOTTOM w0.102: R2168.2 78.61,113.49 78.61,113.7 78.33,113.98 78.33,117.27 78.2,117.4 JDOCK1.21
DPD_DOCK_LANE_P3: length 1.3
  BOTTOM w0.102: R2170.1 80.63,111.76 80.63,111.6 80.34,111.3 C426.1
DPD_DOCK_LANE_P3_R: length 5.8
  BOTTOM w0.102: R2170.2 80.64,113.49 80.64,115.2 79.84,116 79.84,117.26 79.7,117.4 JDOCK1.27
DPD_GPU_HPD: length 118.3
  TOP w0.102: v1(81.9,151.65) 76.41,157.14 50.54,157.14 49.42,156.02 48.73,156.02 48.27,155.56 48.27,154.39 45.39,151.51 45.39,149.8 46.01,149.18 46.01,148.06 45.68,147.74 45.39,147.74 44.58,146.92 42.36,146.92 38.73,143.29 37.68,143.29 37.16,142.77 35.63,142.77 33.73,144.68 v2(30.09,144.68) 29,145.77 27.29,145.77 25.83,147.23 24.36,147.23 20.74,150.85 20.74,151.88 21.01,152.16 21.01,152.66 20.86,152.82 U9.32 ; v1(83.89,121.28) 82.83,120.22 R1000.1 C695.1
  IN1 w0.109: v1(83.89,121.28) 83.89,125.94 83.19,126.64 83.19,128.43 83.66,128.9 83.66,132.12 83.04,132.74 83.04,148.35 81.9,149.49 v1(81.9,151.65)
  BOTTOM w0.102: JDOCK1.39 82.7,120.09 v1(83.89,121.28)
DPD_GPU_LANE_N0: length 83.2
  TOP w0.102: U9.39 23.66,153.15 23.75,153.06 23.75,152.45 v1(23.55,152.26)
  IN3 w0.127: v1(64.3,109.87) 64.15,110.01 63.63,110.01 62.16,111.48 62.16,111.96 60.41,113.7 60.41,130.74 57.53,133.63 57.05,133.63 56.55,134.13 50.86,134.13 48.63,136.36 44.76,136.36 44.73,136.32 41.23,136.32 39.22,138.33 38.59,138.33 38.06,138.86 36.7,138.86 33.83,141.73 33.83,143.43 30.18,147.08 29.53,147.08 28.74,147.86 28.74,148.32 26.53,150.53 25.99,150.53 25.45,151.07 24.29,151.07 23.66,151.7 23.66,152.15 v1(23.55,152.26)
  BOTTOM w0.102: v1(64.3,109.87) 64.49,110.06 65.12,110.06 65.62,109.56 74.46,109.56 74.9,110.01 74.9,110.13 C367.2
DPD_GPU_LANE_N1: length 87.6
  TOP w0.102: U9.36 22.46,153.13 22.52,153.06 22.52,152.42 v1(22.36,152.26)
  IN3 w0.127: v1(64.3,108.62) 64.14,108.77 63.12,108.77 60.4,111.49 60.4,112 59.06,113.35 59.06,130.52 56.2,133.37 50.46,133.37 48.46,135.37 45.04,135.37 44.8,135.14 41.11,135.14 38.68,137.57 36.02,137.57 32.53,141.06 32.53,142.55 30.87,144.21 30.87,145.12 29.67,146.32 28.96,146.32 25.28,150 24.11,150 22.46,151.65 22.46,152.16 v1(22.36,152.26)
  BOTTOM w0.102: C369.2 76.94,110.14 76.94,109.85 76.48,109.38 75.27,109.38 74.75,108.86 72.21,108.86 72.16,108.81 64.49,108.81 v1(64.3,108.62)
DPD_GPU_LANE_N2: length 92.1
  TOP w0.102: v1(21.17,151.72) 21.35,151.91 21.35,153.05 21.26,153.14 U9.33
  IN3 w0.127: v1(63.81,107.55) 63.67,107.7 62.87,107.7 62.76,107.82 62.57,108.01 62.06,108.51 61.58,108.51 58.61,111.48 58.61,111.98 58.3,112.28 58.3,130.2 55.89,132.61 50.15,132.61 48.57,134.19 44.84,134.19 44.66,134.38 39.67,134.38 37.26,136.79 35.71,136.79 31.76,140.74 31.76,141.36 29.73,143.39 29.73,144.4 24.9,149.24 23.02,149.24 21.26,151 21.26,151.63 v1(21.17,151.72)
  BOTTOM w0.102: v1(63.81,107.55) 64,107.74 70.11,107.74 70.44,107.41 76.07,107.41 78.27,109.61 78.7,109.61 78.95,109.86 78.95,110.11 C425.2
DPD_GPU_LANE_N3: length 99.7
  TOP w0.102: v1(19.97,152.26) 20.15,152.43 20.15,153.05 20.06,153.14 U9.30
  IN3 w0.127: v1(19.97,152.26) 20.12,152.11 20.12,150.71 22.91,147.92 23.63,147.92 29.38,142.17 29.38,140.64 30.36,139.66 30.73,139.66 31.21,139.17 31.21,138.33 33.62,135.92 36.65,135.92 39.28,133.28 48.4,133.28 49.83,131.86 55.58,131.86 57.54,129.89 57.54,115.01 56.02,113.49 56.02,110.65 56.45,110.23 58.24,110.23 61.14,107.32 61.76,107.32 62.73,106.36 63.64,106.36 v1(63.79,106.21)
  BOTTOM w0.102: C427.2 81,110.14 81,109.91 80.54,109.45 79.65,109.45 78.96,108.76 78.46,108.76 76.37,106.68 70.06,106.68 69.71,107.03 65.95,107.03 65.3,106.39 63.97,106.39 v1(63.79,106.21)
DPD_GPU_LANE_P0: length 83.2
  TOP w0.102: U9.40 24.06,153.16 23.97,153.07 23.97,152.33 24.04,152.26 v1(24.19,152.26)
  IN3 w0.127: v1(64.3,110.5) 64.3,110.4 64.16,110.26 63.74,110.26 62.41,111.59 62.41,112.06 60.66,113.81 60.66,130.84 57.63,133.88 57.15,133.88 56.65,134.38 50.96,134.38 48.73,136.61 44.66,136.61 44.62,136.57 41.33,136.57 39.33,138.58 38.69,138.58 38.16,139.11 36.8,139.11 34.08,141.83 34.08,143.53 30.29,147.33 29.63,147.33 28.99,147.97 28.99,148.42 26.63,150.78 26.1,150.78 25.56,151.32 24.4,151.32 23.91,151.8 23.91,152.03 24.14,152.26 v1(24.19,152.26)
  BOTTOM w0.102: C366.2 74.6,110.39 74.68,110.3 74.68,110.1 74.37,109.78 65.71,109.78 65.21,110.27 64.37,110.27 64.3,110.35 v1(64.3,110.5)
DPD_GPU_LANE_P1: length 87.5
  TOP w0.102: U9.37 22.86,153.14 22.74,153.02 22.74,152.41 22.89,152.26 v1(22.94,152.26)
  IN3 w0.127: v1(64.3,109.28) 64.3,109.15 64.16,109.02 63.22,109.02 60.65,111.59 60.65,112.1 59.3,113.45 59.3,130.62 56.31,133.62 50.56,133.62 48.56,135.62 44.93,135.62 44.7,135.39 41.21,135.39 38.78,137.82 36.12,137.82 32.77,141.16 32.77,142.65 31.12,144.31 31.12,145.22 29.77,146.57 29.07,146.57 25.38,150.25 24.21,150.25 22.71,151.75 22.71,152.02 v1(22.94,152.26)
  BOTTOM w0.102: C368.2 76.63,110.39 76.72,110.29 76.72,109.94 76.39,109.6 75.18,109.6 74.66,109.08 72.12,109.08 72.07,109.03 64.4,109.03 64.3,109.13 v1(64.3,109.28)
DPD_GPU_LANE_P2: length 92.1
  TOP w0.102: v1(21.75,151.72) 21.65,151.72 21.57,151.81 21.57,153.04 21.66,153.13 U9.34
  IN3 w0.127: v1(21.75,151.72) 21.51,151.49 21.51,151.1 23.13,149.48 25,149.48 29.98,144.51 29.98,143.5 32.01,141.46 32.01,140.84 35.81,137.04 37.36,137.04 39.78,134.63 44.76,134.63 44.95,134.44 48.67,134.44 50.25,132.86 55.99,132.86 58.55,130.31 58.55,112.39 58.86,112.08 58.86,111.59 61.68,108.76 62.16,108.76 62.81,108.11 62.93,107.99 62.98,107.95 63.65,107.95 63.81,108.11 v1(63.81,108.27)
  BOTTOM w0.102: C424.2 78.61,110.39 78.73,110.27 78.73,109.95 78.61,109.83 78.18,109.83 75.98,107.63 70.53,107.63 70.2,107.96 63.92,107.96 63.81,108.06 v1(63.81,108.27)
DPD_GPU_LANE_P3: length 99.7
  TOP w0.102: U9.31 20.46,153.13 20.37,153.03 20.37,152.45 v1(20.56,152.26)
  IN3 w0.127: v1(63.79,106.92) 63.79,106.74 63.65,106.6 62.83,106.6 61.87,107.57 61.25,107.57 58.34,110.48 56.55,110.48 56.27,110.75 56.27,113.39 57.79,114.91 57.79,129.99 55.68,132.11 49.93,132.11 48.51,133.53 39.38,133.53 36.75,136.17 33.73,136.17 31.46,138.43 31.46,139.27 30.83,139.9 30.47,139.9 29.63,140.75 29.63,142.28 23.73,148.17 23.02,148.17 20.37,150.82 20.37,152.07 v1(20.56,152.26)
  BOTTOM w0.102: v1(63.79,106.92) 63.79,106.72 63.9,106.6 65.21,106.6 65.86,107.25 69.8,107.25 70.15,106.89 76.28,106.89 78.37,108.98 78.87,108.98 79.56,109.66 80.45,109.66 80.79,110 80.79,110.3 80.7,110.39 C426.2
DPD_PCH_HPD: length 113.7
  TOP w0.102: UH1.H39 27.27,105.88 v1(27.15,105.76) ; v1(27.77,140.75) v2(28.25,141.23) ; U629.13 v1(39.58,154.2)
  IN3 w0.127: v1(27.15,105.76) 27.15,105.87 28.86,107.58 35.77,107.58 36.15,107.2 36.15,103.64 36.51,103.29 37.83,103.29 38.16,103.62 39.26,103.62 40.38,104.73 45.97,104.73 49,107.76 52.54,107.76 53.4,108.61 53.4,114.95 56.49,118.03 56.49,129.51 55.15,130.84 48.34,130.84 47.29,131.89 38,131.89 36.54,133.34 33.34,133.34 32.42,134.26 32.42,135.58 30.82,137.18 30.02,137.18 27.77,139.43 v1(27.77,140.75)
  IN4 w0.109: v1(27.77,140.75) v2(28.25,141.23) 28.29,141.23 29.88,142.83 29.88,143.89 33.32,147.33 38.29,147.33 39.17,148.22 39.17,153.79 v1(39.58,154.2)
DSCHRG_MOSFET_GC: length 4.5
  BOTTOM w0.102: PR1004.2 157.31,122.08 158.4,122.08 v2(158.66,121.83)
  BOTTOM w0.254: PR1004.2 155.75,121.58 155.54,121.78 PU1001.29
DSWODVREN: length 7.4
  TOP w0.102: RH81.2 RH67.1 20.37,91.73 20.8,91.3 v2(21.18,91.3) 21.94,91.3 22.85,92.21 23.82,92.21 24.3,92.69 24.91,92.69 25.05,92.83 25.39,92.83 25.53,92.97 UH1.C8
DYN_TUR_CURRNT_SET#: length 206.5
  IN3 w0.127: v1(215.41,53.85) 216.28,53.85 216.87,54.44 216.87,57.91 219.05,60.08 224.57,60.08 v1(225.31,60.82) ; v1(200.26,90.99) 200.24,90.99 194.47,96.76 192.61,96.76 191.97,97.39 184.95,97.39 184.21,96.66 181.03,96.66 175.42,102.27 172.42,102.27 159.58,115.11 159.58,116.93 157.81,118.71 157.81,121.38 152.72,126.47 151.68,126.47 151.33,126.82 151.33,134.88 149.55,136.66 149.18,136.66 149.05,136.79 144.79,136.79 136.06,145.51 133.46,145.51 131.97,144.03 121.7,144.03 120.53,145.2 113.85,145.2 113.58,144.93 108.98,144.93 108.21,145.69 106.99,145.69 106.71,145.97 100.96,145.97 97.61,149.32 97.37,149.32 95.77,150.93 95.77,151.15 94.91,152 v1(94.67,152)
  BOTTOM w0.102: v1(215.41,53.85) 214.19,53.85 204.1,63.94 204.1,70.65 201.66,73.09 201.66,74.65 201.15,75.16 201.15,90.71 200.87,90.99 v1(200.26,90.99) ; v1(94.67,152) 95.16,152.49 v2(95.16,152.97) 95.84,153.66 R1980.2 96.42,153.77 U51.A35
  BOTTOM w0.254: v1(225.31,60.82) 225.37,60.75 226.58,60.75 226.81,60.98 PQ707.5
DYN_TURB_SYS_PWR_ALRT#: length 2.4
  BOTTOM w0.102: U46.A46 220.67,88.1 221.23,88.66 T139.1
EC5048_TX: length 167.3
  TOP w0.102: JDEG2.2 169.61,114.24 170.8,113.04 170.8,113.03 R849.2 171.19,112.22 171.19,111.52 v2(172.18,110.53) 172.18,109.47 v1(174.95,106.7)
  IN1 w0.109: v1(221.42,77.35) 220.98,76.91 213.14,76.91 212.4,77.64 210.71,77.64 209.8,78.56 203.02,78.56 198.03,83.55 185.66,83.55 181.16,88.05 181.16,92.05 174.15,99.06 v1(172.36,99.06)
  IN3 w0.127: v1(106.55,132.6) 109.68,132.6 112.3,129.98 114.12,129.98 119.45,124.65 119.45,120.18 123.53,116.1 129.73,116.1 130.94,114.89 144.81,114.89 150.49,109.22 159.85,109.22 170.01,99.06 v1(172.36,99.06)
  BOTTOM w0.102: v1(172.36,99.06) 174.23,99.06 174.95,99.78 v1(174.95,106.7) ; JMINI3.17 108.15,133.36 107.39,132.6 v1(106.55,132.6) ; v1(221.42,77.35) 221.42,77.35 U46.B2
EC_32KHZ_ECE5048: length 154.5
  IN3 w0.127: v1(104.73,160.41) 105.42,161.1 110.77,161.1 111.9,159.97 117.83,159.97 118.94,161.07 123.68,161.07 125.18,159.57 126.7,159.57 127.03,159.24 129.96,159.24 132.47,156.73 138.5,156.73 150.26,144.97 150.26,143.61 154.49,139.38 154.49,138.36 155.67,137.18 155.67,128.02 158.51,125.18 158.51,124.15 163.4,119.26 167.4,119.26 169.59,117.07 169.59,109.23 180.64,98.18 194.73,98.18 201.71,91.2 205.9,91.2 v1(208.03,89.06)
  BOTTOM w0.102: v1(208.03,89.06) 209.37,87.73 v2(211.7,87.73) 212.49,87.73 213.92,86.3 U46.B35 ; v1(104.73,160.41) 104.75,160.43 U51.B62
EC_WAKE#: length 165.5
  TOP w0.089: v1(30.24,93.85) 30.5,94.1 UH1.R11
  TOP w0.102: v1(115.07,152.65) 113.14,150.72 113.14,146.21 110.73,143.8 106.72,143.8 105.29,145.22 103.14,145.22 102.12,144.21 98.15,144.21 v1(97.82,144.54) ; v1(104.83,153.27) v2(104.83,153.88)
  IN2 w0.127: v1(97.82,144.54) 98.21,144.16 98.21,140.64 93.66,136.09 93.66,132.66 93.07,132.08 93.07,126.86 91.68,125.46 91.68,118.97 90.53,117.83 90.53,115.23 89.36,114.06 82.5,114.06 81.31,112.86 70.19,112.86 67.88,110.55 67.88,108.02 66.74,106.89 66.74,105.15 63.94,102.35 62.31,102.35 60.64,104.02 54.45,104.02 53.09,102.66 50.66,102.66 48.15,100.15 43.89,100.15 43.06,99.32 37.4,99.32 36.58,98.51 34.37,98.51 33.23,97.36 33.23,95.81 32.7,95.29 31.38,95.29 30.67,94.57 30.67,94.27 v1(30.24,93.85)
  IN4 w0.109: v1(110.5,156.26) 110.16,156.6 109.34,156.6 107.82,155.08 105.98,155.08 104.83,153.93 v1(104.83,153.27)
  BOTTOM w0.102: RH216.1 26.25,85.41 26.25,86.19 26.48,86.43 27.25,86.43 28.99,88.17 28.99,89.37 29.88,90.26 29.88,91.63 29.74,91.77 29.74,93.27 30.24,93.77 v1(30.24,93.85) ; v1(115.07,152.65) 115.07,153.71 115.53,154.16 115.53,156.35 115.21,156.67 115.21,157.58 R563.1 114.12,158.02 113.15,157.06 112.56,157.06 112.09,157.53 111.19,157.53 110.5,156.83 v1(110.5,156.26) ; v1(104.83,153.27) 104.96,153.27 105.37,152.87 105.37,152.39 105.25,152.26 U51.B23
EDID_SELECT#: length 197.3
  TOP w0.102: v1(86.17,160.79) v2(86.86,160.79)
  IN3 w0.127: v1(86.17,160.79) 86.17,160.89 86.62,161.35 110.88,161.35 112.01,160.22 117.73,160.22 118.83,161.33 123.86,161.33 125.31,159.88 126.76,159.88 127.14,159.5 130.08,159.5 132.6,156.98 138.61,156.98 147.18,148.41 148.55,148.41 152.05,144.91 152.05,142.18 154.75,139.49 154.75,138.46 155.93,137.28 155.93,128.12 158.77,125.28 158.77,124.25 162.37,120.65 168.44,120.65 172.31,116.78 172.31,107.23 180.85,98.69 195.94,98.69 202.7,91.93 206.33,91.93 209.13,89.14 215.71,89.14 216.07,88.78 221.27,88.78 221.7,88.35 221.7,86.7 223.6,84.8 224.65,84.8 225,85.15 226.11,85.15 226.42,84.84 226.42,83.78 225.38,82.74 224.57,82.74 222.61,80.77 v1(221.83,80.77)
  BOTTOM w0.102: U19.1 86.08,160.7 v1(86.17,160.79) ; U46.B61 v1(221.83,80.77)
EDP_COMP: length 3.3
  TOP w0.457: v1(83.07,44.77) 83.56,44.28 JCPU1.E24
  BOTTOM w0.508: RC1.2 82.71,47.03 83.07,46.67 v2(83.07,45.93) v1(83.07,44.77)
EDP_HPD#: length 24.3
  TOP w0.102: JCPU1.P27 v1(80.12,53.75)
  BOTTOM w0.102: RC65.1 66.2,42.71 QC6.1 69.35,43.7 v2(70.32,44.66) 71.92,46.26 78.19,46.26 78.51,46.59 78.51,47.45 78.62,47.56 78.62,51.5 79.61,52.49 79.61,53.24 v1(80.12,53.75)
EDP_IN1_AEQ#: length 2.1
  TOP w0.102: U630.59 66.37,134.51 v2(66.46,134.43) 66.58,134.3 R140.1
EDP_IN1_PEQ: length 4.8
  TOP w0.102: R127.1 63.2,131.76 63.2,132.19 63.14,132.26 63.14,133.07 R137.1 63.6,134.05 63.36,134.28 v2(63.36,134.43) 63.36,134.84 63.57,135.05 U630.52
EDP_IN2_AEQ#: length 6.6
  TOP w0.102: U630.58 65.97,134.96 66.05,134.88 66.05,132.29 66.12,132.22 66.12,130.88 R142.1 66.9,130.43 v2(67.53,131.06)
EDP_IN2_PEQ: length 6
  TOP w0.102: U630.51 63.17,134.99 62.65,134.47 R138.1 62.15,133.03 62.15,131.79 62.57,131.37 R133.1 62.23,130.95 v2(61.67,130.95)
EDP_MUX_CEXT: length 2.2
  TOP w0.102: C98.1 60.31,137.47 v2(61.29,137.47) U630.47
EDP_MUX_PC0: length 3.1
  TOP w0.102: U630.38 v2(61.27,141.07) 60.33,141.07 R136.1 R100.1
EDP_MUX_PC1: length 4.7
  TOP w0.102: U630.55 64.77,134.94 64.85,134.85 v2(64.85,134.43) 64.85,133.77 R141.1 64.16,133.07 64.16,131.82 R109.1
EDP_MUX_PI0: length 4.8
  TOP w0.102: U630.56 65.17,134.94 65.24,134.87 65.24,134.08 65.57,133.75 R139.1 65.08,133.04 65.08,132.31 65.24,132.16 65.24,131.7 R143.1
EDP_MUX_REXT: length 2.8
  TOP w0.102: R101.2 60.64,143.49 61.2,142.94 v2(61.2,142.83) 61.36,142.67 U630.34
EN_1.5VSP: length 6.2
  BOTTOM w0.102: PR404.1 262.47,37.15 v2(263.28,37.96)
  BOTTOM w0.254: PR404.1 262.39,36.66 PR403.2 PR406.2 260.56,36.61 PC406.1 260.56,35.57 259.67,34.68 PU400.5
EN_+1.05VSP: length 5.1
  TOP w0.254: PR303.2 PR315.1 PC307.1 20.48,147.61 20.35,147.74 20.35,148.25 v2(20.61,148.5) 21.04,148.5 21.48,148.06 v1(21.48,147.98)
  BOTTOM w0.254: PU300.3 v1(21.48,147.98)
EN_DK_PWRBAR: length 3.4
  BOTTOM w0.254: PU1001.17 148.08,121.78 147.81,122.05 v2(147.43,122.05) PR1027.1 146.42,122.97 PR1028.1
EN_DOCK_PWR_BAR: length 89.8
  IN3 w0.127: v1(215.5,84.62) 215.34,84.78 212.8,84.78 210.9,86.68 199.45,86.68 192.49,93.64 180.02,93.64 174.18,99.48 169.95,99.48 159.62,109.8 158.39,109.8 156.76,111.43 155.91,111.43 152.75,114.59 151.05,114.59 146.55,119.08 146.55,120.27 v1(144.76,122.06)
  BOTTOM w0.102: U46.B37 214.92,85.63 215.05,85.51 215.05,84.97 215.4,84.62 v1(215.5,84.62) ; v2(144.48,121.58) 144.76,121.85 v1(144.76,122.06) 144.77,122.05 PR1027.2
EN_I2S_NB_CODEC#: length 227.7
  TOP w0.102: v1(14.28,93.36) 14.04,93.6 JIO1.60 ; v1(200.82,92.72) 200.94,92.61 210.46,92.61 213.5,89.57 213.5,87.03 214.64,85.89 v1(214.64,85.23)
  IN2 w0.127: v1(14.28,93.36) 14.36,93.28 14.36,92.67 15.63,91.4 16.51,91.4 18.21,89.7 18.21,88.87 21.09,85.99 25.09,85.99 25.53,86.43 28.05,86.43 28.72,85.76 30.77,85.76 31.44,86.43 34.79,86.43 36.07,85.15 40.41,85.15 40.52,85.27 45.64,85.27 47.36,86.98 57.04,86.98 57.93,87.87 60.96,87.87 61.98,86.85 65.45,86.85 69.87,91.27 71.49,91.27 75.98,95.77 79.28,95.77 80.24,96.72 81.15,96.72 82.01,97.59 82.01,97.95 83.49,99.43 86.38,99.43 86.85,99.9 115.01,99.9 115.24,99.67 119.57,99.67 120.24,98.99 121.16,98.99 122.16,100 128.65,100 132.77,104.13 138.69,104.13 141.12,101.7 178.96,101.7 179.22,101.95 182.72,101.95 189.31,95.36 199.02,95.36 200.82,93.57 v1(200.82,92.72)
  BOTTOM w0.102: v1(214.64,85.23) 214.42,85.45 U46.B36
EN_INVPWR: length 91.1
  IN1 w0.109: v1(71.19,154.68) 68.88,157 64.09,157 63.83,157.25 56.35,157.25 55.61,156.51 49.88,156.51 v1(48.68,155.31)
  IN2 w0.127: v1(71.19,154.68) 72.81,153.07 90.25,153.07 96.42,159.24 97.37,159.24 99.09,160.97 102.42,160.97 102.88,160.51 102.88,160.17 106.46,156.58 106.46,155.43 107.02,154.87 107.22,154.87 108.14,153.96 108.14,152.54 107.07,151.47 104.38,151.47 v1(103.23,150.33)
  IN3 w0.127: v1(103.23,150.33) 103.23,149.64 104.62,148.26 107.83,148.26 108.13,147.97 108.87,147.97 109.41,148.5 v1(109.41,149.26)
  BOTTOM w0.102: v1(103.23,150.33) 103.5,150.59 U51.A25 ; RP7.6 111.68,148.25 110.66,149.26 v2(110.24,149.26) v1(109.41,149.26) ; Q22.2 49.94,155.15 48.83,155.15 v1(48.68,155.31)
EN_LCDPWR: length 10
  BOTTOM w0.102: U62.3 47.23,149.82 46.71,149.31 46.71,147.24 v2(46.52,147.05) 46.14,146.67 R431.1 45.37,145.65 45.03,146 D6.1 43.5,146 42.23,144.72 D53.1
ENVDD_PCH: length 269.8
  TOP w0.102: UH1.G36 27.16,104.54 27.42,104.8 v1(27.45,104.8)
  IN2 w0.127: v1(42.76,135.88) 42.68,135.88 37.97,131.17 37.97,126.32 37.22,125.58 37.22,116.39 v1(37.65,115.96) 37.92,115.69 37.92,114.9 37.88,114.86 37.88,113.4 38.13,113.14 41.21,113.14 42.86,114.79 46.87,114.79 48.88,112.79 51.66,112.79 51.7,112.82 v1(51.8,112.82) ; v1(215.48,85.2) 215.02,85.66 212.7,85.66 206.48,91.88 204.82,91.88 199.71,96.99 197.89,96.99 195.27,99.6 188.33,99.6 181.94,105.99 177.55,105.99 175.48,108.06 158.33,108.06 156.71,106.44 130.65,106.44 129.7,105.48 116.89,105.48 115.27,107.1 85.05,107.1 83.89,105.94 80.94,105.94 80.24,105.24 76.04,105.24 v1(75.17,106.11)
  IN4 w0.109: v1(37.65,115.96) 37.65,115.5 37.91,115.24 37.91,114.9 37.88,114.87 37.88,112.9 36.59,111.61 35.18,111.61 34.49,110.92 29.77,110.92 28.18,109.33 28.18,108.09 27.29,107.2 27.29,106.56 27.54,106.31 27.54,105.6 27.41,105.47 27.41,104.84 v1(27.45,104.8)
  BOTTOM w0.102: v1(75.17,106.11) 74.71,105.65 v2(65.59,105.65) 63.63,105.65 63.31,105.97 63.31,110.27 64.52,111.49 64.52,111.95 62.59,113.88 53.12,113.88 52.09,112.85 51.82,112.85 v1(51.8,112.82) ; v1(215.48,85.2) 215.48,85.23 215.42,85.29 U46.B38 ; v1(27.45,104.8) 27,104.35 26.48,104.35 RH118.2 ; D53.2 40.13,144.22 34.55,138.64 34.55,134.41 34.78,134.19 38.83,134.19 40.34,135.7 42.58,135.7 v1(42.76,135.88)
EQ_A: length 1.7
  BOTTOM w0.102: R551.1 216.87,61.43 U637.19
EQ_B: length 1.8
  BOTTOM w0.102: R564.1 217.79,61.76 217.37,62.18 U637.18
ERC1: length 2.7
  BOTTOM w0.254: PC1007.1 153.18,115.63 152.7,116.11 PU1001.3
ERC2: length 4.7
  BOTTOM w0.102: v2(144.51,119.78) 145.92,119.78 PC1009.1
  BOTTOM w0.254: PC1009.1 146.92,119.29 147.38,119.75 148.2,119.75 148.23,119.78 PU1001.13
ERC3: length 5.4
  BOTTOM w0.102: PC1008.1 146.06,117.49 v2(144.22,117.49)
  BOTTOM w0.254: PU1001.12 147.71,119.28 147.6,119.17
  BOTTOM w0.508: 147.6,119.17 146.72,118.29 PC1008.1
ESATA_PRX_DTX_N3_C: length 128.5
  TOP w0.102: v1(46.62,93.35) 46.8,93.53 46.8,93.84 46.54,94.09 45.83,94.09 45.59,94.33 43.58,94.33 43.57,94.32 43.13,94.32 42.92,94.52 42.45,94.52 UH1.BC12 ; v1(40.01,161.96) 40.22,161.75 40.52,161.75 43.36,164.6 43.36,165.63 C673.1
  IN4 w0.117: v1(46.62,93.35) 46.81,93.16 46.81,93.02 46.67,92.88 44.87,92.88 44.53,92.55 44.53,92.49 42.12,90.08 39.86,90.08 39.35,89.57 35.62,89.57 33.76,87.71 29.73,87.71 29.17,88.28 26.4,88.28 25.36,89.32 25.36,89.44 24.39,90.41 24.39,95.14 23.14,96.39 21.33,96.39 21.23,96.29 20.82,96.29 19.74,97.37 19.74,97.37 18.51,98.61 18.03,98.61 16.75,99.88 16.75,100.85 15.41,102.19 15.41,104.71 15.07,105.04 15.07,106.1 16.14,107.17 16.14,114.61 18.36,116.83 18.36,117.62 19.11,118.37 19.11,119.01 20.63,120.53 20.63,121.78 22.13,123.28 22.13,126.37 26.15,130.39 26.15,133.4 26.58,133.83 26.58,134.77 26.98,135.16 26.98,138.76 34.74,146.52 38.52,146.52 40.31,148.31 40.31,155.37 40.21,155.47 40.21,158.32 40.88,158.99 40.88,161.41 40.52,161.77 40.21,161.77 v1(40.01,161.96)
ESATA_PRX_DTX_P3_C: length 128.6
  TOP w0.102: v1(47.2,93.35) 47.01,93.55 47.01,93.93 46.63,94.31 45.92,94.31 45.68,94.55 43.49,94.55 43.48,94.53 43.35,94.53 UH1.BE12 ; C674.1 43.58,165.63 43.58,164.51 40.61,161.54 40.23,161.54 v1(40.01,161.33)
  IN4 w0.117: v1(47.2,93.35) 47.05,93.2 47.05,92.92 46.77,92.64 44.97,92.64 44.77,92.45 44.77,92.39 42.22,89.84 39.96,89.84 39.45,89.33 35.72,89.33 33.86,87.47 29.64,87.47 29.07,88.04 26.3,88.04 25.12,89.22 25.12,89.35 24.16,90.31 24.16,95.04 23.04,96.16 21.43,96.16 21.33,96.06 20.72,96.06 19.51,97.27 19.51,97.28 18.41,98.37 17.93,98.37 16.52,99.78 16.52,100.75 15.17,102.09 15.17,104.61 14.83,104.95 14.83,106.2 15.9,107.27 15.9,114.71 18.12,116.93 18.12,117.72 18.87,118.47 18.87,119.11 20.4,120.63 20.4,121.88 21.9,123.37 21.9,126.46 25.92,130.48 25.92,133.49 26.35,133.93 26.35,134.86 26.74,135.26 26.74,138.86 34.64,146.75 38.42,146.75 40.08,148.41 40.08,155.27 39.97,155.37 39.97,158.42 40.64,159.09 40.64,161.31 40.42,161.53 40.22,161.53 v1(40.01,161.33)
ESATA_PTX_DRX_N3_C: length 115.7
  TOP w0.102: v1(40.8,163.23) 40.55,163.23 40.45,163.33 40.45,165.79 40.68,166.03 C672.1 ; v1(39.21,94.37) 39.21,94.6 UH1.AR13
  IN4 w0.089: v1(39.21,94.37) 39.38,94.37 39.53,94.22 39.53,94.04 39.02,93.53 39.02,91.58 38.99,91.55 38.99,91.53
  IN4 w0.117: 38.99,91.53 38.99,90.96 38.64,90.61 34.2,90.61 33.52,89.93 25.93,89.93 25.21,90.66 25.21,95.39 24.37,96.22 24.37,97.16 24.01,97.52 22.39,97.52 20.42,99.48 18.19,99.48 17.69,99.99 17.69,101.05 16.15,102.59 16.15,105.53 16.87,106.25 16.87,113.78 18.47,115.38 18.47,115.81 19.09,116.43 19.09,117.32 19.87,118.1 19.87,118.73 21.37,120.23 21.37,121.45 22.87,122.95 22.87,126.06 26.89,130.08 26.89,133.09 27.32,133.52 27.32,134.46 27.71,134.86 27.71,138.45 35.03,145.77 38.81,145.77 41.66,148.63 41.66,159.09 42.54,159.96 42.54,161.45 41.72,162.27 41.06,162.27 40.45,162.88 40.45,163.13 40.55,163.23 v1(40.8,163.23)
ESATA_PTX_DRX_P3_C: length 115.7
  TOP w0.102: 39.53,94.88 39.53,94.72 v1(39.89,94.37) ; v1(40.04,163.23) 40.23,163.42 40.23,165.71 C671.1
  IN4 w0.089: v1(39.89,94.37) 39.71,94.19 39.71,93.97 39.2,93.46 39.2,91.57 39.23,91.54 39.23,91.53
  IN4 w0.117: 39.23,91.53 39.23,90.87 38.74,90.38 34.3,90.38 33.62,89.7 25.84,89.7 24.97,90.57 24.97,95.29 24.14,96.12 24.14,97.06 23.91,97.29 22.29,97.29 20.32,99.25 18.09,99.25 17.45,99.89 17.45,100.95 15.91,102.49 15.91,105.62 16.64,106.35 16.64,113.88 18.24,115.48 18.24,115.91 18.86,116.52 18.86,117.41 19.64,118.19 19.64,118.83 21.13,120.33 21.13,121.55 22.63,123.04 22.63,126.16 26.65,130.18 26.65,133.19 27.08,133.62 27.08,134.56 27.48,134.95 27.48,138.55 34.93,146.01 38.71,146.01 41.43,148.72 41.43,159.19 42.3,160.06 42.3,161.35 41.62,162.03 40.96,162.03 40.21,162.78 40.21,163.06 v1(40.04,163.23)
ESATA_USB_PWR_EN#: length 219.9
  TOP w0.102: v1(70.76,165.06) 70.76,163.24 v2(70.73,163.22) 70.54,163.03 U48.5 U48.4
  IN1 w0.109: v1(70.76,165.06) 71.97,166.27 88.23,166.27 89.44,165.06 93.38,165.06 101.58,173.27 111.36,173.27 114.2,170.42 116.92,170.42 117.84,169.5 120.64,169.5 123.1,167.04 123.1,165.96 126.31,162.75 128.04,162.75 128.82,161.97 134.47,161.97 137.45,158.99 141.03,158.99 146.81,153.21 147.53,153.21 151.23,149.51 151.23,143.29 155.03,139.49 155.03,137.62 159.26,133.39 160.78,133.39 161.08,133.69 165.34,133.69 167.53,131.49 167.53,129.96 170.18,127.31 170.18,122.13 172.37,119.95 172.37,112.07 175.81,108.62 176.66,108.62 186.14,99.14 192.88,99.14 197.77,94.24 197.77,91.43 202.25,86.95 210.96,86.95 212.03,85.88 217.64,85.88 218.14,85.38 218.14,85.05 v1(217.71,84.62)
  IN3 w0.127: v1(217.71,84.62) 217.71,84.59 219.19,83.12 220.73,83.12 220.84,83.22 222,83.22 223.25,84.47 224.93,84.47 v1(225.18,84.72)
  BOTTOM w0.102: v1(217.71,84.62) 217.84,84.62 218.37,85.15 218.37,85.54 218.42,85.58 U46.B44 ; v1(225.18,84.72) 225.14,84.68 RP1.8
EXPCLK_REQ#: length 51.6
  TOP w0.102: JIO1.41 v1(6.23,99) ; v1(29.7,81.34) 29.5,81.54 RH125.1 29.04,82.46 29.04,85.43 v2(29.58,85.97) 29.92,86.31 30.25,86.31 32.19,88.24 32.19,89.54 32.22,89.57 32.22,89.91 32.01,90.12 32.01,90.59 UH1.V3
  IN3 w0.127: v1(6.23,99) 6.23,98.09 4.68,96.55 4.68,90.56 4.56,90.43 4.56,89.44 5.93,88.07 7.39,88.07 13.39,82.08 28.96,82.08 v1(29.7,81.34)
FAN1_PWM: length 146.8
  IN2 w0.127: v1(39.42,128.27) 39.42,131.4 44.95,136.94 45.54,136.94 49.03,140.43 49.64,140.43 54.89,145.69 56.91,145.69 60.11,148.89 61.76,148.89 68.94,156.07 77.53,156.07 78.72,154.88 80.96,154.88 81.95,155.87 88.03,155.87 88.66,155.23 91.69,155.23 93.2,156.74 93.2,158.53 95.54,160.87 97.82,160.87 98.43,161.48 104.44,161.48 104.84,161.08 108.14,161.08 109.48,159.74 109.48,158.15 111.25,156.39 111.25,152.96 109.48,151.19 104.68,151.19 104.07,150.58 104.07,150.12 v1(104.48,149.72)
  IN3 w0.127: v1(39.42,128.27) 37.21,130.47 27.29,130.47 20.91,124.09 18.45,124.09 15.5,127.04 15.5,128.99 14.72,129.77 v1(14.72,129.77)
  IN4 w0.109: v1(108.29,146.77) 108.29,147.08 106.74,148.63 105.57,148.63 v1(104.48,149.72)
  BOTTOM w0.102: R407.2 108.34,146.72 v1(108.29,146.77) ; v1(104.48,149.72) 104,150.2 U51.A24 ; v2(15.22,130.3) 15.09,130.17 15.09,130.15 v1(14.72,129.77) JFAN1.2
FAN1_TACH_FB: length 129.6
  IN2 w0.127: v1(46.22,130.67) 46.22,131.56 47.42,132.75 60.52,132.75 64.25,136.48 66.28,136.48 68.05,138.25 68.94,138.25 69.96,139.28 69.96,140.09 71.26,141.39 74.61,141.39 76.02,142.8 85.66,142.8 86.37,143.51 86.92,143.51 90.33,146.92 90.33,147.4 90.84,147.91 90.84,153.23 93.65,156.04 94.53,156.04 94.81,156.33 94.81,156.92 96.27,158.37 97.99,158.37 99.39,159.76 100.75,159.76 101.45,159.07 101.96,159.07 104.66,156.37 104.66,154.92 105.27,154.31 105.27,153.12 v1(105.77,152.61)
  IN3 w0.127: v1(14.66,129.17) 14.21,129.63 14.21,130.74 14.46,131 14.97,131 19.19,126.78 22.84,126.78 27.16,131.1 42.74,131.1 43.02,131.38 45.51,131.38 v1(46.22,130.67)
  IN4 w0.109: v1(105.77,152.61) 105.52,152.36 105.52,149.18 105.77,148.93 107.9,148.93 v1(108.4,148.42)
  BOTTOM w0.102: U51.B22 105.75,152.49 105.77,152.52 v1(105.77,152.61) ; R408.2 108.63,147.67 108.4,147.9 v1(108.4,148.42) ; JFAN1.3 14.02,128.52 v1(14.66,129.17) 14.74,129.17 v2(15.38,128.53)
FAN2_PWM: length 15.9
  TOP w0.102: v2(170.4,139.71) 170.85,139.27 v1(170.85,139.1)
  TOP w0.254: v1(165.25,131.24) 166.02,132.01 U29.15 ; v1(170.85,139.1) 171.48,139.73 D90.1
  BOTTOM w0.254: v1(170.85,139.1) 170.34,139.61 168.03,139.61 167.17,138.75 167.17,134.12 165.44,132.4 165.44,131.43 v1(165.25,131.24)
FAN2_PWM_D: length 8.7
  TOP w0.102: v1(175.89,142.8) 175.89,142.52 v2(175.4,142.02) 174.91,141.54 174.91,140.37 174.65,140.1 173.25,140.1 D90.2 171.61,138.47 R409.2
  BOTTOM w0.102: JFAN2.2 v1(175.89,142.8)
FAN2_TACH_FB: length 19.5
  TOP w0.254: U29.10 165.95,134.51 v2(165.25,135.2) 164.7,135.75 R405.2 v1(165.41,136.18)
  IN1 w0.254: v1(165.41,136.18) 166.68,137.45 170.91,137.45 173.97,140.51 173.97,142.11 175.9,144.04 v1(175.9,144.05)
  BOTTOM w0.254: JFAN2.3 v1(175.9,144.05)
FB: length 14.3
  TOP w0.102: v2(61.26,25.73) 61.25,25.72 PR543.2
  TOP w0.203: PU500.8 54.34,24.17 v1(54.8,24.17)
  TOP w0.254: PR543.2 PR533.2 PR536.2 v1(63.92,24.5)
  IN3 w0.254: v1(54.8,24.17) 58.33,24.17 59.09,23.4 62.82,23.4 v1(63.92,24.5)
FB_+1.05VSP: length 3.8
  TOP w0.102: PR306.2 23.57,147.31 23.89,146.98 24.1,146.77 v2(24.1,146.71)
  TOP w0.254: v1(22.13,147.99) 22.26,147.86 PR307.2 PR306.2
  BOTTOM w0.254: PU300.4 21.98,147.84 v1(22.13,147.99)
FC_G6: length 26.1
  TOP w0.305: v1(101.12,46.75) JCPU1.G6
  IN1 w0.089: v1(101.12,46.75) 100.66,46.28 93.78,46.28 93.58,46.08 93.58,40.04
  IN1 w0.114: v1(91.98,32.62) 93.58,34.22 93.58,40.04
  BOTTOM w0.102: v1(91.98,32.62) 91.39,32.62 90.98,32.22 RC72.1 RC73.2 ; T90.1 101.15,46.75 v1(101.12,46.75)
FDI_CSYNC: length 93
  TOP w0.089: JCPU1.H29 78.59,47.22 v1(78.12,46.75)
  TOP w0.102: v1(37.67,105.71) 37.51,105.88 UH1.AL39
  IN1 w0.109: v1(73.14,56.91) 71.24,56.91 68.37,59.78 68.37,79.51 68.14,79.74 68.14,83.15 62.21,89.09 62.21,90.07 55.25,97.03 55.25,97.39 54.65,97.98 54.65,99.97 50.29,104.33 44.17,104.33 42.93,105.57 41.77,105.57 41.11,106.23 41.11,106.67 40.8,106.97 40.8,107.17 40.45,107.53 39.81,107.53 39.02,106.74 38.52,106.74 38.26,106.49 38.26,106.3 v1(37.67,105.71)
  BOTTOM w0.102: v1(73.14,56.91) 72.67,56.91 70.01,54.25 v2(70.01,52.55) 70.01,49.06 71.79,47.28 77.59,47.28 v1(78.12,46.75)
FDI_CTX_PRX_N0: length 75.2
  TOP w0.102: v1(36.69,104.34) 36.44,104.09 UH1.AJ35 ; v1(74.12,53.75) JCPU1.P33
  IN1 w0.089: v1(36.69,104.34) 36.92,104.57 37.02,104.57 37.09,104.49 37.09,103.45 38.29,102.25 41.37,102.25 41.62,102 42,102 42.02,101.97 42.05,101.97 ; v1(74.12,53.75) 74.12,54.04 74.03,54.13 73.71,54.13 73.5,54.34 73.5,54.92 73.25,55.16 71.97,55.16 71.96,55.15 71.87,55.15 71.87,55.15 71.85,55.15
  IN1 w0.117: 71.85,55.15 71.02,55.15 67.07,59.09 67.07,78.23 66.4,78.9 66.4,81.93 59.52,88.81 59.52,89.19 54.99,93.72 54.99,94.23 52.89,96.33 52.56,96.33 51.85,97.04 51.85,98.36 48.24,101.97 42.05,101.97
FDI_CTX_PRX_N1: length 76.6
  TOP w0.102: v1(37.67,103.69) 37.27,104.09 UH1.AL35 ; JCPU1.N32 v1(75.12,52.75)
  IN1 w0.089: 74.02,56.14 74.05,56.14 74.07,56.16 74.26,56.16 74.52,55.91 74.52,53.35 74.71,53.16 75.02,53.16 75.12,53.06 v1(75.12,52.75)
  IN1 w0.117: 74.02,56.14 70.97,56.14 67.73,59.37 67.73,78.77 67.17,79.33 67.17,82.26 60.41,89.01 60.41,90.68 54.46,96.64 54.46,96.99 52.99,98.46 52.68,98.46 48.46,102.68 44.01,102.68 42.01,104.67 40.16,104.67 39.38,103.89 37.88,103.89 v1(37.67,103.69)
FDI_CTX_PRX_P0: length 75.3
  TOP w0.102: UH1.AJ36 36.39,104.68 v1(36.69,104.99) ; v1(74.12,54.75) JCPU1.R33
  IN1 w0.089: 71.87,55.37 73.34,55.37 73.71,55 73.71,54.43 73.8,54.34 74.02,54.34 74.12,54.44 v1(74.12,54.75) ; 42.05,102.21 42.02,102.21 42,102.19 41.7,102.19 41.44,102.44 38.37,102.44 37.28,103.53 37.28,104.57 37.1,104.76 36.92,104.76 v1(36.69,104.99)
  IN1 w0.117: 42.05,102.21 48.33,102.21 52.09,98.46 52.09,97.14 52.66,96.56 52.99,96.56 55.22,94.33 55.22,93.82 59.76,89.29 59.76,88.91 66.64,82.02 66.64,79 67.31,78.33 67.31,59.19 71.12,55.38 71.85,55.38 71.87,55.37
FDI_CTX_PRX_P1: length 76.6
  TOP w0.102: UH1.AL36 37.3,104.68 v1(37.67,104.31) ; JCPU1.P32 v1(75.12,53.75)
  IN1 w0.089: v1(75.12,53.75) 75.12,53.43 75.04,53.35 74.79,53.35 74.71,53.43 74.71,55.99 74.34,56.35 74.07,56.35 74.05,56.37 74.02,56.37
  IN1 w0.117: 74.02,56.37 71.07,56.37 67.97,59.47 67.97,78.87 67.4,79.43 67.4,82.35 60.65,89.11 60.65,90.78 54.69,96.73 54.69,97.09 53.09,98.7 52.78,98.7 48.56,102.91 44.1,102.91 42.11,104.91 40.06,104.91 39.28,104.13 37.85,104.13 v1(37.67,104.31)
FDI_INT: length 93.5
  TOP w0.089: v1(78.12,47.75) 78.59,48.22 JCPU1.J29
  TOP w0.102: v1(37.67,106.31) 37.51,106.47 UH1.AL40
  IN1 w0.109: v1(72.13,57.69) 72.07,57.63 71.21,57.63 68.61,60.23 68.61,79.62 68.39,79.84 68.39,83.6 62.7,89.29 62.7,90.27 55.74,97.23 55.74,97.59 55.14,98.18 55.14,100.17 50.96,104.35 50.96,105.65 49.16,107.45 46.74,107.45 46.06,108.14 42.63,108.14 42.5,108.27 39.35,108.27 37.67,106.58 v1(37.67,106.31)
  BOTTOM w0.102: v1(78.12,47.75) 77.63,48.24 77.63,51.09 77.33,51.39 71.27,51.39 70.9,51.76 70.9,54.46 71.75,55.31 72.46,55.31 73.75,56.59 73.75,57.33 73.39,57.69 v1(72.13,57.69)
