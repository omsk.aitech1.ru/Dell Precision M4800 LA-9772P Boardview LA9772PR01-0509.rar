# Allegro board LA9772PR01-0509.brd (continued)
## Nets (continued)
DDR_B_D54: JCPU1.D9 JDIMM3.177 JDIMM4.176
DDR_B_D55: JCPU1.E9 JDIMM3.175 JDIMM4.174
DDR_B_D56: JCPU1.E15 JDIMM3.183 JDIMM4.182
DDR_B_D57: JCPU1.D15 JDIMM3.181 JDIMM4.180
DDR_B_D58: JCPU1.A15 JDIMM3.193 JDIMM4.194
DDR_B_D59: JCPU1.B15 JDIMM3.191 JDIMM4.192
DDR_B_D60: JCPU1.E14 JDIMM3.180 JDIMM4.181
DDR_B_D61: JCPU1.D14 JDIMM3.182 JDIMM4.183
DDR_B_D62: JCPU1.A14 JDIMM3.194 JDIMM4.193
DDR_B_D63: JCPU1.B14 JDIMM3.192 JDIMM4.191
DDR_B_DQS0: JCPU1.AP17 JDIMM3.12 JDIMM4.12
DDR_B_DQS1: JCPU1.AP12 JDIMM3.29 JDIMM4.29
DDR_B_DQS2: JCPU1.AP6 JDIMM3.47 JDIMM4.47
DDR_B_DQS3: JCPU1.AK3 JDIMM3.64 JDIMM4.64
DDR_B_DQS4: JCPU1.M3 JDIMM3.137 JDIMM4.137
DDR_B_DQS5: JCPU1.H8 JDIMM3.154 JDIMM4.154
DDR_B_DQS6: JCPU1.C9 JDIMM3.171 JDIMM4.171
DDR_B_DQS7: JCPU1.C15 JDIMM3.188 JDIMM4.188
DDR_B_DQS#0: JCPU1.AP18 JDIMM3.10 JDIMM4.10
DDR_B_DQS#1: JCPU1.AP11 JDIMM3.27 JDIMM4.27
DDR_B_DQS#2: JCPU1.AP5 JDIMM3.45 JDIMM4.45
DDR_B_DQS#3: JCPU1.AJ3 JDIMM3.62 JDIMM4.62
DDR_B_DQS#4: JCPU1.L3 JDIMM3.135 JDIMM4.135
DDR_B_DQS#5: JCPU1.H9 JDIMM3.152 JDIMM4.152
DDR_B_DQS#6: JCPU1.C8 JDIMM3.169 JDIMM4.169
DDR_B_DQS#7: JCPU1.C14 JDIMM3.186 JDIMM4.186
DDR_B_MA0: JCPU1.R8 JDIMM3.98 JDIMM4.98
DDR_B_MA1: JCPU1.Y5 JDIMM3.97 JDIMM4.97
DDR_B_MA2: JCPU1.Y10 JDIMM3.96 JDIMM4.96
DDR_B_MA3: JCPU1.AA5 JDIMM3.95 JDIMM4.95
DDR_B_MA4: JCPU1.Y7 JDIMM3.92 JDIMM4.92
DDR_B_MA5: JCPU1.AA6 JDIMM3.91 JDIMM4.91
DDR_B_MA6: JCPU1.Y6 JDIMM3.90 JDIMM4.90
DDR_B_MA7: JCPU1.AA7 JDIMM3.86 JDIMM4.86
DDR_B_MA8: JCPU1.Y8 JDIMM3.89 JDIMM4.89
DDR_B_MA9: JCPU1.AA10 JDIMM3.85 JDIMM4.85
DDR_B_MA10: JCPU1.R9 JDIMM3.107 JDIMM4.107
DDR_B_MA11: JCPU1.Y9 JDIMM3.84 JDIMM4.84
DDR_B_MA12: JCPU1.AF7 JDIMM3.83 JDIMM4.83
DDR_B_MA13: JCPU1.P9 JDIMM3.119 JDIMM4.119
DDR_B_MA14: JCPU1.AA8 JDIMM3.80 JDIMM4.80
DDR_B_MA15: JCPU1.AG7 JDIMM3.78 JDIMM4.78
DDR_B_RAS#: JCPU1.R6 JDIMM3.110 JDIMM4.110
DDR_B_WE#: JCPU1.P6 JDIMM3.113 JDIMM4.113
DDR_CKE0_DIMM2: JCPU1.AD9 JDIMM2.73
DDR_CKE1_DIMM2: JCPU1.AC9 JDIMM2.74
DDR_CKE2_DIMM4: JCPU1.AF10 JDIMM4.73
DDR_CKE3_DIMM4: JCPU1.AG10 JDIMM4.74
DDR_CKE4_DIMM1: JCPU1.AD8 JDIMM1.73
DDR_CKE5_DIMM1: JCPU1.AC8 JDIMM1.74
DDR_CKE6_DIMM3: JCPU1.AG9 JDIMM3.73
DDR_CKE7_DIMM3: JCPU1.AF9 JDIMM3.74
DDR_CS0_DIMM2#: JCPU1.M7 JDIMM2.114
DDR_CS1_DIMM2#: JCPU1.L9 JDIMM2.121
DDR_CS2_DIMM4#: JCPU1.P4 JDIMM4.114
DDR_CS3_DIMM4#: JCPU1.R2 JDIMM4.121
DDR_CS4_DIMM1#: JCPU1.M9 JDIMM1.114
DDR_CS5_DIMM1#: JCPU1.M10 JDIMM1.121
DDR_CS6_DIMM3#: JCPU1.P3 JDIMM3.114
DDR_CS7_DIMM3#: JCPU1.P1 JDIMM3.121
DDR_HVREF_RST_PCH: RH170.2 UH1.N8
DDR_XDP_SMBCLK_R1: JXDP1.53 RC127.2
DDR_XDP_SMBDAT_R1: JXDP1.51 RC125.2
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 JDIMM3.202 JDIMM4.202 JMINI2.30 QH4.1 R502.2 R1159.2 RC127.1 RH31.1 U88.4
DDR_XDP_WAN_SMBCLK_R2: JXDP2.53 RH31.2
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 JDIMM3.200 JDIMM4.200 JMINI2.32 QH4.4 R501.2 R1160.2 RC125.1 RH30.1 U88.6
DDR_XDP_WAN_SMBDAT_R2: JXDP2.51 RH30.2
DE_A: R560.2 U637.7
DE_B: R550.2 U637.8
DEVICE_DET#: JODD1.8 R1125.2 U51.B1
DGPU_ALERT#: Q5.1 RP3.5 U46.A42
DGPU_HOLD_RST#: R39.1 R1973.2 RH74.2 U16.1 UH1.A12
DGPU_PEX_RST#: JMXM1.184 Q4.2 R38.2 R1973.1 U16.4
DGPU_PWR_EN: JMXM1.44 QC5.1 RH113.2 RH132.1 U46.B45
DGPU_PWR_EN#: QC5.2 RH328.2 UH1.C12
DGPU_PWROK: JMXM1.42 R14.1 R1977.2 U14.1 U25.1 U27.1 U46.A56 UH1.C14
DGPU_SELECT#: U3.1 U19.39 U46.B14 U630.54
DGPU_THERMTRIP#: Q4.1 R11.2 U51.A2
DH_1.35V: PQ201.4 PU200.17
DH_CHG: PQ704.4 PU700.18
DIMM1_SA0: JDIMM1.197 RD8.1
DIMM1_SA1: JDIMM1.201 RD11.2
DIMM2_SA0: JDIMM2.197 RD19.2
DIMM2_SA1: JDIMM2.201 RD20.2
DIMM3_SA0: JDIMM3.197 RD26.1
DIMM3_SA1: JDIMM3.201 RD27.1
DIMM4_SA0: JDIMM4.197 RD37.2
DIMM4_SA1: JDIMM4.201 RD36.1
DIS_BAT_PROCHOT#: PR1081.1 R760.2
DIS_BAT_PROCHOT#_R: R760.1 U46.B51
DIS_PROCHOT#: PC735.1 PC736.1 PQ706.2 PR716.1 PR735.1 PR740.2 PU703.7
DISP_ON: D64.1 D67.1 D69.1 JEDP1.19 R1138.1
DK_AC_OFF: PR1014.1 PU1001.25
DK_AC_OFF_EN: PR1020.1 PU1001.22
DK_CSS_GC: PR714.1 PU1001.11
DK_PWR_BAR: PR1007.2 PU1001.33
DL_1.35V: PQ202.4 PU200.15
DL_CHG: PQ705.4 PU700.15
DMI_CRX_PTX_N0: JCPU1.D21 UH1.BD21
DMI_CRX_PTX_N1: JCPU1.C21 UH1.BE20
DMI_CRX_PTX_N2: JCPU1.B21 UH1.BD17
DMI_CRX_PTX_N3: JCPU1.A21 UH1.BE18
DMI_CRX_PTX_P0: JCPU1.D20 UH1.BB21
DMI_CRX_PTX_P1: JCPU1.C20 UH1.BC20
DMI_CRX_PTX_P2: JCPU1.B20 UH1.BB17
DMI_CRX_PTX_P3: JCPU1.A20 UH1.BC18
DMI_CTX_PRX_N0: JCPU1.D18 UH1.AW22
DMI_CTX_PRX_N1: JCPU1.C17 UH1.AR20
DMI_CTX_PRX_N2: JCPU1.B17 UH1.AP17
DMI_CTX_PRX_N3: JCPU1.A17 UH1.AV20
DMI_CTX_PRX_P0: JCPU1.D17 UH1.AY22
DMI_CTX_PRX_P1: JCPU1.C18 UH1.AP20
DMI_CTX_PRX_P2: JCPU1.B18 UH1.AR17
DMI_CTX_PRX_P3: JCPU1.A18 UH1.AW20
DMI_RCOMP: RH100.2 UH1.AY17
DMIC0: D22.3 JEDP1.13 JIO1.64
DMIC_CLK: D22.2 JEDP1.11 JIO1.62
DMUX_CEXT: C86.1 U9.1
DOCK_AC_OFF: JDOCK1.2 PD1010.1 PR1031.2
DOCK_AC_OFF_EC: PR1018.1 PR1020.2 U46.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.6 PR715.1
DOCK_DCIN_IS-: JDOCK1.136 PR713.2
DOCK_DET#: D32.2 R755.2 U46.B41
DOCK_DET_R#: D32.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: JIO1.66 U46.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U32.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U32.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U32.20
DOCK_LOM_TRD0+: JDOCK1.104 U32.22
DOCK_LOM_TRD0-: JDOCK1.106 U32.23
DOCK_LOM_TRD1+: JDOCK1.110 U32.26
DOCK_LOM_TRD1-: JDOCK1.112 U32.27
DOCK_LOM_TRD2+: JDOCK1.122 U32.31
DOCK_LOM_TRD2-: JDOCK1.124 U32.32
DOCK_LOM_TRD3+: JDOCK1.128 U32.35
DOCK_LOM_TRD3-: JDOCK1.130 U32.36
DOCK_MIC_DET: JIO1.68 U46.B8
DOCK_POR_RST#: C737.1 JDOCK1.140 RP7.7 U51.A21
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: JDOCK1.139 R825.2
DOCK_PWR_SW#: C734.1 R819.2 R825.1 U10.1 U51.A63
DOCK_SMB_ALERT#: JDOCK1.133 PQ1.3 R763.2 U46.A51
DOCK_SMB_CLK: JDOCK1.127 R841.2 U51.B4
DOCK_SMB_DAT: JDOCK1.129 R838.2 U51.A3
DOCKED: Q326.2 U32.13 U46.A38
DOCKED#: Q326.1 R518.2 U9.45
DP1_MUX_REXT: R96.2 U629.34
DP_A_MXM_AUX_Q: Q339.3 Q340.2 Q340.5 R2193.2
DP_CFG0: R61.2 R64.2 U9.44
DP_CFG1: R72.2 R73.2 U9.29
DP_MB_P14: JDP1.14 R801.2
DP_RP_CEXT: C87.1 U22.2
DP_RP_CFG0: R76.2 R77.1 U22.5
DP_RP_CFG1: R78.2 R79.1 U22.40
DP_RP_PEQ: R80.2 R81.1 U22.4
DP_RP_REXT: R75.2 U22.7
DPC_CA_DET: C1174.1 D88.2 JDOCK1.6 Q110.2 R492.2 U20.1 U20.4
DPC_CA_DET#: Q110.5 Q110.6 R1532.2 U20.10 U20.13
DPC_DOCK_AUX: C387.1 U20.2
DPC_DOCK_AUX#: C388.1 U20.5
DPC_DOCK_LANE_C_N0: C438.1 R2173.2
DPC_DOCK_LANE_C_N1: C440.1 R2175.2
DPC_DOCK_LANE_C_N2: C442.1 R2177.2
DPC_DOCK_LANE_C_N3: C444.1 R2179.2
DPC_DOCK_LANE_C_P0: C431.1 R2172.2
DPC_DOCK_LANE_C_P1: C439.1 R2174.2
DPC_DOCK_LANE_C_P2: C441.1 R2176.2
DPC_DOCK_LANE_C_P3: C443.1 R2178.2
DPC_DOCK_LANE_N0_R: JDOCK1.12 R2173.1
DPC_DOCK_LANE_N1_R: JDOCK1.18 R2175.1
DPC_DOCK_LANE_N2_R: JDOCK1.24 R2177.1
DPC_DOCK_LANE_N3_R: JDOCK1.30 R2179.1
DPC_DOCK_LANE_P0_R: JDOCK1.10 R2172.1
DPC_DOCK_LANE_P1_R: JDOCK1.16 R2174.1
DPC_DOCK_LANE_P2_R: JDOCK1.22 R2176.1
DPC_DOCK_LANE_P3_R: JDOCK1.28 R2178.1
DPC_DOCK_SW_AUX: JDOCK1.34 Q113.1 U20.3 U20.11
DPC_DOCK_SW_AUX#: JDOCK1.36 Q113.4 U20.6 U20.8
DPC_GPU_HPD: C696.1 D18.2 JDOCK1.40 R2160.1 U14.2
DPC_GPU_HPD_GATE: JMXM1.302 U14.4
DPD_CA_DET: C1332.1 JDOCK1.5 Q336.2 R491.2 U9.42
DPD_CPU_LANE_N0: C516.1 JCPU1.P29
DPD_CPU_LANE_N0_C: C516.2 U629.12
DPD_CPU_LANE_N1: C518.1 JCPU1.N28
DPD_CPU_LANE_N1_C: C518.2 U629.15
DPD_CPU_LANE_N2: C520.1 JCPU1.P31
DPD_CPU_LANE_N2_C: C520.2 U629.17
DPD_CPU_LANE_N3: C522.1 JCPU1.N30
DPD_CPU_LANE_N3_C: C522.2 U629.20
DPD_CPU_LANE_P0: C515.1 JCPU1.R29
DPD_CPU_LANE_P0_C: C515.2 U629.11
DPD_CPU_LANE_P1: C517.1 JCPU1.P28
DPD_CPU_LANE_P1_C: C517.2 U629.14
DPD_CPU_LANE_P2: C519.1 JCPU1.R31
DPD_CPU_LANE_P2_C: C519.2 U629.16
DPD_CPU_LANE_P3: C521.1 JCPU1.P30
DPD_CPU_LANE_P3_C: C521.2 U629.19
DPD_DOCK_AUX: JDOCK1.33 Q337.1 U9.55
DPD_DOCK_AUX#: JDOCK1.35 Q337.4 U9.54
DPD_DOCK_AUX_Q: Q335.2 Q335.5 Q336.3 Q337.2 Q337.5 R2153.2
DPD_DOCK_LANE_N0: C367.1 R2165.1
DPD_DOCK_LANE_N0_R: JDOCK1.11 R2165.2
DPD_DOCK_LANE_N1: C369.1 R2167.1
DPD_DOCK_LANE_N1_R: JDOCK1.17 R2167.2
DPD_DOCK_LANE_N2: C425.1 R2169.1
DPD_DOCK_LANE_N2_R: JDOCK1.23 R2169.2
DPD_DOCK_LANE_N3: C427.1 R2171.1
DPD_DOCK_LANE_N3_R: JDOCK1.29 R2171.2
DPD_DOCK_LANE_P0: C366.1 R2164.1
DPD_DOCK_LANE_P0_R: JDOCK1.9 R2164.2
DPD_DOCK_LANE_P1: C368.1 R2166.1
DPD_DOCK_LANE_P1_R: JDOCK1.15 R2166.2
DPD_DOCK_LANE_P2: C424.1 R2168.1
DPD_DOCK_LANE_P2_R: JDOCK1.21 R2168.2
DPD_DOCK_LANE_P3: C426.1 R2170.1
DPD_DOCK_LANE_P3_R: JDOCK1.27 R2170.2
DPD_GPU_HPD: C695.1 JDOCK1.39 R1000.1 U9.32
DPD_GPU_LANE_N0: C367.2 U9.39
DPD_GPU_LANE_N1: C369.2 U9.36
DPD_GPU_LANE_N2: C425.2 U9.33
DPD_GPU_LANE_N3: C427.2 U9.30
DPD_GPU_LANE_P0: C366.2 U9.40
DPD_GPU_LANE_P1: C368.2 U9.37
DPD_GPU_LANE_P2: C424.2 U9.34
DPD_GPU_LANE_P3: C426.2 U9.31
DPD_PCH_HPD: U629.13 UH1.H39
DSCHRG_MOSFET_GC: PR1004.2 PU1001.29
DSWODVREN: RH67.1 RH81.2 UH1.C8
DYN_TUR_CURRNT_SET#: PQ707.5 R1980.2 U51.A35
DYN_TURB_SYS_PWR_ALRT#: T139.1(TP-1) U46.A46
EC5048_TX: JDEG2.2 JMINI3.17 R849.2 U46.B2
EC_32KHZ_ECE5048: U46.B35 U51.B62
EC_WAKE#: R563.1 RH216.1 U51.B23 UH1.R11
EDID_SELECT#: U19.1 U46.B61
EDP_COMP: JCPU1.E24 RC1.2
EDP_HPD#: JCPU1.P27 QC6.1 RC65.1
EDP_IN1_AEQ#: R140.1 U630.59
EDP_IN1_PEQ: R127.1 R137.1 U630.52
EDP_IN2_AEQ#: R142.1 U630.58
EDP_IN2_PEQ: R133.1 R138.1 U630.51
EDP_MUX_CEXT: C98.1 U630.47
EDP_MUX_PC0: R100.1 R136.1 U630.38
EDP_MUX_PC1: R109.1 R141.1 U630.55
EDP_MUX_PI0: R139.1 R143.1 U630.56
EDP_MUX_REXT: R101.2 U630.34
EN_1.5VSP: PC406.1 PR403.2 PR404.1 PR406.2 PU400.5
EN_+1.05VSP: PC307.1 PR303.2 PR315.1 PU300.3
EN_DK_PWRBAR: PR1027.1 PR1028.1 PU1001.17
EN_DOCK_PWR_BAR: PR1027.2 U46.B37
EN_I2S_NB_CODEC#: JIO1.60 U46.B36
EN_INVPWR: Q22.2 RP7.6 U51.A25
EN_LCDPWR: D6.1 D53.1 R431.1 U62.3
ENVDD_PCH: D53.2 RH118.2 U46.B38 UH1.G36
EQ_A: R551.1 U637.19
EQ_B: R564.1 U637.18
ERC1: PC1007.1 PU1001.3
ERC2: PC1009.1 PU1001.13
ERC3: PC1008.1 PU1001.12
ESATA_PRX_DTX_N3_C: C673.1 UH1.BC12
ESATA_PRX_DTX_P3_C: C674.1 UH1.BE12
ESATA_PTX_DRX_N3_C: C672.1 UH1.AR13
ESATA_PTX_DRX_P3_C: C671.1 UH1.AT13
ESATA_USB_PWR_EN#: RP1.8 U46.B44 U48.4 U48.5
EXPCLK_REQ#: JIO1.41 RH125.1 UH1.V3
FAN1_PWM: JFAN1.2 R407.2 U51.A24
FAN1_TACH_FB: JFAN1.3 R408.2 U51.B22
FAN2_PWM: D90.1 U29.15
FAN2_PWM_D: D90.2 JFAN2.2 R409.2
FAN2_TACH_FB: JFAN2.3 R405.2 U29.10
FB: PR533.2 PR536.2 PR543.2 PU500.8
FB_+1.05VSP: PR306.2 PR307.2 PU300.4
FC_G6: JCPU1.G6 RC72.1 RC73.2 T90.1(TP-1)
FDI_CSYNC: JCPU1.H29 UH1.AL39
FDI_CTX_PRX_N0: JCPU1.P33 UH1.AJ35
FDI_CTX_PRX_N1: JCPU1.N32 UH1.AL35
FDI_CTX_PRX_P0: JCPU1.R33 UH1.AJ36
FDI_CTX_PRX_P1: JCPU1.P32 UH1.AL36
FDI_INT: JCPU1.J29 UH1.AL40
FDI_RCOMP: RH99.2 UH1.AR44
FFS_INT2: Q29.2 R504.2 U88.9 UH1.AN4
FFS_INT2_Q: JSATA1.18 Q29.3
FFS_PCH_INT: RH106.1 UH1.M15
FWP#: R872.2 U51.B65
GFX_CLK_REQ#: QH3.1 RH128.1 UH1.AF6
GPIO103: T138.1(TP-1) U51.B37
GPIO_PSID_SELECT: PU1.6 U46.A6
GPIOL5: T135.1(TP-1) U46.B1
GPU_PWR_LEVEL: R782.1 U17.2 U46.A52
GPU_SMBCLK: Q295.3 R822.2 U51.A7
GPU_SMBCLK_R: JMXM1.70 Q295.4 R1.2
GPU_SMBDAT: Q295.6 R829.2 U51.B7
GPU_SMBDAT_R: JMXM1.68 Q295.1 R2.2
GREEN_CRT: C23.1 L2.1 R54.1 U19.32
GREEN_CRT_L: JCRT1.2 L2.2
GREEN_DOCK: JDOCK1.59 U19.23
H_CATERR#: JCPU1.AN32 RC128.2
H_CPU_RSVD: JCPU1.G26 RC59.1
H_CPU_SVIDALRT#: JCPU1.AM28 RC61.1
H_CPU_TESTLO: JCPU1.W34 RC45.1
H_CPUPWRGD: JCPU1.AL34 RC5.1 RC130.1 UH1.AV3
H_CPUPWRGD_XDP: JXDP1.39 RC5.2
H_PM_SYNC: JCPU1.AT28 T129.1(TP-1) UH1.AY3
H_PROCHOT#: PC510.1 PQ1080.3 PQ1080.6 PR524.1 PR739.2 RC44.2 RC57.1 U51.A46
H_PROCHOT#_R: JCPU1.AM30 RC57.2
H_THERMTRIP#: JCPU1.AM35 Q28.3 RC126.2
HDD1_DET#: JSATA1.12 RH11.1 RH36.1 UH1.AT1
HDD_FALL_INT: R503.2 RH106.2 U88.11
HDMI_CEC: JHDMI1.13 R1165.1
HDMI_HPD_SINK: R1128.2 R1164.1 U9.17
HDMI_HPD_SINK_R: JHDMI1.19 R1164.2
HDMI_SCL_SINK: JHDMI1.15 R461.2 U9.48
HDMI_SDA_SINK: JHDMI1.16 R460.2 U9.47
HOST_DEBUG_RX: R855.2 U51.B46
HOST_DEBUG_TX: C595.1 JDEG2.3 JMINI3.16 R848.2 U51.B44
HSYNC: RH94.2 UH1.N42
HSYNC_BUF: L4.1 U19.37
HSYNC_DOCK: JDOCK1.65 U19.28
HSYNC_L: JCRT1.13 L4.2
HW_GPS_DISABLE2#: JMINI2.51 R798.2 U46.B34
IMON: PC509.2 PR521.1 PU500.4
IMVP_PWRGD: PR519.1 PR522.1 U46.A62
IMVP_VR_ON: PR513.1 U46.B66
IN1_AEQ#: R117.1 U629.59
IN1_PEQ: R119.1 R121.1 U629.52
IN2_AEQ#: R118.1 U629.58
IN2_PEQ: R120.1 R122.1 U629.51
INTRUDER#: RH43.2 UH1.A8
IRQ_SERIRQ: RH168.2 U39.27 U46.B21 U51.A28 UH1.AL11
ISEN1: PC539.2 PR553.2 PR556.1 PR557.1 PU500.12
ISEN2: PC541.2 PR539.2 PR546.1 PR547.1 PU500.11
ISEN3: PC543.2 PR510.1 PR516.2 PR518.2 PU500.10
IST_TRIGGER: JCPU1.AL26 T163.1(TP-1)
ISUMN: PC528.1 PC539.1 PC541.1 PC543.1 PC547.1 PH501.1 PR512.1 PR537.2 PR544.2 PR545.1 PR548.1 PR550.1 PR555.2
ISUMP: PC528.2 PC532.2 PC538.2 PR511.1 PR535.1 PR550.2 PR551.2 PR552.1 PR558.2 PU500.15
IVR_ERROR: JCPU1.AR32 T162.1(TP-1)
JETWAY_14M: RH161.2 UH1.F39
JETWAY_CLK14M: CH80.1 RH161.1 U39.13
JTAG_CLK: JDEG2.7 RP9.3 U51.B56
JTAG_RST#: C735.1 JTAG1.1 R1981.2 U51.A57
JTAG_TDI: JDEG2.9 RP9.1 U51.A51
JTAG_TDO: JDEG2.6 RP9.4 U51.B55
JTAG_TMS: JDEG2.8 RP9.2 U51.A53
KB_DET#: JKB1.1 JKB1.2 RH212.1 UH1.U12
LAN_ACTLED_YEL#: Q325.1 U32.17
LAN_ACTLED_YEL#_Q: Q325.6 R1171.1
LAN_DISABLE#_R: R549.2 R555.2 U31.3 U46.B47
LAN_SMBCLK: RH174.2 U31.28 UH1.U8
LAN_SMBDATA: RH175.2 U31.31 UH1.R7
LAN_TEST_EN: R561.1 U31.30
LAN_TX0+: L70.1 U31.13
LAN_TX0+R: L70.2 U32.12
LAN_TX0-: L69.1 U31.14
LAN_TX0-R: L69.2 U32.11
LAN_TX1+: L68.1 U31.17
LAN_TX1+R: L68.2 U32.10
LAN_TX1-: L67.1 U31.18
LAN_TX1-R: L67.2 U32.9
LAN_TX2+: L66.1 U31.20
LAN_TX2+R: L66.2 U32.7
LAN_TX2-: L65.1 U31.21
LAN_TX2-R: L65.2 U32.6
LAN_TX3+: L64.1 U31.23
LAN_TX3+R: L64.2 U32.3
LAN_TX3-: L63.1 U31.24
LAN_TX3-R: L63.2 U32.2
LAN_WAKE#: R556.1 U51.B27
LAN_WAKE#_R: R556.2 R563.2 U31.2
LANCLK_REQ#: RH20.1 RH140.1 U31.48 UH1.AF1
LAT_ON_SW#: R870.2 U51.B63
LCD_CBL_DET#: JEDP1.20 RH77.2 UH1.G17
LCD_EDP_AUX: C371.1 R337.2 U630.32
LCD_EDP_AUX#: C373.1 R340.2 U630.31
LCD_EDP_AUX#_C: C373.2 JEDP1.29
LCD_EDP_AUX_C: C371.2 JEDP1.28
LCD_EDP_HPD: JEDP1.25 R103.2 R223.2 U630.44
LCD_EDP_LANE_N0: C380.1 U630.45
LCD_EDP_LANE_N0_C: C380.2 JEDP1.38
LCD_EDP_LANE_N1: C378.1 U630.42
LCD_EDP_LANE_N1_C: C378.2 JEDP1.36
LCD_EDP_LANE_N2: C376.1 U630.39
LCD_EDP_LANE_N2_C: C376.2 JEDP1.34
LCD_EDP_LANE_N3: C374.1 U630.36
LCD_EDP_LANE_N3_C: C374.2 JEDP1.32
LCD_EDP_LANE_P0: C379.1 U630.46
LCD_EDP_LANE_P0_C: C379.2 JEDP1.39
LCD_EDP_LANE_P1: C377.1 U630.43
LCD_EDP_LANE_P1_C: C377.2 JEDP1.37
LCD_EDP_LANE_P2: C375.1 U630.40
LCD_EDP_LANE_P2_C: C375.2 JEDP1.35
LCD_EDP_LANE_P3: C372.1 U630.37
LCD_EDP_LANE_P3_C: C372.2 JEDP1.33
LCD_SMBCLK: Q6.6 R839.2 U51.B5
LCD_SMBCLK_Q: JEDP1.26 Q6.1
LCD_SMBDAT: Q6.3 R840.2 U51.A4
LCD_SMBDAT_Q: JEDP1.27 Q6.4
LCD_TST: JEDP1.24 RP8.2 U46.A36
LCD_VCC_TEST_EN: D6.2 U46.A40
LED_10_GRN#: Q327.3 U32.41
LED_10_GRN#_Q: Q327.1 R1170.1
LED_100_ORG#: Q325.4 U32.18
LED_100_ORG#_Q: Q325.3 R1167.1
LED_SATA_DIAG_OUT#: D62.1 U46.A10
LED_WWAN_OUT#: JMINI2.42 Q77.3 R719.1
LG_3V: PC107.1 PQ103.4 PU101.11
LG_5V: PQ104.4 PU101.15
LG_+1.05VSP: PQ303.4 PU300.6
LGATE1: PQ504.4 PU500.21
LGATE2: PQ502.4 PU500.24
LGATE3: PQ500.4 PU501.5
LID_CL#: JIO1.75 R807.1 U58.2
LID_CL_SIO#: C716.1 R805.2 R807.2 U46.B54
LOM_ACTLED_YEL#: U31.26 U32.15
LOM_SPD10LED_GRN#: U15.2 U31.25 U32.42
LOM_SPD100LED_ORG#: U15.1 U31.27 U32.16
LPC_LAD0: JMINI4.16 U39.26 U46.A27 U51.A30 UH1.A20
LPC_LAD1: JMINI4.14 U39.23 U46.A26 U51.B32 UH1.C20
LPC_LAD2: JMINI4.12 U39.20 U46.B26 U51.A31 UH1.A18
LPC_LAD3: JMINI4.10 U39.17 U46.B25 U51.B33 UH1.C18
LPC_LDRQ0#: T136.1(TP-1) U46.A23
LPC_LDRQ1#: U46.A22 UH1.G20
LPC_LFRAME#: JMINI4.8 U39.22 U46.A21 U51.B31 UH1.B21
LX_CHG: PC734.1 PL701.1 PQ704.1 PQ704.2 PQ704.3 PQ705.5 PR724.1 PU700.19
M_CLK_DDR0: JCPU1.V4 JDIMM2.101
M_CLK_DDR1: JCPU1.V3 JDIMM2.102
M_CLK_DDR2: JCPU1.AA4 JDIMM4.101
M_CLK_DDR3: JCPU1.AA3 JDIMM4.102
M_CLK_DDR4: JCPU1.V2 JDIMM1.101
M_CLK_DDR5: JCPU1.V1 JDIMM1.102
M_CLK_DDR6: JCPU1.AA2 JDIMM3.101
M_CLK_DDR7: JCPU1.AA1 JDIMM3.102
M_CLK_DDR#0: JCPU1.U4 JDIMM2.103
M_CLK_DDR#1: JCPU1.U3 JDIMM2.104
M_CLK_DDR#2: JCPU1.Y4 JDIMM4.103
M_CLK_DDR#3: JCPU1.Y3 JDIMM4.104
M_CLK_DDR#4: JCPU1.U2 JDIMM1.103
M_CLK_DDR#5: JCPU1.U1 JDIMM1.104
M_CLK_DDR#6: JCPU1.Y2 JDIMM3.103
M_CLK_DDR#7: JCPU1.Y1 JDIMM3.104
M_ID2#: C15.1 JCRT1.4
M_ODT0: JCPU1.M8 JDIMM2.116
M_ODT1: JCPU1.L7 JDIMM2.120
M_ODT2: JCPU1.R4 JDIMM4.116
M_ODT3: JCPU1.R3 JDIMM4.120
M_ODT4: JCPU1.L8 JDIMM1.116
M_ODT5: JCPU1.L10 JDIMM1.120
M_ODT6: JCPU1.R1 JDIMM3.116
M_ODT7: JCPU1.P2 JDIMM3.120
M_REXT: R757.1 U637.9
MASK_BASE_LEDS#: JIO1.108 Q74.2 Q78.2 Q318.2 Q344.5 U58.4
MASK_SATA_LED#: Q74.5 U46.B9
MB_DP_CA_DET: C1341.1 JDP1.13 Q339.2 R62.2 U22.10
MB_DP_HPD: JDP1.18 U22.11
MB_DP_RP_AUX: JDP1.15 R59.2 U22.28
MB_DP_RP_AUX#: JDP1.17 R56.2 U22.27
MB_DP_RP_C_N0: C304.2 U22.22
MB_DP_RP_C_N1: C308.2 U22.19
MB_DP_RP_C_N2: C309.2 U22.16
MB_DP_RP_C_N3: C302.2 U22.13
MB_DP_RP_C_P0: C307.2 U22.23
MB_DP_RP_C_P1: C295.2 U22.20
MB_DP_RP_C_P2: C306.2 U22.17
MB_DP_RP_C_P3: C303.2 U22.14
MB_DP_RP_N0: C304.1 JDP1.3
MB_DP_RP_N1: C308.1 JDP1.6
MB_DP_RP_N2: C309.1 JDP1.9
MB_DP_RP_N3: C302.1 JDP1.12
MB_DP_RP_P0: C307.1 JDP1.1
MB_DP_RP_P1: C295.1 JDP1.4
MB_DP_RP_P2: C306.1 JDP1.7
MB_DP_RP_P3: C303.1 JDP1.10
MB_DP_RST#: C88.1 R415.2 U22.35
MCARD_MISC_PWREN: R733.1 U46.B53 U56.3
MCARD_PCIE#_SATA: Q322.1 R785.2 U637.17
MCARD_PCIE_SATA#: Q322.2 RH16.1 RH226.1 U46.B3 UH1.AN2
MCARD_WWAN_PWREN: T127.1(TP-1) U46.B42
ME_FWP: RH45.1 U46.A8
ME_SUS_PWR_ACK: RH75.2 RH91.1 U51.A8 UH1.J4
MEC_XTAL1: C743.1 U51.A61 Y6.1
MEC_XTAL2: C741.1 U51.A62 Y6.2
MEM_SMBCLK: QH4.6 RPH5.1 UH1.R10
MEM_SMBDATA: QH4.3 RPH5.2 UH1.U11
MINI1CLK_REQ#: JMINI2.7 RH123.1 UH1.AB1
MINI2CLK_REQ#: JMINI4.7 RH124.1 UH1.AE4
MINI3CLK_REQ#: JMINI3.7 RH254.1 UH1.T3
MOD_MD: JODD1.11 Q81.1 R808.2
MODC_EN: Q81.5 R514.1 U46.B7 U57.3
MODC_EN#: Q81.2 Q81.3 R515.2
MODE: R58.2 R63.2 U9.53
MSATA_PCIE_PIN51: T119.1(TP-1) U46.A57
MSATA_PRX_WANTX_N4_RP: C538.2 U637.12
MSATA_PRX_WANTX_N4_RP_C: C538.1 JMINI2.25
MSATA_PRX_WANTX_P4_RP: C537.2 U637.11
MSATA_PRX_WANTX_P4_RP_C: C537.1 JMINI2.23
MSATA_PTX_WANRX_N4_RP: C539.2 U637.14
MSATA_PTX_WANRX_N4_RP_C: C539.1 JMINI2.31
MSATA_PTX_WANRX_P4_RP: C540.2 U637.15
MSATA_PTX_WANRX_P4_RP_C: C540.1 JMINI2.33
MSCLK: JDEG2.5 JMINI3.19 R847.2 U51.B43
MSDATA: JDEG2.4 JMINI3.14 R706.2 R869.2 U51.A40
MUX_AUX: Q335.1 U9.50 U9.52 U629.32
MUX_AUX#: Q335.4 U9.49 U9.51 U629.31
MUX_CA_DET: Q346.2 R82.1 U9.11 U629.48
MUX_CEXT: C97.2 U629.47
MUX_D0: C505.1 U629.46
MUX_D0#: C506.1 U629.45
MUX_D0#_C: C506.2 U9.4
MUX_D0_C: C505.2 U9.3
MUX_D1: C507.1 U629.43
MUX_D1#: C508.1 U629.42
MUX_D1#_C: C508.2 U9.7
MUX_D1_C: C507.2 U9.6
MUX_D2: C509.1 U629.40
MUX_D2#: C510.1 U629.39
MUX_D2#_C: C510.2 U9.10
MUX_D2_C: C509.2 U9.9
MUX_D3: C511.1 U629.37
MUX_D3#: C512.1 U629.36
MUX_D3#_C: C512.2 U9.13
MUX_D3_C: C511.2 U9.12
MUX_HPD: U9.5 U629.44
MUX_PC0: R98.1 R115.1 U629.38
MUX_PC1: R99.1 R116.1 U629.55
MUX_PI0: R123.1 R124.1 U629.56
MXM_ALERT#: JMXM1.58 Q5.3 R4.2
MXM_BIA_PWM: JMXM1.63 U3.2
MXM_CLK_REQ#: JMXM1.182 R1978.2
MXM_CRT_BLU: JMXM1.200 U19.9
MXM_CRT_DDC_CLK: JMXM1.188 R5.2 U19.5
MXM_CRT_DDC_DAT: JMXM1.186 R3.2 U19.6
MXM_CRT_GRN: JMXM1.198 U19.8
MXM_CRT_HSYNC: JMXM1.192 U19.3
MXM_CRT_RED: JMXM1.196 U19.7
MXM_CRT_VSYNC: JMXM1.190 U19.4
MXM_DP_HDMI_HPD: D7.1 D8.1 D18.1 R17.2 U46.B4
MXM_DPB_AUX: C387.2 JMXM1.300 U20.12
MXM_DPB_AUX#: C388.2 JMXM1.298 U20.9
MXM_DPB_N0: C438.2 JMXM1.274
MXM_DPB_N1: C440.2 JMXM1.280
MXM_DPB_N2: C442.2 JMXM1.286
MXM_DPB_N3: C444.2 JMXM1.292
MXM_DPB_P0: C431.2 JMXM1.276
MXM_DPB_P1: C439.2 JMXM1.282
MXM_DPB_P2: C441.2 JMXM1.288
MXM_DPB_P3: C443.2 JMXM1.294
MXM_DPC_AUX: C531.1 JMXM1.255 R21.2 U629.23
MXM_DPC_AUX#: C532.1 JMXM1.253 R20.2 U629.22
MXM_DPC_AUX#_C: C532.2 U629.27
MXM_DPC_AUX_C: C531.2 U629.28
MXM_DPC_HPD: D7.2 U25.2 U629.3
MXM_DPC_HPD_GATE: JMXM1.262 U25.4
MXM_DPC_N0: C524.1 JMXM1.229
MXM_DPC_N0_C: C524.2 U629.2
MXM_DPC_N1: C526.1 JMXM1.235
MXM_DPC_N1_C: C526.2 U629.5
MXM_DPC_N2: C528.1 JMXM1.241
MXM_DPC_N2_C: C528.2 U629.7
MXM_DPC_N3: C530.1 JMXM1.247
MXM_DPC_N3_C: C530.2 U629.10
MXM_DPC_P0: C523.1 JMXM1.231
MXM_DPC_P0_C: C523.2 U629.1
MXM_DPC_P1: C525.1 JMXM1.237
MXM_DPC_P1_C: C525.2 U629.4
MXM_DPC_P2: C527.1 JMXM1.243
MXM_DPC_P2_C: C527.2 U629.6
MXM_DPC_P3: C529.1 JMXM1.249
MXM_DPC_P3_C: C529.2 U629.9
MXM_EDP_AUX: C566.1 JMXM1.260
MXM_EDP_AUX#: C568.1 JMXM1.258
MXM_EDP_AUX#_C: C568.2 U630.27
MXM_EDP_AUX_C: C566.2 U630.28
MXM_EDP_HPD: JMXM1.264 U630.3
MXM_EDP_LANE_N0: C556.1 JMXM1.234
MXM_EDP_LANE_N0_C: C556.2 U630.2
MXM_EDP_LANE_N1: C559.1 JMXM1.240
MXM_EDP_LANE_N1_C: C559.2 U630.5
MXM_EDP_LANE_N2: C571.1 JMXM1.246
MXM_EDP_LANE_N2_C: C571.2 U630.7
MXM_EDP_LANE_N3: C562.1 JMXM1.252
MXM_EDP_LANE_N3_C: C562.2 U630.10
MXM_EDP_LANE_P0: C557.1 JMXM1.236
MXM_EDP_LANE_P0_C: C557.2 U630.1
MXM_EDP_LANE_P1: C561.1 JMXM1.242
MXM_EDP_LANE_P1_C: C561.2 U630.4
MXM_EDP_LANE_P2: C573.1 JMXM1.248
MXM_EDP_LANE_P2_C: C573.2 U630.6
MXM_EDP_LANE_P3: C564.1 JMXM1.254
MXM_EDP_LANE_P3_C: C564.2 U630.9
MXM_ENVDD: D6.3 JMXM1.59
MXM_MB_DP_AUX: C397.1 JMXM1.309 Q340.1 U22.33
MXM_MB_DP_AUX#: C398.1 JMXM1.307 Q340.4 U22.34
MXM_MB_DP_AUX#_C: C398.2 U22.29
MXM_MB_DP_AUX_C: C397.2 U22.30
MXM_MB_DP_HPD: D8.2 U22.9 U27.2
MXM_MB_DP_HPD_GATE: JMXM1.304 U27.4
MXM_MB_DP_N0: C284.1 JMXM1.283
MXM_MB_DP_N0_C: C284.2 U22.39
MXM_MB_DP_N1: C283.1 JMXM1.289
MXM_MB_DP_N1_C: C283.2 U22.42
MXM_MB_DP_N2: C286.1 JMXM1.295
MXM_MB_DP_N2_C: C286.2 U22.45
MXM_MB_DP_N3: C282.1 JMXM1.301
MXM_MB_DP_N3_C: C282.2 U22.48
MXM_MB_DP_P0: C285.1 JMXM1.285
MXM_MB_DP_P0_C: C285.2 U22.38
MXM_MB_DP_P1: C280.1 JMXM1.291
MXM_MB_DP_P1_C: C280.2 U22.41
MXM_MB_DP_P2: C281.1 JMXM1.297
MXM_MB_DP_P2_C: C281.2 U22.44
MXM_MB_DP_P3: C279.1 JMXM1.303
MXM_MB_DP_P3_C: C279.2 U22.47
MXM_OVERT#: JMXM1.56 Q4.3 R10.2
MXM_PANEL_BKEN: D64.2 JMXM1.61
MXM_PRESENTL#: JMXM1.310 RPH8.8 UH1.G15
MXM_PRESENTR#: JMXM1.38 RPH9.7 UH1.G13
MXM_PWR_LEVEL: JMXM1.54 R37.2 U17.4
MXM_RSVD1: JMXM1.268 R6.2
MXM_RSVD2: JMXM1.270 R1979.2
MXM_SRC_EN#: C774.1 Q186.4 R940.2 R944.1
NB_LAN_TX0+: JLOM1.1 T156.24
NB_LAN_TX0-: JLOM1.2 T156.23
NB_LAN_TX1+: JLOM1.3 T156.20
NB_LAN_TX1-: JLOM1.6 T156.19
NB_LAN_TX2+: JLOM1.4 T156.18
NB_LAN_TX2-: JLOM1.5 T156.17
NB_LAN_TX3+: JLOM1.7 T156.14
NB_LAN_TX3-: JLOM1.8 T156.13
NB_PSID: PJPDC1.2 PL3.2
NB_PSID_TS5A63157: PR8.1 PR9.2 PU1.3
NTC: PH500.1 PR528.1 PU500.6
NUM_LED: JIO1.92 R942.2
NUM_LED#: Q84.3 U46.A2
NVRAM_PWR_EN: R720.1 U43.3 U46.B32
P1_SW: PC545.1 PL502.2 PQ504.5 PQ504.6 PQ504.7 PR552.2 PR553.1
P2_SW: PC523.1 PL501.2 PQ502.5 PQ502.6 PQ502.7 PR535.2 PR539.1
P3_SW: PC507.1 PL500.2 PQ500.5 PQ500.6 PQ500.7 PR510.2 PR511.2
P33ALW: PR1025.1 PU1001.18
P33ALW2: PR1022.2 PU1001.9
P50ALW: PR1012.1 PU1001.27
PANEL_BKEN_EC: D69.2 U46.A35
PANEL_BKEN_PCH: D67.2 UH1.K36
PBA_GPU_SEL#: U46.A15 U629.54
PBAT_PRES#: PD5.1 PR2.2 PR3.7 PU1081.1 U46.B40
PBAT_SMBCLK: PR3.5 RP5.8 U51.A56
PBAT_SMBDAT: PR3.6 RP5.7 U51.B59
PBATT+: PL2.2 PL6.2 PQ1002.1 PQ1002.2 PQ1002.3 PQ1003.1 PQ1003.2 PQ1003.3 PR1008.2
PBATT+_C: PBATT1.1 PBATT1.2 PC4.1 PL2.1 PL6.1
PBATT_IN_SS: PD1002.2 PD1002.3 PQ1003.5 PQ1004.5 PR1003.1 PR1005.1
PCH_ALW_ON: PR23.1 RP7.8 U34.5 U51.A23
PCH_AZ_BITCLK: RH65.2 UH1.B25
PCH_AZ_CODEC_BITCLK: CH9.1 JIO1.36 RH65.1
PCH_AZ_CODEC_RST#: JIO1.40 RH63.1
PCH_AZ_CODEC_SDIN0: JIO1.44 UH1.L22
PCH_AZ_CODEC_SDOUT: JIO1.38 RH59.1
PCH_AZ_CODEC_SYNC: JIO1.42 RH61.1
PCH_AZ_RST#: RH63.2 UH1.C24
PCH_AZ_SDOUT: RH35.2 RH45.2 RH59.2 UH1.A24
PCH_AZ_SYNC: RH61.2 UH1.A22
PCH_BATLOW#: RH112.2 UH1.K7
PCH_CL_CLK1: JMINI4.45 UH1.AF11
PCH_CL_DATA1: JMINI4.47 UH1.AF10
PCH_CL_RST1#: JMINI4.49 UH1.AF7
PCH_CLK_BIASREF: RH165.1 UH1.AN44
PCH_CRT_BLU: RH115.2 U19.19 UH1.T45
PCH_CRT_DDC_CLK: U19.15 UH1.M43
PCH_CRT_DDC_DAT: U19.16 UH1.M45
PCH_CRT_GRN: RH116.2 U19.18 UH1.U44
PCH_CRT_HSYNC: RH94.1 U19.13
PCH_CRT_RED: RH117.2 U19.17 UH1.V45
PCH_CRT_VSYNC: RH95.1 U19.14
PCH_DDPD_AUX: C535.1 UH1.J44
PCH_DDPD_AUX#: C536.1 UH1.J42
PCH_DDPD_AUX#_C: C536.2 U629.29
PCH_DDPD_AUX_C: C535.2 U629.30
PCH_DDPD_CTRLCLK: RH255.2 U629.25 UH1.N40
PCH_DDPD_CTRLDATA: RH256.2 U629.24 UH1.N38
PCH_DPWROK: R802.1 RH79.1 RH131.2 UH1.L13
PCH_GPIO3: RH83.2 UH1.F17
PCH_GPIO06: RPH8.7 UH1.A14
PCH_GPIO13: RH60.2 UH1.C22
PCH_GPIO15: RH211.2 UH1.AB11
PCH_GPIO24: RH213.1 UH1.Y10
PCH_GPIO33: RH40.2 UH1.B17
PCH_GPIO34: RPH10.5 UH1.AN6
PCH_GPIO35: RH25.1 RH205.1 UH1.AP1
PCH_GPIO36: RH12.1 RH228.1 RH230.1 UH1.AT3
PCH_GPIO37: RH14.1 RH37.1 RH62.1 UH1.AK1
PCH_GPIO49: RH19.1 RH225.1 UH1.AK3
PCH_GPIO55: RH76.1 UH1.AL6
PCH_GPIO69: RPH9.6 UH1.D13
PCH_GPIO71: RPH8.5 UH1.H15
PCH_INTVRMEN: RH5.2 UH1.G10
PCH_JTAG_RST: RH32.2 UH1.AB6
PCH_JTAG_RST_R: JXDP2.54 RH32.1
PCH_JTAG_TCK: JXDP2.57 RH47.1 UH1.AB3
PCH_JTAG_TDI: JXDP2.56 RH50.2 RH55.1 UH1.AE2
PCH_JTAG_TDO: JXDP2.52 RH52.2 RH56.1 UH1.AD3
PCH_JTAG_TMS: JXDP2.58 RH48.2 RH54.1 UH1.AD1
PCH_PCIE_RCOMP: RH192.2 UH1.BD29
PCH_PCIE_WAKE#: RH78.2 RH129.2 U51.A44 UH1.K3
PCH_PLTRST#: JIO1.6 JUSH1.15 QH2.2 U16.2 U31.36 UH1.Y11 UH3.1 UH3.2
PCH_PLTRST#_EC: JIO1.8 JMINI2.22 JMINI3.22 JMINI4.17 JMINI4.22 U39.16 U46.B22 U51.B30 UH3.4
PCH_PWRBTN#_XDP: JXDP2.41 RH28.2
PCH_PWRGD#: Q52.1 R410.1 R893.2
PCH_RI#: RH84.2 UH1.N4
PCH_RSMRST#: R892.2 U7.1 U51.B47
PCH_RSMRST#_Q: RH26.1 RH79.2 RH142.2 U7.4 UH1.J2
PCH_RTCRST#: CH7.2 CMOS1.2 JAPS1.9 RH44.2 UH1.D9
PCH_RTCX1: CH4.2 RH39.1 UH1.B5 YH1.1
PCH_RTCX2: CH5.2 RH39.2 UH1.B4 YH1.2
PCH_SATA_MOD_EN#: QH2.3 U51.B36
PCH_SATA_MOD_G_EN#: QH2.1 RH13.1 RH229.1 UH1.AU2
PCH_SMB_ALERT#: RH166.2 UH1.N7
PCH_SPI_CLK: JSPI1.8 RH181.2 UH1.AJ11
PCH_SPI_CS0#: JSPI1.10 RH182.2 UH1.AJ7
PCH_SPI_CS1#: JSPI1.2 RH177.2 UH1.AL7
PCH_SPI_DIN: JSPI1.6 RH179.2 UH1.AH3
PCH_SPI_DO: JSPI1.4 RH178.2 UH1.AH1
PCH_SPI_DO2: JSPI1.12 RH183.2 UH1.AJ4
PCH_SPI_DO3: JSPI1.14 RH184.2 UH1.AJ2
PCH_TD_IREF: RH176.1 UH1.AY43
PCH_THRMTRIP#_R: CH17.1 RH206.2 UH1.AV1
PCH_TPM_EN: R2189.1 RH208.1 RH209.1 UH1.BB4
PCI_5048: RH158.1 UH1.D44
PCI_DOCK: RH162.1 UH1.B42
PCI_LOOPBACKOUT: RH164.1 UH1.A40
PCI_MEC: RH160.1 UH1.E44
PCI_PIRQA#: RPH1.3 UH1.H20
PCI_PIRQB#: RPH1.2 UH1.L20
PCI_PIRQC#: RPH1.4 UH1.K17
PCI_PIRQD#: RPH1.1 UH1.M20
PCI_TPM_TCM: RH155.2 UH1.C40
PCIE_PRX_EXPTX_N7: JIO1.35 UH1.AT40
PCIE_PRX_EXPTX_P7: JIO1.37 UH1.AT39
PCIE_PRX_GLANTX_N2: C459.2 UH1.AT31
PCIE_PRX_GLANTX_N2_C: C459.1 U31.39
PCIE_PRX_GLANTX_P2: C458.2 UH1.AR31
PCIE_PRX_GLANTX_P2_C: C458.1 U31.38
PCIE_PRX_MMITX_N8: JIO1.19 UH1.AN38
PCIE_PRX_MMITX_P8: JIO1.17 UH1.AN39
PCIE_PRX_WLANTX_N3: JMINI4.23 UH1.AW33
PCIE_PRX_WLANTX_P3: JMINI4.25 UH1.AY33
PCIE_PRX_WPANTX_N6: JMINI3.23 UH1.AY38
PCIE_PRX_WPANTX_P6: JMINI3.25 UH1.AW38
PCIE_PTX_EXPRX_N7: JIO1.29 UH1.BE40
PCIE_PTX_EXPRX_P7: JIO1.31 UH1.BC40
PCIE_PTX_GLANRX_N2: C461.1 UH1.BD33
PCIE_PTX_GLANRX_N2_C: C461.2 U31.42
PCIE_PTX_GLANRX_P2: C460.1 UH1.BB33
PCIE_PTX_GLANRX_P2_C: C460.2 U31.41
PCIE_PTX_MMIRX_N8: JIO1.13 UH1.BD42
PCIE_PTX_MMIRX_P8: JIO1.11 UH1.BD41
PCIE_PTX_WLANRX_N3: C596.1 UH1.BE34
PCIE_PTX_WLANRX_N3_C: C596.2 JMINI4.31
PCIE_PTX_WLANRX_P3: C598.1 UH1.BC34
PCIE_PTX_WLANRX_P3_C: C598.2 JMINI4.33
PCIE_PTX_WPANRX_N6: C636.1 UH1.BC38
PCIE_PTX_WPANRX_N6_C: C636.2 JMINI3.31
PCIE_PTX_WPANRX_P6: C626.1 UH1.BE38
PCIE_PTX_WPANRX_P6_C: C626.2 JMINI3.33
PCIE_SATA_PRX_WANTX_N4: C534.1 UH1.BD13
PCIE_SATA_PRX_WANTX_N4_C: C534.2 U637.4
PCIE_SATA_PRX_WANTX_P4: C533.1 UH1.BB13
PCIE_SATA_PRX_WANTX_P4_C: C533.2 U637.5
PCIE_SATA_PTX_WANRX_N4: C513.1 UH1.AV15
PCIE_SATA_PTX_WANRX_N4_C: C513.2 U637.2
PCIE_SATA_PTX_WANRX_P4: C514.1 UH1.AW15
PCIE_SATA_PTX_WANRX_P4_C: C514.2 U637.1
PCIE_WAKE#: JIO1.83 JMINI2.1 JMINI3.1 JMINI4.1 R759.2 R1972.2 U51.B38
PCLK_80H: JMINI4.19 RH159.1
PECI_EC: JCPU1.AR27 R952.2
PECI_EC_R: R952.1 U51.A48
PEG_B_CLKRQ#: RH130.2 UH1.U4
PEG_COMP: JCPU1.E23 RC2.2
PEG_CRX_GTX_C_N0: CC16.1 JMXM1.177
PEG_CRX_GTX_C_N1: CC15.1 JMXM1.171
PEG_CRX_GTX_C_N2: CC14.1 JMXM1.165
PEG_CRX_GTX_C_N3: CC13.1 JMXM1.157
PEG_CRX_GTX_C_N4: CC12.1 JMXM1.151
PEG_CRX_GTX_C_N5: CC11.1 JMXM1.145
PEG_CRX_GTX_C_N6: CC10.1 JMXM1.139
PEG_CRX_GTX_C_N7: CC9.1 JMXM1.133
PEG_CRX_GTX_C_N8: CC8.1 JMXM1.127
PEG_CRX_GTX_C_N9: CC7.1 JMXM1.121
PEG_CRX_GTX_C_N10: CC6.1 JMXM1.115
PEG_CRX_GTX_C_N11: CC5.1 JMXM1.109
PEG_CRX_GTX_C_N12: CC4.1 JMXM1.103
PEG_CRX_GTX_C_N13: CC3.1 JMXM1.97
PEG_CRX_GTX_C_N14: CC2.1 JMXM1.91
PEG_CRX_GTX_C_N15: CC1.1 JMXM1.85
PEG_CRX_GTX_C_P0: CC32.1 JMXM1.179
PEG_CRX_GTX_C_P1: CC31.1 JMXM1.173
PEG_CRX_GTX_C_P2: CC30.1 JMXM1.167
PEG_CRX_GTX_C_P3: CC29.1 JMXM1.159
PEG_CRX_GTX_C_P4: CC28.1 JMXM1.153
PEG_CRX_GTX_C_P5: CC27.1 JMXM1.147
PEG_CRX_GTX_C_P6: CC26.1 JMXM1.141
PEG_CRX_GTX_C_P7: CC25.1 JMXM1.135
PEG_CRX_GTX_C_P8: CC24.1 JMXM1.129
PEG_CRX_GTX_C_P9: CC23.1 JMXM1.123
PEG_CRX_GTX_C_P10: CC22.1 JMXM1.117
PEG_CRX_GTX_C_P11: CC21.1 JMXM1.111
PEG_CRX_GTX_C_P12: CC20.1 JMXM1.105
PEG_CRX_GTX_C_P13: CC19.1 JMXM1.99
PEG_CRX_GTX_C_P14: CC18.1 JMXM1.93
PEG_CRX_GTX_C_P15: CC17.1 JMXM1.87
PEG_CRX_GTX_N0: CC16.2 JCPU1.E32
PEG_CRX_GTX_N1: CC15.2 JCPU1.E33
PEG_CRX_GTX_N2: CC14.2 JCPU1.D34
PEG_CRX_GTX_N3: CC13.2 JCPU1.E35
PEG_CRX_GTX_N4: CC12.2 JCPU1.D30
PEG_CRX_GTX_N5: CC11.2 JCPU1.E31
PEG_CRX_GTX_N6: CC10.2 JCPU1.D28
PEG_CRX_GTX_N7: CC9.2 JCPU1.E29
PEG_CRX_GTX_N8: CC8.2 JCPU1.L34
PEG_CRX_GTX_N9: CC7.2 JCPU1.M35
PEG_CRX_GTX_N10: CC6.2 JCPU1.L32
PEG_CRX_GTX_N11: CC5.2 JCPU1.M33
PEG_CRX_GTX_N12: CC4.2 JCPU1.L30
PEG_CRX_GTX_N13: CC3.2 JCPU1.M31
PEG_CRX_GTX_N14: CC2.2 JCPU1.K28
PEG_CRX_GTX_N15: CC1.2 JCPU1.M29
PEG_CRX_GTX_P0: CC32.2 JCPU1.D32
PEG_CRX_GTX_P1: CC31.2 JCPU1.F33
PEG_CRX_GTX_P2: CC30.2 JCPU1.E34
PEG_CRX_GTX_P3: CC29.2 JCPU1.F35
PEG_CRX_GTX_P4: CC28.2 JCPU1.E30
PEG_CRX_GTX_P5: CC27.2 JCPU1.F31
PEG_CRX_GTX_P6: CC26.2 JCPU1.E28
PEG_CRX_GTX_P7: CC25.2 JCPU1.F29
PEG_CRX_GTX_P8: CC24.2 JCPU1.K34
PEG_CRX_GTX_P9: CC23.2 JCPU1.L35
PEG_CRX_GTX_P10: CC22.2 JCPU1.K32
PEG_CRX_GTX_P11: CC21.2 JCPU1.L33
PEG_CRX_GTX_P12: CC20.2 JCPU1.K30
PEG_CRX_GTX_P13: CC19.2 JCPU1.L31
PEG_CRX_GTX_P14: CC18.2 JCPU1.L28
PEG_CRX_GTX_P15: CC17.2 JCPU1.L29
PEG_CTX_GRX_C_N0: CC50.2 JCPU1.A24
PEG_CTX_GRX_C_N1: CC77.2 JCPU1.B25
PEG_CTX_GRX_C_N2: CC62.2 JCPU1.A26
PEG_CTX_GRX_C_N3: CC49.2 JCPU1.B27
PEG_CTX_GRX_C_N4: CC76.2 JCPU1.A28
PEG_CTX_GRX_C_N5: CC59.2 JCPU1.B29
PEG_CTX_GRX_C_N6: CC48.2 JCPU1.A30
PEG_CTX_GRX_C_N7: CC75.2 JCPU1.B31
PEG_CTX_GRX_C_N8: CC56.2 JCPU1.B32
PEG_CTX_GRX_C_N9: CC47.2 JCPU1.C33
PEG_CTX_GRX_C_N10: CC74.2 JCPU1.G30
PEG_CTX_GRX_C_N11: CC46.2 JCPU1.J31
PEG_CTX_GRX_C_N12: CC73.2 JCPU1.H32
PEG_CTX_GRX_C_N13: CC53.2 JCPU1.J33
PEG_CTX_GRX_C_N14: CC45.2 JCPU1.H34
PEG_CTX_GRX_C_N15: CC44.2 JCPU1.H35
PEG_CTX_GRX_C_P0: CC64.2 JCPU1.B24
PEG_CTX_GRX_C_P1: CC63.2 JCPU1.C25
PEG_CTX_GRX_C_P2: CC72.2 JCPU1.B26
PEG_CTX_GRX_C_P3: CC61.2 JCPU1.C27
PEG_CTX_GRX_C_P4: CC60.2 JCPU1.B28
PEG_CTX_GRX_C_P5: CC71.2 JCPU1.C29
PEG_CTX_GRX_C_P6: CC58.2 JCPU1.B30
PEG_CTX_GRX_C_P7: CC57.2 JCPU1.C31
PEG_CTX_GRX_C_P8: CC70.2 JCPU1.A32
PEG_CTX_GRX_C_P9: CC55.2 JCPU1.B33
PEG_CTX_GRX_C_P10: CC54.2 JCPU1.H30
PEG_CTX_GRX_C_P11: CC69.2 JCPU1.H31
PEG_CTX_GRX_C_P12: CC52.2 JCPU1.G32
PEG_CTX_GRX_C_P13: CC51.2 JCPU1.H33
PEG_CTX_GRX_C_P14: CC68.2 JCPU1.G34
PEG_CTX_GRX_C_P15: CC67.2 JCPU1.J35
PEG_CTX_GRX_N0: CC50.1 JMXM1.176
PEG_CTX_GRX_N1: CC77.1 JMXM1.170
PEG_CTX_GRX_N2: CC62.1 JMXM1.164
PEG_CTX_GRX_N3: CC49.1 JMXM1.156
PEG_CTX_GRX_N4: CC76.1 JMXM1.150
PEG_CTX_GRX_N5: CC59.1 JMXM1.144
PEG_CTX_GRX_N6: CC48.1 JMXM1.138
PEG_CTX_GRX_N7: CC75.1 JMXM1.132
PEG_CTX_GRX_N8: CC56.1 JMXM1.126
PEG_CTX_GRX_N9: CC47.1 JMXM1.120
PEG_CTX_GRX_N10: CC74.1 JMXM1.114
PEG_CTX_GRX_N11: CC46.1 JMXM1.108
PEG_CTX_GRX_N12: CC73.1 JMXM1.102
PEG_CTX_GRX_N13: CC53.1 JMXM1.96
PEG_CTX_GRX_N14: CC45.1 JMXM1.90
PEG_CTX_GRX_N15: CC44.1 JMXM1.84
PEG_CTX_GRX_P0: CC64.1 JMXM1.178
PEG_CTX_GRX_P1: CC63.1 JMXM1.172
PEG_CTX_GRX_P2: CC72.1 JMXM1.166
PEG_CTX_GRX_P3: CC61.1 JMXM1.158
PEG_CTX_GRX_P4: CC60.1 JMXM1.152
PEG_CTX_GRX_P5: CC71.1 JMXM1.146
PEG_CTX_GRX_P6: CC58.1 JMXM1.140
PEG_CTX_GRX_P7: CC57.1 JMXM1.134
PEG_CTX_GRX_P8: CC70.1 JMXM1.128
PEG_CTX_GRX_P9: CC55.1 JMXM1.122
PEG_CTX_GRX_P10: CC54.1 JMXM1.116
PEG_CTX_GRX_P11: CC69.1 JMXM1.110
PEG_CTX_GRX_P12: CC52.1 JMXM1.104
PEG_CTX_GRX_P13: CC51.1 JMXM1.98
PEG_CTX_GRX_P14: CC68.1 JMXM1.92
PEG_CTX_GRX_P15: CC67.1 JMXM1.86
PEQ: R69.2 R70.2 U9.8
PHASE1: PC540.2 PQ504.3 PU500.20
PHASE2: PC521.2 PQ502.3 PU500.25
PHASE3: PC501.2 PQ500.3 PU501.8
PM_APWROK: RH87.1 U51.A9 UH2.2
PM_APWROK_R: RH87.2 UH1.AB7 UH2.4
PM_DRAM_PWRGD: T104.1(TP-1) UH1.H3
PM_DRAM_PWRGD_A: RC18.2 UC2.2
PM_DRAM_PWRGD_CPU: JCPU1.AC10 RC14.1 RC16.2 UC2.4
PM_LANPHY_ENABLE: R555.1 RH217.1 UH1.K13
POWER_SW#: U10.4 U29.20
POWER_SW#_MB: JAPS1.11 JPB1.1 PWRSW1.1 R811.2
POWER_SW_IN#: C1352.1 R810.2 R811.1 U10.2 U51.B67
PROCHOT_GATE: PU704.2 RP1.6 U46.A50
PS2_CLK_TS: JIO1.118 JKB1.3 JKB1.4
PS2_DAT_TS: JIO1.116 JKB1.5 JKB1.6
PS_ID: PU1.4 U51.A55
PSATA_PRX_DTX_N0: C385.1 JSATA1.5
PSATA_PRX_DTX_N0_C: C385.2 UH1.BC8
PSATA_PRX_DTX_P0: C386.1 JSATA1.6
PSATA_PRX_DTX_P0_C: C386.2 UH1.BE8
PSATA_PTX_DRX_N0: C384.1 JSATA1.3
PSATA_PTX_DRX_N0_C: C384.2 UH1.AW8
PSATA_PTX_DRX_P0: C383.1 JSATA1.2
PSATA_PTX_DRX_P0_C: C383.2 UH1.AY8
PSID_DISABLE#: PR13.2 U46.A37
PWM3: PR523.2 PU500.22 PU501.3
PWR_SRC_ON: C297.2 Q21.3 R422.2 R423.1
PWRSHARE_EN#: Q55.1 R816.1 U45.5
QHD_DET#: JEDP1.10 R19.2 U46.A44
RED_CRT: C20.1 L1.1 R53.1 U19.33
RED_CRT_L: JCRT1.1 L1.2
RED_DOCK: JDOCK1.53 U19.24
REGCTL_PNP10: L29.1 U31.7
REM_DIODE1_N: C339.2 C1343.1 Q26.3 U51.B13
REM_DIODE1_N_4021: C271.2 C273.2 Q16.3 U29.23
REM_DIODE1_P: C339.1 C1343.2 Q26.1 Q26.2 U51.A13
REM_DIODE1_P_4021: C271.1 C273.1 Q16.1 Q16.2 U29.24
REM_DIODE2_N: C340.2 C1350.1 Q17.3 U51.B14
REM_DIODE2_N_4021: C291.2 C315.1 Q27.3 U29.26
REM_DIODE2_P: C340.1 C1350.2 Q17.1 Q17.2 U51.A14
REM_DIODE2_P_4021: C291.1 C315.2 Q27.1 Q27.2 U29.27
REM_DIODE3_N: C272.2 C1351.1 Q14.3 U51.A15
REM_DIODE3_P: C272.1 C1351.2 Q14.1 Q14.2 U51.B16
REM_DIODE4_N: C288.2 C335.2 C1346.1 Q15.3 U51.A16
REM_DIODE4_P: C288.1 C335.1 C1346.2 Q15.1 Q15.2 U51.B17
RES_BIAS: R562.1 U31.12
RESET_OUT#: Q52.2 R843.2 RC73.1 RH27.1 U51.B39 UH1.F10
RESET_OUT#_R: JXDP2.46 RH27.2
REXT3: R74.2 U9.27
RF_+1.05VSP: PR305.1 PU300.5
RSMRST#: R1622.1 R1630.1 U4.3 U7.2
RSMRST#_XDP: JXDP2.39 RH26.2
RUN_ON: JIO1.87 PR406.1 Q304.2 R15.1 RP4.2 U19.2 U37.3 U46.A11
RUN_ON_ENABLE#: Q45.2 Q304.5 Q304.6 R909.2
RUNPWROK: Q45.1 R799.2 U46.A4 U50.2 U51.B26
S3_1.35V: PR208.2 PU200.7
S5_1.35V: PC215.1 PR206.2 PR240.1 PU200.8
SATA_ACT#: Q74.4 UH1.AP3
SATA_COMP: RH57.1 UH1.AY5
SATA_LED: JIO1.98 R934.2
SATA_ODD_PRX_DTX_N1: C432.1 JODD1.5
SATA_ODD_PRX_DTX_N1_C: C432.2 UH1.BC10
SATA_ODD_PRX_DTX_P1: C430.1 JODD1.6
SATA_ODD_PRX_DTX_P1_C: C430.2 UH1.BE10
SATA_ODD_PTX_DRX_N1: C434.1 JODD1.3
SATA_ODD_PTX_DRX_N1_C: C434.2 UH1.AV10
SATA_ODD_PTX_DRX_P1: C433.1 JODD1.2
SATA_ODD_PTX_DRX_P1_C: C433.2 UH1.AW10
SATA_PRX_DKTX_N2: C698.2 JDOCK1.56
SATA_PRX_DKTX_N2_C: C698.1 UH1.BB9
SATA_PRX_DKTX_P2: C697.2 JDOCK1.54
SATA_PRX_DKTX_P2_C: C697.1 UH1.BD9
SATA_PRX_DTX_N3: C673.2 JESA1.9
SATA_PRX_DTX_P3: C674.2 JESA1.10
SATA_PTX_DKRX_N2: C700.1 JDOCK1.62
SATA_PTX_DKRX_N2_C: C700.2 UH1.AY13
SATA_PTX_DKRX_P2: C699.1 JDOCK1.60
SATA_PTX_DKRX_P2_C: C699.2 UH1.AW13
SATA_PTX_DRX_N3: C672.2 JESA1.7
SATA_PTX_DRX_P3: C671.2 JESA1.6
SATA_SIDE_LED: JIO1.90 R943.2
SB#: Q338.2 R1626.2 U2.8
SCLK: PR504.1 PR508.2 PU500.1
SDA: PR500.1 PR505.2 PU500.31
SEL: Q338.1 R1614.1 U2.4
SIO_14M: RH157.2 UH1.F38
SIO_A20GATE: RH202.1 U51.A45 UH1.AN10
SIO_EXT_SCI#: RH195.1 RPH10.8 U51.A33
SIO_EXT_SMI#: RH10.1 RPH7.4 U51.A6 UH1.M1
SIO_EXT_WAKE#: RH24.1 RH210.1 U46.B49 UH1.Y1
SIO_PWRBTN#: RC6.1 RH28.1 U51.B58 UH1.K1
SIO_RCIN#: RPH10.7 U51.A27 UH1.AT6
SIO_SLP_A#: JAPS1.6 PR303.1 U46.B63 UH1.F3 UH2.1
SIO_SLP_LAN#: RH80.2 U46.A5 U63.3 UH1.G5
SIO_SLP_S3#: JAPS1.2 JIO1.85 PR403.1 U46.B65 UH1.H1
SIO_SLP_S4#: JAPS1.5 PR206.1 T118.1(TP-1) U46.A61 UH1.C6
SIO_SLP_S5#: JAPS1.4 T146.1(TP-1) U51.A18 UH1.Y7
SIO_SLP_SUS#: T145.1(TP-1) U46.B6 UH1.F1
SIO_SLP_WLAN#: R815.1 U46.A14 UH1.D2
SL_BAT_PRES#: PR1023.1 PU1001.21
SLICE_BAT_ON: PQ1082.2 PR1016.2 PU1080.2 R761.1 RP8.3 U46.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PD1100.1 PR33.1 PR1023.2 PU1080.1 R784.1 U46.B33
SLICE_BST_CHG_EN: PQ1071.5 PR1033.2 PR1098.1 R761.2 U46.B16
SLP_ME_CSW_DEV#: RH222.1 RH223.1 U46.B58 UH1.AD11
SM_RCOMP0: JCPU1.AP3 RC42.1
SM_RCOMP1: JCPU1.AR3 RC55.1
SM_RCOMP2: JCPU1.AP2 RC49.1
SML1_SMBCLK: RPH5.3 U51.B6 UH1.K6
SML1_SMBDATA: RPH5.4 U51.A5 UH1.N11
SNB_CPU_P1: PC545.2 PR554.1
SNB_CPU_P2: PC523.2 PR542.1
SNB_CPU_P3: PC507.2 PR515.1
SNUB_1.5VSP: PC407.1 PR401.2
SNUB_1.35V: PC212.1 PR202.2
SNUB_3V: PC116.1 PR109.2
SNUB_5V: PC119.1 PR110.2
SNUB_CHG: PC717.1 PR724.2
SOFT_START_GC: PR20.2 PU1001.2
SP_TPM_LPC_EN: R2188.1 U46.B56
SP_TPM_LPC_EN_R: R2188.2 R2189.2 U39.28
SPI_CLK32: R897.1 RE2.1 U53.6
SPI_CLK64: R899.1 RE1.1 U52.6
SPI_DIN32: R895.2 U53.2
SPI_DIN64: R8.2 U52.2
SPI_DO32: R900.1 U53.5
SPI_DO64: R901.1 U52.5
SPI_PCH_CLK: JSPI1.7 R897.2 R899.2 RH181.1
SPI_PCH_CS0#: JSPI1.9 R7.1 RH182.1
SPI_PCH_CS0#_R: R7.2 U52.1
SPI_PCH_CS1#: JSPI1.1 R936.1 RH177.1
SPI_PCH_CS1#_R: R936.2 U53.1
SPI_PCH_DIN: JSPI1.5 R8.1 R895.1 RH179.1
SPI_PCH_DO: JSPI1.3 R900.2 R901.2 RH178.1
SPI_PCH_DO2: JSPI1.11 R9.1 R3667.1 RH183.1
SPI_PCH_DO2_32: R3665.2 R3667.2 RH186.1 U53.3
SPI_PCH_DO2_64: R9.2 R3664.2 RH180.1 U52.3
SPI_PCH_DO3: JSPI1.13 R3669.2 R3670.2 RH184.1
SPI_PCH_DO3_32: R3666.2 R3670.1 U53.7
SPI_PCH_DO3_64: R3668.2 R3669.1 U52.7
SPI_WP#_SEL: RH180.2 RH186.2 U46.A12
SPKR: JIO1.76 RH34.2 UH1.AL10
SRTCRST#: CH6.2 ME1.2 RH42.2 UH1.B9
STSTART_DCBLOCK_GC: PR1002.1 PU1001.16
SUS_ON: PR240.2 RP4.4 U46.B60 U57.5
SUS_STAT#/LPCPD#: T103.1(TP-1) UH1.U7
SUSACK#: RH101.1 U46.A58
SUSACK#_R: RH91.2 RH101.2 UH1.R6
SUSCLK: T68.1(TP-1) UH1.Y6
SW1: PC111.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ104.5 PR110.1 PU101.18
SW2: PC112.1 PL103.1 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PR109.1 PU101.8
SW_1.35V: PC206.1 PL201.2 PQ201.1 PQ201.2 PQ201.3 PQ202.5 PR202.1 PU200.16
SW_+1.05VSP: PC306.1 PL301.1 PQ301.1 PQ301.2 PQ301.3 PQ303.5 PR304.1 PU300.8
SW_LAN_TX0+: T156.1 U32.24
SW_LAN_TX0-: T156.2 U32.25
SW_LAN_TX1+: T156.5 U32.28
SW_LAN_TX1-: T156.6 U32.29
SW_LAN_TX2+: T156.7 U32.33
SW_LAN_TX2-: T156.8 U32.34
SW_LAN_TX3+: T156.11 U32.37
SW_LAN_TX3-: T156.12 U32.38
SYS_LED_MASK#: JIO1.114 Q84.2 Q325.2 Q325.5 Q327.2 Q328.2 Q344.2 R775.2 U46.B48 U58.1
SYS_PWROK: RC9.1 U46.B57 UH1.AD7
SYS_PWROK_XDP: JXDP1.47 RC9.2 RC124.2
SYS_RESET#: JAPS1.13 JXDP1.48 JXDP2.48 RC26.1 UH1.AM1
SYSPWR_PRES: R874.1 R876.1 U51.A59
SYSTEM_ID: C742.1 R871.2 U51.A10
TEMP_ALERT#: RH171.2 U46.B11 UH1.H6
THERM_STP#: PR111.1 R395.1 U29.19
THERMATRIP2#: C327.1 Q28.1 R396.2 U51.B34
THSEL_STRAP: R1069.1 U51.B29
TMDS_DDCBUF: R66.2 R68.2 U9.2
TMDS_PRE: R65.2 R67.2 U9.20
TMDS_RT: R57.2 R71.2 U9.23
TMDSE_CON_CLK: C1333.1 JHDMI1.10 L19.3 R451.2
TMDSE_CON_CLK#: C1334.1 JHDMI1.12 L19.2 R452.2
TMDSE_CON_N0: C1335.1 JHDMI1.9 L23.2 R454.2
TMDSE_CON_N1: C1337.1 JHDMI1.6 L24.2 R456.2
TMDSE_CON_N2: C1339.1 JHDMI1.3 L25.2 R458.2
TMDSE_CON_P0: C1336.1 JHDMI1.7 L23.3 R453.2
TMDSE_CON_P1: C1338.1 JHDMI1.4 L24.3 R455.2
TMDSE_CON_P2: C1340.1 JHDMI1.1 L25.3 R459.2
TMDSE_RP_CLK: L19.4 R451.1 U9.16
TMDSE_RP_CLK#: L19.1 R452.1 U9.15
TMDSE_RP_N0: L23.1 R454.1 U9.18
TMDSE_RP_N1: L24.1 R456.1 U9.21
TMDSE_RP_N2: L25.1 R458.1 U9.24
TMDSE_RP_P0: L23.4 R453.1 U9.19
TMDSE_RP_P1: L24.4 R455.1 U9.22
TMDSE_RP_P2: L25.4 R459.1 U9.25
TOUCH_SCREEN_PD#: T155.1(TP-1) U46.B55
TP_LAN_JTAG_TCK: T172.1(TP-1) U31.35
TP_LAN_JTAG_TDI: T142.1(TP-1) U31.32
TP_LAN_JTAG_TDO: T143.1(TP-1) U31.34
TP_LAN_JTAG_TMS: T171.1(TP-1) U31.33
TP_VSS_NCTF: RH219.2 UH1.BE5
TPM_ID0: RPH10.6 UH1.AT7
TPM_ID1: RH200.2 UH1.AM3
TRIP_+1.05VSP: PR302.2 PU300.2
UG_3V: PQ101.4 PU101.10
UG_5V: PQ102.4 PU101.16
UG_+1.05VSP: PQ301.4 PU300.9
UGATE1: PQ504.2 PU500.19
UGATE2: PQ502.2 PU500.26
UGATE3: PQ500.2 PU501.1
UIM_CLK: C628.1 JMINI2.12 JSIM1.3
UIM_DATA: C631.1 JMINI2.10 JSIM1.7
UIM_RESET: C629.1 JMINI2.14 JSIM1.2
UIM_VPP: C630.1 JMINI2.16 JSIM1.6
USB3_A_DE0: R23.2 U638.29
USB3_A_DE1: R25.2 U638.28
USB3_A_EQ0: R24.2 U638.32
USB3_A_EQ1: R22.2 U638.31
USB3_B_DE0: R28.2 U638.15
USB3_B_DE1: R30.2 U638.16
USB3_B_EQ0: R18.2 U638.13
USB3_B_EQ1: R27.2 U638.14
USB3_RX1_N_D-: D14.5 D14.6 JUSB1.5 L40.1
USB3_RX1_P_D+: D14.4 D14.7 JUSB1.6 L40.4
USB3_RX2_N_D-: D16.5 D16.6 JUSB2.5 L43.1
USB3_RX2_P_D+: D16.4 D16.7 JUSB2.6 L43.4
USB3_TEST: R26.2 U638.22
USB3_TX1_N_D-: D14.2 D14.8 JUSB1.8 L42.1
USB3_TX1_P_D+: D14.1 D14.9 JUSB1.9 L42.4
USB3_TX2_N_D-: D16.2 D16.8 JUSB2.8 L44.1
USB3_TX2_P_D+: D16.1 D16.9 JUSB2.9 L44.4
USB3RN1: C487.2 UH1.AR26
USB3RN1_C: C487.1 U638.24
USB3RN1_RP: L40.2 U638.4
USB3RN2: C490.2 UH1.AW26
USB3RN2_C: C490.1 U638.18
USB3RN2_RP: L43.2 U638.10
USB3RN3: JDOCK1.84 UH1.AW31
USB3RN5: JIO1.45 UH1.AW29
USB3RN6: JIO1.57 UH1.AR29
USB3RP1: C465.2 UH1.AP26
USB3RP1_C: C465.1 U638.23
USB3RP1_RP: L40.3 U638.5
USB3RP2: C491.2 UH1.AV26
USB3RP2_C: C491.1 U638.17
USB3RP2_RP: L43.3 U638.11
USB3RP3: JDOCK1.86 UH1.AY31
USB3RP5: JIO1.47 UH1.AV29
USB3RP6: JIO1.59 UH1.AP29
USB3TN1: C452.2 UH1.BE24
USB3TN1_C: C452.1 U638.27
USB3TN1_RP: C488.1 L42.2
USB3TN1_RP_C: C488.2 U638.1
USB3TN2: C456.2 UH1.BD25
USB3TN2_C: C456.1 U638.21
USB3TN2_RP: C492.1 L44.2
USB3TN2_RP_C: C492.2 U638.7
USB3TN3: JDOCK1.90 UH1.BE32
USB3TN5: JIO1.51 UH1.BE26
USB3TN6: JIO1.63 UH1.BD27
USB3TP1: C454.2 UH1.BD23
USB3TP1_C: C454.1 U638.26
USB3TP1_RP: C489.1 L42.3
USB3TP1_RP_C: C489.2 U638.2
USB3TP2: C457.2 UH1.BC24
USB3TP2_C: C457.1 U638.20
USB3TP2_RP: C493.1 L44.3
USB3TP2_RP_C: C493.2 U638.8
USB3TP3: JDOCK1.92 UH1.BC32
USB3TP5: JIO1.53 UH1.BC26
USB3TP6: JIO1.65 UH1.BE28
USB_MCARD1_DET#: JMINI4.40 R824.1 UH1.A10
USB_OC0#: RH3.1 RH246.2 U45.6 U45.10 UH1.P3
USB_OC1#: JIO1.69 RH4.1 RH247.2 UH1.V1
USB_OC2#: RH6.1 RPH7.1 UH1.U2
USB_OC3#: RH7.1 RH248.2 UH1.P1
USB_OC4#: JIO1.71 RH8.1 RH249.2 U48.6 U48.10 UH1.M3
USB_OC5#: RH9.1 RPH7.2 UH1.T1
USB_OC6#: RH17.1 RPH7.3 UH1.N2
USB_PWR_SHR_EN#: R1626.1 RP2.7 U46.B10
USB_PWR_SHR_VBUS_EN: Q55.2 RP1.7 U2.1 U46.B50
USB_SIDE_EN#: JIO1.73 R768.2 U45.4 U46.A33
USBP0+: U2.6 UH1.D37
USBP0-: U2.7 UH1.B37
USBP0_D+: L39.2 U2.3
USBP0_D-: L39.3 U2.2
USBP0_R_D+: D15.3 JUSB1.3 L39.1
USBP0_R_D-: D15.2 JUSB1.2 L39.4
USBP1+: L41.3 UH1.C38
USBP1-: L41.2 UH1.A38
USBP1_D+: D17.2 JUSB2.3 L41.4
USBP1_D-: D17.3 JUSB2.2 L41.1
USBP2+: JIO1.18 UH1.C36
USBP2-: JIO1.20 UH1.A36
USBP3+: JDOCK1.72 UH1.C34
USBP3-: JDOCK1.74 UH1.A34
USBP4+: JMINI4.38 UH1.D33
USBP4-: JMINI4.36 UH1.B33
USBP5+: JMINI2.38 UH1.G31
USBP5-: JMINI2.36 UH1.F31
USBP6+: JDOCK1.66 UH1.L31
USBP6-: JDOCK1.68 UH1.K31
USBP7+: JUSH1.3 UH1.H29
USBP7-: JUSH1.2 UH1.G29
USBP8+: L51.1 UH1.C32
USBP8-: L51.4 UH1.A32
USBP8_D+: D73.3 JESA1.3 L51.2
USBP8_D-: D73.2 JESA1.2 L51.3
USBP9+: JIO1.26 UH1.C30
USBP9-: JIO1.24 UH1.A30
USBP10+: JIO1.32 UH1.D29
USBP10-: JIO1.30 UH1.B29
USBP12+: L10.4 UH1.F26
USBP12-: L10.1 UH1.G26
USBP12_D+: D21.3 JEDP1.16 L10.3
USBP12_D-: D21.2 JEDP1.15 L10.2
USBP13+: T167.1(TP-1) UH1.G24
USBP13-: T166.1(TP-1) UH1.F24
USBRBIAS: RH187.1 UH1.K24 UH1.K26
USH_DET#: JUSH1.20 RPH9.8 UH1.F13
USH_PWR_ON: T140.1(TP-1) U46.A18
USH_PWR_STATE#: JUSH1.16 R102.2 U46.A34
USH_SMBCLK: JUSH1.5 R589.2 U51.A50
USH_SMBDAT: JUSH1.6 R585.2 U51.B53
VCI_IN3#: R873.2 U51.B68
VCORE_VDDP: PC508.2 PR520.1 PR523.1 PU500.23
VCP_4021: R430.1 U29.25
VCT_LAN_R1: R553.2 R558.1 U31.6
VGA_ID: R803.1 U46.B59
VIDALERT_N: PR506.1 RC60.2 RC61.2
VIDSCLK: JCPU1.AM29 PR508.1
VIDSOUT: JCPU1.AL28 PR505.1 RC63.2
VLDOIN_1.35V: PJP201.2 PU200.19
VOL_DOWN: JIO1.79 R887.2 R1197.2
VOL_DOWN_R: R887.1 U51.B57
VOL_MUTE: JIO1.81 R884.2 R1986.2
VOL_UP: JIO1.77 R1118.2 R1984.2
VR_HOT#: PR524.2 PU500.5
VR_ON: PR513.2 PR517.2 PU500.2
VSB_N_001: PC7.2 PQ4.2 PR15.2 PR17.2
VSB_N_002: PC16.1 PQ7.2 PR21.2 PR23.2
VSB_N_003: PQ7.1 PR17.1
VSET_4021: C319.1 R424.1 U29.28
VSET_5075: C1347.1 R1983.1 U51.A17
VSYNC: RH95.2 UH1.N44
VSYNC_BUF: L5.1 U19.36
VSYNC_DOCK: JDOCK1.67 U19.27
VSYNC_L: JCRT1.14 L5.2
WAKE#: JMXM1.40 R36.2 R1972.1
WIGIG60GHZ_DIS#: D29.1 U46.A1
WIGIG60GHZ_DIS#_R: D29.2 JMINI4.32 R692.1
WIGIG_LED#: JMINI4.42 Q124.4 R705.1 R706.1
WIRELESS_LED#: Q77.1 Q78.3 Q124.3 Q124.6 R937.2 U46.A47
WIRELESS_ON#/OFF: JWL1.3 RP2.6 U46.B13
WLAN_LAN_DISB#: U15.4 U46.A64
WLAN_LED: JIO1.96 R939.2
WLAN_LED#: JMINI4.44 Q124.1 R718.1
WLAN_RADIO_DIS#: D31.1 U46.A48
WLAN_RADIO_DIS#_R: D31.2 JMINI4.20 R695.1
WWAN_RADIO_DIS#: JMINI2.20 RP1.5 U46.A53
XDP_DBRESET#_R: JCPU1.AP33 RC19.2 RC26.2
XDP_FN0: JXDP2.9 RH3.2
XDP_FN1: JXDP2.11 RH4.2
XDP_FN2: JXDP2.15 RH6.2
XDP_FN3: JXDP2.17 RH7.2
XDP_FN4: JXDP2.27 RH8.2
XDP_FN5: JXDP2.29 RH9.2
XDP_FN6: JXDP2.33 RH17.2
XDP_FN7: JXDP2.35 RH10.2
XDP_FN8: JXDP2.10 RH11.2
XDP_FN9: JXDP2.12 RH13.2
XDP_FN10: JXDP2.16 RH12.2
XDP_FN11: JXDP2.18 RH14.2
XDP_FN12: JXDP2.28 RH16.2
XDP_FN13: JXDP2.30 RH19.2
XDP_FN14: JXDP2.34 RH20.2
XDP_FN15: JXDP2.36 RH22.2
XDP_FN16: JXDP2.4 RH24.2
XDP_FN17: JXDP2.6 RH25.2
XDP_OBS0: JXDP1.21 RC30.2
XDP_OBS0_R: JCPU1.AR30 RC30.1
XDP_OBS1: JXDP1.23 RC31.2
XDP_OBS1_R: JCPU1.AN31 RC31.1
XDP_OBS2_R: JCPU1.AN29 T1.1(TP-1)
XDP_OBS3_R: JCPU1.AP31 T2.1(TP-1)
XDP_OBS4_R: JCPU1.AP30 T3.1(TP-1)
XDP_OBS5_R: JCPU1.AN28 T4.1(TP-1)
XDP_OBS6_R: JCPU1.AP29 T5.1(TP-1)
XDP_OBS7_R: JCPU1.AP28 T6.1(TP-1)
XDP_PRDY#: JCPU1.AR29 RC47.1
XDP_PRDY#_R: JXDP1.5 RC47.2
XDP_PREQ#: JCPU1.AT29 RC32.2 RC48.1
XDP_PREQ#_R: JXDP1.3 RC48.2
XDP_RST#_R: JXDP1.46 RC8.2
XDP_TCLK: JCPU1.AM34 RC40.2 RC50.1
XDP_TCLK_R: JXDP1.57 RC50.2
XDP_TDI: JXDP1.56 RC23.2
XDP_TDI_R: JCPU1.AM31 RC23.1 RC29.2
XDP_TDO: JXDP1.52 RC24.2
XDP_TDO_R: JCPU1.AL33 RC24.1 RC35.2
XDP_TMS: JCPU1.AN33 RC27.2 RC56.1
XDP_TMS_R: JXDP1.58 RC56.2
XDP_TRST#: JCPU1.AM33 RC41.2 RC62.1
XDP_TRST#_R: JXDP1.54 RC62.2
XTAL25_IN: CH14.2 RH153.2 UH1.AM43 YH2.1
XTAL25_OUT: CH13.2 RH153.1 UH1.AL44 YH2.3
XTALI: C471.1 U31.10 Y3.3
XTALO: C470.1 U31.9 Y3.1
Z2805: R574.1 T156.22
Z2806: R573.1 T156.16
Z2807: R572.1 T156.21
Z2808: R571.1 T156.15
Z4012: PD1.2 PR1.2
Z4304: PBATT1.3 PD2.2 PR3.4
Z4305: PBATT1.4 PD2.3 PR3.3
Z4306: PBATT1.5 PD3.2 PR3.2
ZODD_WAKE#: Q81.6 R796.2 U46.A59
N265433: PQ8.1 PQ8.2
N16717680: PC9.1 PQ5.4 PQ8.4 PR16.2 PR20.1 PR22.1
N16751240: PQ701.4 PR700.2
N16759342: PC700.2 PQ700.2 PQ702.2 PR703.1
N16759370: PQ703.1 PQ703.3 PR709.2 PR712.2 PR714.2
N16759478: PQ700.1 PR701.2
N16762870: PQ706.3 PQ706.6 PR739.1
N16762920: PQ707.6 PR749.2 PU704.1
N16762966: PQ706.5 PU704.4
N16763030: PR734.2 PR738.2 PR742.2 PR746.1 PU703.1
N16763050: PC731.1 PR740.1 PR743.2 PU703.5
N16763106: PC729.1 PR734.1 PR736.2 PR744.1 PU703.3
N16763148: PC730.1 PR737.2 PR745.1 PU703.2
N16763200: PC732.1 PR741.2 PR747.1 PR748.1 PU703.6
N16790095: T59.1(TP-1) UH1.C26
N16807572: T58.1(TP-1) UH1.BB2
N16845401: T65.1(TP-1) UH1.AW17
N16845569: T67.1(TP-1) UH1.AV17
N16848437: Q344.6 R956.1
N16848559: Q80.2 Q84.1
N16855849: PC540.1 PR549.1
N16857314: T57.1(TP-1) UH1.BA2
N16858942: T144.1(TP-1) UH1.AB10
N16863974: T132.1(TP-1) UH1.AV43
N16864660: T133.1(TP-1) UH1.AY45
N16864959: T130.1(TP-1) UH1.AV45
N16865260: T131.1(TP-1) UH1.AW44
N16869408: T134.1(TP-1) UH1.AU42
N16869720: T66.1(TP-1) UH1.AU44
N16917464: PC217.1 PQ205.5 PR223.2 PR225.1
N16917466: PC219.1 PQ204.5 PR219.2 PR220.1
N16917470: PC216.1 PQ204.2 PQ204.3 PR213.2 PR217.1
N16917506: PC220.1 PQ205.2 PQ205.3 PR221.2 PR224.1
N16917526: PQ204.6 PR211.1
N16917538: PQ205.6 PR218.2
N16919045: R820.2 U29.31
N16923593: Q345.4 R20.1
N16923598: Q345.1 R21.1
N16923957: Q345.2 Q345.5 Q346.3 R12.2
N16958896: T141.1(TP-1) UH1.AD10
N17068457: T148.1(TP-1) UH1.AD39
N17068936: T147.1(TP-1) UH1.AD38
N17075402: PQ2.3 PR7.2 PR9.1
N17106356: T149.1(TP-1) UH1.BA45
N17106357: T150.1(TP-1) UH1.BC45
N17106358: T120.1(TP-1) UH1.BE43
N17106359: T121.1(TP-1) UH1.BE44
N17132539: PC1001.2 PQ1001.4 PR1002.2
N17139830: T122.1(TP-1) UH1.M33
N17139840: T123.1(TP-1) UH1.L33
N17164171: T124.1(TP-1) UH1.BC30
N17164181: T125.1(TP-1) UH1.BB29
N17205976: JDEG2.10 R864.2
N17319754: PC1004.1 PQ1003.4 PR1004.1
N17649391: PBATT1.7 PD3.3
N17657331: PC1099.1 PQ1008.1 PQ1008.2 PQ1008.3 PQ1009.1 PQ1009.2 PQ1009.3 PR1099.1
N17657337: PC1099.2 PD1099.1 PQ1008.4 PQ1009.4 PR1097.1 PR1099.2
N17657416: PQ1010.1 PR1097.2
N17657433: PQ1010.2 PR1098.2
N17657445: PD1099.2 PQ1002.5 PQ1002.6 PQ1002.7 PQ1002.8 PQ1005.5 PQ1005.6 PQ1005.7 PQ1005.8
N17657654: PQ1002.4 PR1006.1
N17669554: Q346.5 Q346.6 R13.2
N17684555: PC1005.1 PR1005.2
N17707524: PQ1071.2 PQ1071.3 PR1073.2
N17707536: PQ1070.3 PR1070.1 PR1071.2
N17707538: PQ1070.2 PR1071.1 PR1072.1
N17707548: PQ1071.6 PR1072.2
N17708032: PC5.1 PQ1.2 PR33.2
N17708061: PD5.2 PQ1.1
N18894456: PH500.2 PR525.2 PR528.2
N18894698: PC511.1 PR526.1 PU500.17
N18894707: PR507.2 PU500.28
N18894708: PR514.2 PU500.30
N18894710: PR509.2 PU500.29
N18894766: PC520.2 PR533.1
N18894780: PC527.2 PR543.1
N18894784: PC526.2 PR541.1
N18894793: PR529.2 PU500.9
N18894855: PC522.1 PR537.1 PU500.14
N18894856: PC522.2 PR545.2
N18894871: PH501.2 PR551.1
N18894872: PC532.1 PC538.1 PR548.2
N18894895: PC519.1 PR531.1 PU500.16
N18986312: PC791.1 PR775.1 PU700.20
N18986344: PR766.1 PU700.9
N18986424: PR758.1 PR760.1 PR764.2 PU700.10
N18986719: PC744.2 PR704.2 PR705.2 PU700.7
N18986737: PC734.2 PR765.2
N18986745: PR763.1 PU700.8
N18986747: PR759.1 PU700.13
N18986804: PR761.1 PU700.12
N18989990: PQ710.6 PR760.2
N19021798: PQ1080.5 PU1081.4
N19021978: PQ1082.1 PR1081.2 PR1083.2 PU1081.2
N19041240: PQ702.1 PR701.3
N19061218: PQ703.4 PR713.1 PR715.2
N19183947: PR702.2 PU701.6
N19183951: PR706.2 PR708.2 PU701.4
N19208717: PQ1080.2 PU1080.4
N19242649: PQ707.3 PR747.2
N19359738: PR100.2 PR102.2 PU101.4
N19359776: PR118.2 PR119.1 PU101.7
N19359778: PR105.1 PU101.5
N19359887: PR101.2 PR104.2 PU101.2
N19360011: PR106.1 PU101.1
N19407535: PQ1083.1 PQ1083.2
N19407555: PQ1005.4 PQ1083.4 PR1026.2
N19407586: PD1010.2 PR1014.2
N19407600: PD1100.2 PQ1011.2 PR1030.1 PR1032.1
N19407654: PD1010.3 PQ1072.1 PR1032.2
N19407656: PQ1011.1 PQ1072.2 PR1100.2
N20156535: D91.1 F3.2
N20207345: C555.1 R709.2 U62.4
N20966390: PL3.1 PQ2.1 PR7.1 PR10.2
N20966408: PQ3.2 PR10.1 PR12.2
N20966410: PQ2.2 PQ3.1 PR11.2 PR13.1
N21631508: PQ1004.4 PR1009.1
N21765641: C554.1 U63.12
N21766116: R717.1 R815.2 R844.2 U63.5
N21766341: C545.1 U63.10
N21774776: C436.1 U35.12
N21775970: C543.1 U35.10
N21777187: C435.1 U34.12
N21777255: C548.1 U34.10
N21778289: C549.1 U57.12
N21778337: C544.1 U57.10
N22506578: PR1008.1 PU1001.28
N22841899: Q87.1 R944.2
N22890234: RH195.2 UH1.AT8
N23248496: R802.2 U46.B18
N24484285: C546.1 U43.6
N24485569: C547.1 U56.6
N24487647: C541.1 U37.6
N24489474: C542.1 U38.6
N25846218: C16.1 R15.2 U38.3
N26598173: R3722.1 U630.48
N26614658: JEDP1.18 R208.2
N32810427: CE3.1 RE5.2
N32854162: C704.1 R756.2
N32854418: CE8.1 RE11.2
N32854492: CE9.1 RE12.2
N32916170: R804.1 U46.B19
N32917691: C713.1 R795.2
N32917710: C712.1 R794.2
N33080426: Q22.1 R423.2
N34391004: Q29.5 Q29.6 R513.2
N38606908: R783.1 U48.7
N48711348: PC521.1 PR534.1
N51290432: PC501.1 PR502.1
N51302473: PC500.1 PR501.1 PU501.6 PU501.7
N53085144: PC206.2 PR200.1
N53085275: PR205.2 PU200.9
N53866851: C747.1 R885.2
N63746311: R884.1 U51.B2
N63746359: R1984.1 U51.B8
