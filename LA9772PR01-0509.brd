# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_M_U35: length 3.1
  BOTTOM w0.102: PJP6.2 123.8,114.12 v2(124.51,114.82)
+3.3V_MXM: length 245.9
  TOP w0.254: RH113.1 14.6,94.4 v1(14.45,94.55)
  TOP w0.508: v1(119.03,100.92) 118.6,100.49 116.09,100.49 v1(115.99,100.59) 115.96,100.62 111.74,100.62 v1(111.29,101.08) 110.8,101.56 88.63,101.56 87.46,100.39 v1(85.96,100.39) ; v1(70.95,92.24) 69.78,91.07 62.15,91.07 60.59,92.63 v1(60.59,94.35)
  IN1 w0.508: v1(49.17,114.07) 49.89,114.79 51.57,114.79 52.64,113.73 52.64,110.61 53.65,109.6 53.65,109.24 54.94,107.96 55.23,107.96 56.12,107.07 56.12,103.9 57.16,102.86 57.16,100.19 58.15,99.2 58.63,99.2 v1(59.01,98.82)
  IN2 w0.254: v1(30.54,136.51) 30.41,136.51 29.8,135.9 29.8,135.42 28.63,134.25 28.63,133.44 22.18,126.99 22.18,123.35 22.36,123.17 22.36,120.49 22.23,120.36 21.62,120.36 21.1,119.84 20.59,119.84 19.68,118.93 19.68,117.78 18.42,116.53 18.42,115.55 16.15,113.27 16.15,112.99 15.48,112.31 15.48,110.48 13.98,108.98 13.98,108.38 13.11,107.51 13.11,101.35 13.56,100.9 13.56,95.76 14.45,94.87 v1(14.45,94.55)
  IN2 w0.508: v1(70.95,92.24) 71.1,92.24 75.76,96.9 79.07,96.9 81.06,98.89 81.06,98.92 v1(81.54,99.4) 82.53,100.39 v1(85.96,100.39) ; v1(126.78,101.84) 126.15,102.47 125.05,102.47 v1(124.52,101.94) ; v1(59.01,98.82) 58.78,99.05 57.46,99.05 56.83,98.41 56.83,97.93 55.36,96.45 v3(53.93,96.45)
  IN3 w0.508: v1(124.52,101.94) 124.29,101.71 119.82,101.71 v1(119.03,100.92)
  BOTTOM w0.254: v1(30.54,136.51) 31.05,136.51 33.72,133.84 38.91,133.84 40.46,135.39 50.57,135.39 56.32,129.64 56.32,118.93 52.94,115.56 52.42,115.56 51.76,114.89 50,114.89 v1(49.17,114.07)
  BOTTOM w0.381: R1.1 112.3,101.08 112.38,101 113,101 ; R2.1 115.63,101.31 115.32,101 114.9,101 ; 59.85,100.04 60.29,100.48 U14.5 ; C95.1 65.81,99.3 65.3,99.81 U25.5
  BOTTOM w0.508: R4.1 119.03,100.54 v1(119.03,100.92) 119.03,101.66 119.05,101.68 Q5.2 ; 54.77,100.37 52.87,102.27 51.85,101.26 51.85,99.22 52.59,98.49 54.19,98.49 ; C95.1 65.81,97.22 64.94,96.35 R6.1 R1979.1 62.59,96.35 62.59,96.35 61.51,96.35 61.22,96.63 ; v1(85.96,100.39) R10.1 R38.1 87.33,102.27 R1978.1 ; 61.22,96.63 60.59,96 v1(60.59,94.35) ; 61.22,96.63 61.22,98.11 60.32,99.01 60.32,99.64 59.93,100.04 59.85,100.04 59.77,99.96 59.77,99.58 v1(59.01,98.82) ; R36.1 126.6,102.02 v1(126.78,101.84) R1977.1 ; v1(111.29,101.08) R1.1 ; R3.1 R5.1 82.46,100.32 v1(81.54,99.4) ; v1(115.99,100.59) R2.1 ; v1(124.52,101.94) 124.37,101.79 R37.1
  BOTTOM w1.016: 52.29,102.85 52.87,102.27
  vias: v3(53.3,97.47) v4(53.83,97.81)
+3.3V_MXM_U34:
  vias: v2(51.66,111.64)
+3.3V_PCIE_FLASH: length 6.8
  TOP w0.508: v1(105.3,141.48) 105.69,141.09 C637.2 ; v1(97.8,136.55) 98.14,136.21 v2(98.14,136.04) C639.1 ; v1(99.32,136.15) 99.03,135.86 C624.1 ; v1(94.19,141.26) 94.1,141.35 C634.1 ; v1(117.27,141.23) 117.29,141.26 C638.2 117.26,142.28 C633.1
+3.3V_PCIE_WWAN: length 103.2
  IN1 w0.508: v1(215.45,68.57) 215.65,68.77 218.04,68.77 v1(218.86,67.96)
  IN2 w0.508: 221.92,67.32 221.92,62.57 v1(222.13,62.36) ; 221.92,67.32 230.69,67.32 231.99,68.62 236.08,68.62 240.45,72.98 240.45,75.65 241.97,77.18 245.98,77.18 246.54,77.73 248.85,77.73 v1(249.56,77.02) ; 221.92,67.32 219.26,67.32 218.86,67.73 v1(218.86,67.96)
  BOTTOM w0.254: v1(218.86,67.96) 218.83,67.96 218.37,67.49 U637.10 ; C1312.1 216.37,61.76 U637.20
  BOTTOM w0.508: JMINI2.24 252.26,76.24 C612.1 249.28,76.74 v1(249.56,77.02) ; R1160.1 248.32,71.37 ; 248.32,71.37 248.34,71.35 R719.2 v1(247.63,70.2) ; 248.32,71.37 245.89,71.37 Q77.2 245.46,73.76 245.93,74.23 R1159.1 ; R550.1 R560.1 216.24,69.35 v1(215.45,68.57) 214.93,68.57 v4(214.02,67.65) 213.51,67.14 210.96,67.14 210.24,66.43 210.24,63.97 211.36,62.85 213.9,62.85 215.05,61.71 C1313.1 C1312.1 ; R785.1 220.18,60.41 v1(222.13,62.36) 222.61,62.85 R568.1 ; JMINI2.52 250.18,65 C613.1 249.36,66.33 v3(249.97,66.33) ; v1(250.53,88.86) 250.1,88.43 C614.1 250.15,88.2 JMINI2.2 253.59,88.2 254.07,88.68 254.07,90.24 253.55,90.76 250.64,90.76 C615.1
  vias: v1(262.11,70.04) v1(262.1,69.44) v1(262.1,68.8) v1(262.72,70.04) v1(262.74,69.44) v1(262.74,68.8)
+3.3V_PCIE_WWAN_U43: length 3.4
  BOTTOM w0.102: 265.9,60.2 265.71,60.39 262.86,60.39 v2(262.63,60.62)
+3.3V_RTC_LDO: length 309.8
  IN1 w0.508: v1(229.88,66.69) 226.42,66.69 225.76,67.35 221.19,67.35 221.12,67.27 208.19,67.27 206.69,68.77 204.24,68.77 195.94,77.07 183.88,77.07 180.53,80.43 176.59,80.43 168.23,88.78 168.21,88.78 167.65,89.34 v1(167.65,89.57)
  IN2 w0.508: v3(141.26,170.47) 145.96,165.77 145.96,164.51 151.67,158.79 151.67,156.5 152.56,155.61 152.56,153.83 153.45,152.94 153.45,152.56 155.23,150.79 155.23,147.89 160.59,142.53 165.85,142.53 172.37,136 172.37,125.89 178.37,119.9 178.37,108.16 v1(178.57,107.96) ; v3(51.93,158.84) 46.54,158.84 45.86,159.52 42.5,159.52 41.46,158.48 v1(39.48,158.48)
  IN3 w0.508: v3(141.26,170.47) 140.7,171.03 123.73,171.03 123,171.75 108.13,171.75 106.9,170.52 97.65,170.52 94.75,167.63 89.59,167.63 88.14,166.17 83.59,166.17 83.28,166.48 82.61,166.48 81.03,168.06 79.69,168.06 77.95,166.31 73.33,166.31 69.48,162.47 61.31,162.47 57.77,158.94 52.03,158.94 v3(51.93,158.84)
  BOTTOM w0.508: v1(39.48,158.48) 41.21,158.48 PD1.3 ; v1(229.88,66.69) 229.88,66.66 230.41,66.13 234.37,66.13 235.49,67.24 v4(240.48,67.24) 243.14,67.24 245.99,64.39 PR103.2 ; v1(178.57,107.96) 178.57,100.72 173.77,95.92 173.77,91.48 171.23,88.94 168.08,88.94 167.65,89.37 v1(167.65,89.57)
+3.3V_RUN: length 671.6
  TOP w0.203: 67.47,133.58 66.86,134.19 66.86,134.96 66.77,135.05 U630.60 ; C560.1 60.15,142.27 U630.35 ; C502.1 61.29,136.67 U630.49 ; U630.26 64.77,145.07 65.29,145.59 65.29,145.98 C503.1 ; v1(36.48,161.28) 36.46,161.25 36.46,159.85 36.03,159.42 U629.26 ; U629.60 38.03,147.85 v1(38.05,147.84) ; 17.15,154.54 U9.28 ; U9.14 v1(19.19,160.61) ; C495.1 38.03,158.25 U629.21 ; U9.56 26.21,159.74 26.55,160.08 v1(26.63,160.08) ; U9.41 24.46,152.85 v1(24.6,152.72) ; RH200.1 39.79,83.75 39.99,83.55 39.99,81.32 39.61,80.94 39.2,80.94 v1(38.77,81.37) ; C494.1 31.83,149.49 32.95,149.49 33.26,149.8 U629.49 ; U630.21 66.77,145.88 C784.1 ; C504.1 31.71,156.4 31.71,156.18 32.49,155.4 U629.35
  TOP w0.254: R1197.1 101.38,162.8 101.89,163.31 v1(101.95,163.31) ; v1(113.7,163.46) 113.9,163.26 R1986.1 ; v1(43.85,83.55) 43.93,83.55 44.41,83.07 44.41,81.95 RH36.2 ; RH40.1 18.88,97.32 v1(18.3,97.9) 18.22,97.83 RH74.1 ; PR519.2 50.78,20.48 v1(50.91,20.48) ; R409.1 v1(170.14,139.1) ; v1(132.04,155.69) 131.47,155.69 129.36,153.58 129.36,153.03 128.84,152.51 128.84,148.81 130.23,147.41 130.23,145.15 129.6,144.51 119.15,144.51 v3(118.5,143.86) ; R68.1 27.57,165.62 v1(28.41,165.62)
  TOP w0.305: v1(29.28,102.93) 29.55,102.65 UH1.M31 ; UH1.AF12 34.78,95.15 UH1.AE14 ; UH1.AF12 35.44,94.92 UH1.AG14 ; UH1.AF12 35.51,94.42 v1(35.8,94.42) ; JUSH1.13 55.05,6.03 54.64,5.62 v1(54.57,5.62) ; UH1.AK32 36.76,102.54 v1(36.43,102.21) 36.76,101.88 UH1.AK30 ; UH1.R30 30.49,102.13 v1(30.49,102.19) 30.49,102.28 UH1.R32 ; v1(29.27,99.81) 29.27,99.72 UH1.L24
  TOP w0.33: v1(18.78,85.84) 18.78,85.86 18.96,86.04 QH4.2
  TOP w0.356: R1532.1 85.04,132.4 85.35,132.71 85.35,133.35 v1(85.51,133.5) ; v1(149.59,28.82) 149.65,28.76 JDIMM3.199 ; JDIMM1.199 136.23,28.75 v1(136.11,28.87)
  TOP w0.381: Q345.3 38.37,138.57 38.81,139 v1(38.96,139) ; C359.1 71.63,112.2 U20.14 ; v1(39.35,135.8) 39.67,136.12 Q345.6 ; v1(18.96,89.16) QH4.5
  TOP w0.457: v1(29.55,157.64) 29.09,157.19 R2154.1 R58.1 27.85,156.32 R2151.1 ; RH120.1 v1(36.74,83.55)
  TOP w0.508: v1(64.8,129.68) 64.61,129.87 R109.2 ; R143.2 v1(65.57,129.73) ; R2157.1 R2161.1 v1(29.7,163.99) ; v1(36.74,83.55) RH140.2 ; v3(25.84,80.86) 24.85,79.87 19.49,79.87 17.51,77.89 ; R13.1 v1(43.04,139.74) ; v1(16.11,153.91) C402.1 17.09,154.6 17.15,154.54 ; v1(60.65,142.83) 60.39,142.83 60.13,142.57 C560.1 ; C504.1 31.23,157.52 v1(31.2,157.54) ; RH205.2 41.82,83.81 v1(41.54,83.53) 41.6,83.46 41.6,82.5 41.11,82 RH226.2 ; v1(36.18,143.57) 36.18,143.86 36.38,144.07 R99.2 ; R2152.1 v1(28.15,148.12) ; v1(87.79,130.21) 88.3,130.72 R1530.1 ; R100.2 v1(58.62,140.12) ; v1(70.33,111.91) 70.59,112.18 71.59,112.18 C359.1 ; R518.1 R64.1 29.55,154.09 v1(29.63,154.16) 29.65,154.14 30.23,154.14 R98.2 ; v1(38.77,81.37) RH225.2 RH37.2 ; v1(60.91,135.29) 60.68,135.29 C502.1 ; v1(162.77,27.29) CD65.1 CD87.1 ; R127.2 R133.2 62.65,129.86 v1(62.79,129.72) ; 18.58,80.27 18.58,85.63 v1(18.78,85.84) ; R822.1 R829.1 112.76,157.52 v1(112.78,157.49) ; RD26.2 v1(162.09,31.66) ; R140.2 v1(66.58,131.98) R142.2 ; v1(30.84,147.79) 31.07,147.56 R119.2 R120.2 ; v1(85.51,133.5) 85.51,133.74 85.1,134.15 R1539.1 ; R340.1 v1(57.45,142.11) ; v1(67.61,134.45) 67.47,134.31 C558.1 ; v1(18.37,95.62) 18.45,95.54 18.83,95.54 RH328.1 ; v1(40.22,159.85) 40.94,159.85 C783.1 ; C784.1 v1(67.53,145.79) ; RD27.2 v1(162.09,30.77) ; v1(38.85,159.83) 38.85,159.32 38.95,159.22 C495.1 ; R118.2 R117.2 v1(38.9,144.56) 38.64,144.31 R124.2 ; v1(65.92,145.97) C503.1 ; R72.1 18.37,152.31 v1(18.74,152.68) ; v1(20.94,163.21) 21.07,163.33 21.07,163.85 R1165.2 ; RH229.2 45.44,83.87 v1(45.75,83.55) ; v1(108.44,149.54) R1118.1 ; v1(31.96,148.78) 31.94,148.8 31.28,148.8 31.23,148.85 C494.1 ; v1(130.97,32.54) RD8.2 ; R405.1 v1(163.1,136.18) ; RH228.2 v1(43.85,83.55)
  IN1 w0.254: v1(163.1,136.18) 166.02,139.1 v1(170.14,139.1)
  IN1 w0.508: v1(41.54,83.53) 41.54,83.3 40.32,82.08 40.32,81.11 43.43,78 v1(45.37,78) ; v1(48.7,149.67) 48.7,150.42 51.2,152.92 53.12,152.92 53.76,153.55 65.67,153.55 67.53,151.69 v1(67.53,145.79)
  IN2 w0.254: v1(54.57,5.62) 54.14,6.06 54.14,8.21 52.99,9.36 52.36,9.36 48.88,12.84 48.88,15.94 49.44,16.5 49.44,19.09 50.83,20.48 v1(50.91,20.48) ; v1(101.95,163.31) 102.32,163.31 103.44,162.19 107.35,162.19 107.86,161.68 112.28,161.68 113.7,163.1 v1(113.7,163.46) ; v1(148.88,155.23) 148.88,152.18 149.39,151.67 149.39,150.79 148.62,150.02 148.62,148.12 151.27,145.48 151.27,143.25 152.83,141.69 152.83,139.65 157.74,134.74 v1(157.74,131.2) ; v3(93.2,132.92) 93.34,133.06 93.34,136.22 97.89,140.77 97.89,143.29 97.24,143.94 97.24,145.45 v1(97.77,145.98)
  IN2 w0.508: 111.95,161.68 111.95,158.33 v1(112.78,157.49) ; v1(212.89,72.9) 212.21,73.57 210.3,73.57 209.99,73.26 209.99,72.65 209.61,72.27 209.12,72.27 206.28,75.11 206.28,78.55 207.5,79.77 v1(208.06,79.77) ; v1(162.31,131.15) 162.31,131.61 163.76,133.06 163.76,135.6 163.18,136.18 v1(163.1,136.18) ; v3(38.16,75.88) 37.91,76.13 29.32,76.13 28.95,76.5 20.38,76.5 16.68,72.81 v3(15.05,72.81)
  IN3 w0.508: v1(212.89,72.9) 213.14,72.64 v1(213.14,67.9)
  IN4 w0.254: v1(36.43,102.21) 35.95,102.69 30.98,102.69 v1(30.49,102.19)
  IN4 w0.508: v3(4.07,74.43) 4.07,74.41 4.38,74.1 5.14,74.1 6.43,72.81 v3(14.39,72.81) ; v3(85.05,152.28) 85.05,151.98 v3(84.74,151.67) 82.8,149.73 76.56,149.73 74.29,147.46 69.2,147.46 v1(67.53,145.79) 66.1,145.79 v1(65.92,145.97) ; v1(54.57,5.62) 55.42,6.48 73.15,6.48 77.78,11.11 77.78,13.12 89.91,25.25 92.5,25.25 94.06,26.81 94.06,27.87 94.55,28.36 130.21,28.36
  IN4 w1.524: 260.83,142.6 260.83,126.47 256.8,122.44 256.8,121.09 257.13,120.76 257.13,115.28 255.5,113.65 255.5,110.52
  BOTTOM w0.203: C450.1 232.25,89.22 U638.9 ; U638.25 v1(229.85,83.93)
  BOTTOM w0.254: U22.25 243.58,81.86 v1(244.32,81.11) ; v1(132.04,155.69) 132.11,155.61 R823.2 ; RH208.2 48.32,86.73 52.45,86.73 52.73,86.45 58.1,86.45 59.32,85.23 59.32,84.67 64.78,79.21 67.55,79.21 69.88,76.87 RC19.1 ; U22.1 238.08,90.36 v1(237.95,90.49) ; R799.1 97.87,146.09 v1(97.77,145.98) ; C392.1 166.28,41.3 R501.1 ; U22.32 240.08,81.85 240.38,81.54 v1(240.38,81.32) ; C497.1 240.16,90.92 240.16,90.24 240.58,89.82 U22.6 ; R824.2 v1(148.88,155.23) ; v1(244.42,90.49) 244.15,90.49 243.58,89.91 U22.12 ; U22.36 238.08,81.84 v1(237.73,81.5)
  BOTTOM w0.305: U88.1 170.2,38.86 169,37.66 R502.1 ; U88.7 166.71,41.4 C392.1 166.88,41.9 U88.8 ; U88.14 172.19,41.9 C391.1
  BOTTOM w0.356: v1(147.72,26.88) 147.72,27.89 146.86,28.75 JDIMM2.199 ; JDIMM4.199 159.41,28.75 v1(160.82,28.75)
  BOTTOM w0.381: U3.5 49.42,150.24 49.49,150.18 C248.1 ; v1(168.56,45.93) 168.6,45.9 R503.1 ; v1(30.49,102.19) 30.49,102.51 CH27.1
  BOTTOM w0.457: R28.1 233.33,76.56 v1(233.27,76.5)
  BOTTOM w0.508: RD36.2 v1(170.72,34.2) ; R504.1 166.58,44.99 v1(166.53,44.94) ; RH208.2 v1(45.75,83.55) ; C496.1 245.47,80.49 244.85,81.11 v1(244.32,81.11) ; v1(41.54,83.53) 41.82,83.81 RH205.2 RH202.2 ; v1(38.05,147.84) 37.83,148.05 C499.1 ; CH49.1 35.42,95.84 35.92,95.34 CH65.1 35.92,94.55 v1(35.8,94.42) ; C437.1 24.29,153.02 v1(24.6,152.72) ; v1(231.43,76.46) 231.43,77.05 R26.1 ; v1(48.7,149.67) 48.73,149.64 C248.1 ; v3(4.07,74.43) 3.29,75.22 3.29,80.91 4.43,82.05 4.43,84.82 5.14,85.53 5.14,88.2 6.31,89.37 6.94,89.37 7.78,90.21 7.78,94.14 9.08,95.44 9.53,95.44 9.61,95.36 10.37,95.36 ; PR400.1 258.1,35.72 v1(258.05,35.67) ; v1(166.53,31.77) CD66.1 CD88.1 ; CD22.1 132.9,34.58 v1(133.31,34.18) 133.31,33.82 132.93,33.44 CD43.1 ; v1(240.67,90.49) 240.67,91.37 C497.1 ; C52.1 v1(54.57,5.62) ; R70.1 20.71,160.77 C405.1 19.34,160.77 v1(19.19,160.61) ; CH48.1 36.75,102.53 v1(36.43,102.21) ; R2191.1 v1(239.62,76.5) ; v1(234.35,76.49) R27.1 ; v1(227.57,81.16) 227.16,81.57 R782.2 ; v1(235.24,76.49) R18.1 ; v1(22.59,113.5) 22.51,113.42 RH255.1 ; C392.1 v1(166.54,42.38) ; R71.1 R65.1 v1(16.29,157.06) ; C450.1 233.11,90.08 C453.1 234,91.54 232.83,92.72 230.69,92.72 230.16,92.19 v1(230.03,92.19) 230.03,92.52 229.57,92.97 227.24,92.97 226.7,92.44 226.7,91.82 225.37,90.49 R24.1 R22.1 224.91,89.13 223.81,88.03 223.81,87.56 224.19,87.18 225.2,87.18 R23.1 R25.1 ; R56.1 v1(243.62,78.12) ; v1(172.22,42.5) C391.1 ; v1(29.28,102.93) 29.69,103.34 30.32,103.34 CH27.1 ; R415.1 v1(237.51,80.87) ; R513.1 169.2,47.51 168.84,47.15 v1(168.84,46.92) ; v3(38.16,75.88) 37.96,76.08 37.96,79.44 38.31,79.79 43.58,79.79 v4(44.24,79.13) v1(45.37,78) ; v1(15.86,98.84) 16.72,98.84 RH86.1 RH83.1 RH77.1 ; v1(237.92,92.98) 237.91,92.97 R80.1 R76.1 ; v1(38.72,83.55) 38.9,83.73 RH168.1 RH200.1 ; Q24.3 57.45,149.38 C301.1 57.48,147.51 v1(58.82,146.16) ; RH256.1 v1(21.37,113.5) ; R30.1 v1(232.38,76.5) ; R78.1 v1(236.64,80.22) ; R407.1 R408.1 110.73,147.67 v1(110.75,147.65) ; v1(168.22,37.66) R502.1 ; R2190.1 v1(213.55,62.09)
  BOTTOM w1.524: 252.74,108 252.66,107.92 252.66,106.73 252.15,106.22 252.15,102.55 251.88,102.27 251.88,101.84 246.49,96.45 246.49,92.59
  vias: v1(24.29,114.69) v1(25.43,113.57) v1(25.94,109.87) v1(26.58,109.87) v1(27.06,158.89) v1(36.6,135.37) v1(38.57,148.42) v1(245.05,90.49) v1(245.69,90.49) v1(253.81,108.6) v1(253.81,108.02) v1(254.39,108.61) v1(254.39,108.02) v1(262.16,144.1) v1(262.16,143.47) v1(262.16,142.83) v3(16.62,105.37) v3(16.62,104.73) v3(16.62,104.07) v3(87.13,155.05) v3(87.21,154.37) v3(87.89,154.52) v3(92.26,133.08) v3(92.66,132.57) v3(92.83,133.46) v3(118.5,143.23) v3(118.5,141.44) v3(118.5,140.8) v3(156.5,116.88) v3(156.5,116.24) v3(169.71,60.62) v3(169.71,59.98) v3(169.71,59.35) v3(192.57,56.68) v3(193.2,56.68) v3(193.84,56.68) v3(194.47,56.68) v3(195.11,56.68) v3(195.74,56.68) v3(245.04,67.4) v3(245.04,66.76) v3(245.37,66.2) v3(245.68,68.03) v3(245.68,67.4) v3(245.68,66.76)
+3.3V_RUN_R: length 4.2
  TOP w0.508: R45.2 167.74,64.12 v2(168.84,64.12) 169.71,64.12 170.22,63.61 JSATA1.10
+3.3V_RUN_TPM: length 10.9
  BOTTOM w0.381: C552.1 169.5,112.7 U39.10 ; U39.24 160.25,115.95 C551.1 ; U39.5 169.52,115.95 C45.1 ; C553.1 160.19,112.7 U39.19
  BOTTOM w0.508: C552.1 169.78,112.66 v1(170.18,113.05) ; v1(170.26,115.09) 169.54,115.81 C45.1 ; C553.1 C550.1 v1(158.45,112.66)
  vias: v1(158.4,115.76) v2(158.03,113.21)
+3.3V_RUN_U38: length 3.2
  BOTTOM w0.102: PJP8.2 86.03,136.82 86.94,135.91 86.94,135.53 v2(86.88,135.47)
+3.3V_SPI: length 40.7
  TOP w0.305: v1(53.63,89.4) 53.7,89.47 JSPI1.15
  IN2 w0.508: v1(53.63,89.4) 53.81,89.22 56.98,89.22 v1(57.84,90.08)
  IN4 w0.508: v1(57.84,90.08) 56.3,88.53 v1(56.3,82)
  BOTTOM w0.254: R3664.1 46.9,81.49 48.68,79.72 v2(53.45,79.72) 54.29,79.72 55.66,81.09 R3665.1 55.91,82 v1(56.3,82) ; R3666.1 60.56,89.04 C1216.1 ; R3668.1 51.47,94.47 51.97,93.97 51.98,93.97 52.36,93.58 C746.1
  BOTTOM w0.508: U53.8 58.2,91.4 C1216.1 57.97,89.95 v1(57.84,90.08) ; U52.8 51.34,92.31 52.15,93.13 52.15,93.36 C746.1 52.66,93.25 52.66,92.09 52.18,91.6 52.18,90.76 52.69,90.26 RH185.2 52.82,90.21 52.82,90.13 53.55,89.4 v1(53.63,89.4)
+3.3V_SUS: length 143.6
  TOP w0.305: JUSH1.8 52.55,5.94 52.87,5.62 v1(53.05,5.62) ; JUSH1.10 53.55,5.93 53.25,5.62 v1(53.05,5.62) ; v1(53.05,5.62) JUSH1.9
  TOP w0.356: JIO1.86 15.31,85.8 15.4,85.89 C725.1
  TOP w0.508: C725.1 16.34,85.33 17.89,83.78 v1(17.89,80.43)
  IN1 w0.508: v1(17.89,80.43) 17.89,80.15 17.51,79.77 5.75,79.77 v1(4.68,78.7)
  IN2 w0.508: v1(4.68,78.7) 3.41,77.43 3.41,72.17 4.28,71.31 4.5,71.31 7.55,68.26 7.55,67.98 8.85,66.69 11.54,66.69 11.85,66.99 13.5,66.99 15.12,68.62 24.67,68.62 28.86,72.81 29.58,72.81 30.68,71.71 35.25,71.71 40.65,66.32 40.65,57.15 42.86,54.94 42.86,50.11 42.07,49.32 42.07,44.87 41.44,44.23 41.44,36.48 46.02,31.89 v1(46.02,26.99) 46.22,27.19 46.9,27.19 47.46,26.63 47.46,13.07 v3(51.85,8.67)
  vias: v4(53.48,3.6)
+3.3V_SUS_U57:
  vias: v2(47.06,31.86)
+3.3V_VCCPRTCSUS: length 22.2
  TOP w0.254: v1(28.25,93.13) 28.53,93.13 UH1.K8
  IN4 w0.254: v1(28.25,93.13) 28.33,93.13 28.74,93.53 28.74,93.86 29.04,94.17 29.04,94.47 29.88,95.31 29.88,95.84 30.49,96.45 32.34,96.45 32.95,97.06 32.95,98.13 32.6,98.49 29.83,98.49 29.45,98.87 26.12,98.87 v1(26.07,98.92)
  BOTTOM w0.254: v1(26.07,98.92) 25.18,99.81 CH53.1 24.61,100.68 24.56,100.68 v2(23.22,102.02) 23.06,102.02 22.58,102.5 RH240.2
+3.3V_WLAN: length 21.7
  TOP w0.254: v1(130.64,157.24) 130.64,159.84 R696.2
  BOTTOM w0.381: Q124.5 147.17,156.87 v1(146.97,157.06) ; Q124.2 149.88,156.87 v1(150.15,157.14)
  BOTTOM w0.508: v1(149.34,158.53) R718.2 148.52,158.94 Q89.2 ; JMINI4.24 147.59,150.94 C606.2 148.26,150.96 v1(148.28,150.99) ; JMINI4.52 144.24,162.14 146.52,162.14 147.35,162.98 C607.2 147.71,163.61 v1(147.74,163.64) ; JMINI4.2 147.27,138.94 147.61,139.28 148.47,139.28 v1(148.5,139.3) ; R725.2 v1(149.31,162.09) ; v1(146.86,142.76) 146.89,142.78 R705.2 ; R692.2 v1(146.57,152.82)
  vias: v1(123.57,166.9) v1(123.9,167.38) v1(124.21,166.89) v1(130.67,156.6) v1(150.68,145.25) v1(150.68,144.59) v1(150.71,144) v3(138.7,154.33) v3(139.27,153.67) v3(142.54,159.22) v3(142.82,159.81) v4(151.55,143.88)
+3VALWP: length 12.7
  BOTTOM w0.508: PR100.1 252.25,64.26 258.99,57.52 258.99,57.19
  vias: v2(263.7,43.5)
+5V_ALW: length 468.7
  TOP w0.203: v1(44.45,30.2) 44.45,30.47 44.28,30.63 U57.4 ; U63.4 126.51,165.24 126.86,165.58 126.86,166.96 127.1,167.21
  TOP w0.508: v1(9.54,145.3) 9.51,145.34 Q79.3 ; R1629.1 146.11,141.78 v1(145.74,141.78) ; v3(127.19,168.73) 127.19,168.04 127.1,167.96 127.1,167.21 ; v1(253.48,105.74) 253.48,104.73 253.05,104.3 JPB1.2 ; PR531.2 v1(57.95,31.61) ; v1(116.9,167.09) 115.91,166.1 115.91,154.7 112.71,151.5 112.71,147.53 v1(111.69,146.52) ; Q75.3 9,148.47 v1(8.54,148.02) ; v1(49.51,32.1) PR520.2 ; v1(56.78,109.76) 55.99,110.55 55.99,112.14 58.02,114.17 63.57,114.17 68.2,109.54 73.62,109.54 74.19,110.11 78.58,110.11 v1(79.82,108.88)
  IN1 w0.508: v1(108.23,140.5) 108.23,140.55 111.08,143.41 111.08,143.82 112.35,145.08 112.35,145.87 v1(111.69,146.52)
  IN2 w0.508: v1(180.65,78.27) 182.81,78.27 186.11,74.97 198.95,74.97 202.95,70.96 202.95,66.5 211.13,58.33 217.18,58.33 v1(217.66,57.85) 233.87,57.85 241.03,65.01 251.19,65.01 258.81,57.39 263.58,57.39 264.58,56.4 v3(264.58,56.27) ; v1(154.57,142.58) 153.4,142.58 152.08,143.9 152.08,148.32 152.76,149.01 152.76,149.77 151.04,151.5 151.04,153.2 149.52,154.72 149.52,156.13 136.01,169.63 128.09,169.63 v3(127.19,168.73) 126.63,168.17 124.33,168.17 123.96,168.54 123.96,169.07 123.52,169.52 122.01,169.52 120.07,167.57 117.38,167.57 v1(116.9,167.09) 116.4,167.09 112.97,170.52 104.03,170.52 102.53,169.02 98.23,169.02 93.25,164.04 88.6,164.04 86.98,165.67 86.08,165.67 85.88,165.87 82.79,165.87 82.76,165.85 79.38,165.85 78.66,166.57 74.2,166.57 70.58,162.95 67.7,162.95 65.19,160.44 v1(65.19,158.99)
  IN2 w5.08: 262.24,91.43 262.24,86.65 271.94,76.95 271.94,39.48 262.21,29.75 262.21,25.06 262.24,25.03
  IN3 w0.508: v1(154.57,142.58) 154.57,141.73 157.13,139.17 157.13,128.62 v1(157.44,128.32) ; v1(217.66,57.85) 228.1,57.85 230.21,55.74 230.21,41.51 v3(230.54,41.18)
  IN4 w0.508: v1(108.23,140.5) 107.24,139.52 97.58,139.52 94.52,136.46 90.48,136.46 89.26,137.69 85.51,137.69 82.69,134.86 v1(82.53,134.86)
  BOTTOM w0.102: v3(22.39,143.42) 22.39,143.27 v4(22.84,142.81)
  BOTTOM w0.203: PU200.12 181.1,77.5 PR203.1 ; U35.4 118.86,108.67 118.68,108.85 118.29,108.85 117.89,108.45 117.89,107.66 ; U34.4 56.7,109.84 v1(56.78,109.76)
  BOTTOM w0.254: U37.4 50.44,74.25 50.11,73.92 v1(50.1,73.92) ; v3(264.58,56.27) 264.58,56.3 264.84,56.56 U43.4 ; U2.5 256.66,105.19 v1(256.87,104.99) ; v3(22.39,143.42) 22.31,143.42 21.98,143.75 PU300.7 ; v1(111.69,146.52) 111.79,146.42 U56.4 ; v1(82.53,134.86) 82.84,135.16 U38.4
  BOTTOM w0.508: v1(257.46,108.46) C715.1 259.52,108.46 R1614.2 ; v1(39.48,68.36) 38.57,68.36 37.84,69.09 PR501.2 ; v1(157.44,128.32) 157.44,128.2 155.86,126.63 PR1012.2 ; v1(17.38,148.07) 17.4,148.06 Q86.3 ; v1(145.74,141.78) 153.77,141.78 v1(154.57,142.58)
  vias: v1(43.52,30.43) v1(43.54,29.83) v1(43.8,29.3) v1(65.16,158.38) v1(65.49,157.87) v1(65.85,158.99) v1(65.85,158.38) v1(256.28,23.4) v1(256.28,22.77) v1(256.98,23.4) v1(256.98,22.77) v1(257.62,23.4) v1(257.62,22.77) v1(258.25,23.4) v1(258.25,22.77) v3(5.16,83.09) v3(5.16,82.46) v3(5.16,81.82) v3(5.16,81.19) v3(5.88,83.09) v3(5.88,82.46) v3(5.88,81.82) v3(5.88,81.19) v3(6.51,81.82) v3(6.51,81.19) v3(49.56,70.14) v3(49.56,69.51) v3(49.56,68.87) v3(50.2,70.14) v3(50.2,69.51) v3(50.2,68.87) v3(50.83,70.14) v3(50.83,69.51) v3(50.83,68.87) v3(51.47,70.14) v3(51.47,69.51) v3(51.47,68.87) v3(95.73,23.06) v3(96.35,23.24) v3(96.67,22.68) v3(96.99,23.24) v3(97.06,20.46) v3(97.14,22.01) v3(97.13,21.12) v3(97.32,22.64) v3(97.62,23.24) v3(97.7,21.4) v3(97.67,20.76) v3(97.61,20.13) v3(97.77,22.03) v3(97.98,22.69) v3(98.33,23.24) v3(117.94,106.79) v3(118.4,107.25) v3(118.55,106.44) v3(119.13,106.84) v3(119.13,106.18) v3(131.94,17.71) v3(131.96,17.08) v3(131.96,16.44) v3(131.96,15.81) v3(132.6,17.71) v3(132.6,17.08) v3(132.6,16.44) v3(132.6,15.81) v3(133.23,17.74) v3(133.23,17.1) v3(133.23,16.44) v3(133.23,15.81) v3(133.88,17.1) v3(133.88,16.47) v3(133.88,15.81) v3(230.54,40.55) v3(231.17,41.18) v3(231.17,40.55) v3(231.81,41.18) v3(231.81,40.55) v3(232.44,41.18) v3(232.44,40.55) v3(236.25,41.18) v3(236.25,40.55) v3(236.89,41.18) v3(236.89,40.55) v3(237.52,41.18) v3(237.52,40.55) v3(238.16,41.18) v3(238.16,40.55) v3(256.19,96.05) v3(256.19,95.41) v3(256.19,94.78) v3(256.19,94.14) v3(256.32,96.68) v3(256.83,94.78) v3(256.83,94.14) v3(257.46,95.03) v3(257.46,94.4) v3(257.46,93.76) v4(52.45,72.06) v4(117.98,106.09)
+5V_ALW2: length 1.4
  BOTTOM w0.102: PC118.1 245.12,56.17 v2(244.6,55.65)
+5V_ALW_R: length 3.6
  TOP w0.508: R1629.2 C290.1 v2(147.33,139.34) 147.33,138.91 147.1,138.68 U4.1
+5V_ESATA_PWR:
  vias: v1(65.16,166.96) v1(65.76,167.61) v1(65.76,166.98) v1(66.39,167.61) v1(66.39,166.98) v4(65.31,165.5)
+5V_HDD: length 1.8
  BOTTOM w0.102: 168.18,71.16 v4(166.4,71.16)
  vias: v3(169.58,71.03) v3(169.58,70.39) v3(169.58,69.76) v3(169.58,69.12)
+5V_MOD: length 2.6
  TOP w0.102: v1(42.11,37.98) 42.02,37.89 42.02,36.26
  BOTTOM w0.102: v1(42.11,37.98) 42.11,37.68 v4(41.72,37.29)
+5V_MXM:
  vias: v3(122.46,106.84) v3(122.46,106.21) v3(123.22,106.84) v3(123.22,106.21) v3(124.11,106.21) v4(124.11,105.34)
+5V_MXM_U35:
  vias: v2(123.49,107.49)
+5V_RUN: length 232.1
  TOP w0.305: JUSH1.14 55.55,5.69 v1(55.51,5.65)
  TOP w0.508: v1(85.63,132.12) 85.04,131.52 R1537.1 ; JKB1.10 JKB1.9 182.47,113.5 C758.1 v1(183.12,113.5) ; U6.1 80.56,162.3 v1(80.56,161.67) ; v1(24.75,148.75) 24.79,148.71 R2153.1 ; R12.1 42.15,141.56 v1(42.3,141.72) ; v3(92.59,171.28) 90.99,169.68 90.99,160.67 91.52,160.13 91.52,156.55 v1(91.58,156.5)
  IN1 w0.508: v1(24.75,148.75) 24.75,145.76 25.51,144.99 25.51,142.96 26.93,141.54 26.93,131.81 22.36,127.24 15.2,127.24 v1(14.89,127.54)
  IN2 w0.508: v1(173.77,71.92) 175.29,71.92 175.85,72.48 180.68,72.48 182.3,74.1 198.91,74.1 201.33,71.68 201.33,67.23 210.91,57.64 212.38,57.64 v1(212.45,57.57) ; 44.56,35.32 44.56,34.25 46.66,32.15 46.66,28.36 48.17,26.85 48.17,21.88 48.6,21.45 51.55,21.45 52.28,20.71 52.28,18.37 51.42,17.51 51.42,13.09 54.34,10.17 55.13,10.17 57.21,8.09 57.21,7.35 v1(55.51,5.65) ; v1(9.96,154.7) 10.01,154.65 13.08,154.65 15.29,152.44 16.29,152.44 17.13,151.6 20.4,151.6 21.8,150.2 23.76,150.2 24.75,149.21 v1(24.75,148.75)
  IN3 w0.508: v1(42.3,141.72) 41.82,142.2 41.82,150.91 40.39,152.34 40.39,156.42 40.01,156.8 40.01,158.15 40.9,159.04 40.9,161.94 40.22,162.62 39.2,162.62 37.19,164.63 37.19,165.72 v1(37.22,165.75)
  IN4 w0.508: v1(80.03,139.88) 81.66,139.88 90.38,148.6 90.38,154.67 v1(91.58,155.87)
  BOTTOM w0.203: U19.21 81.09,156.35 v1(80.55,155.81)
  BOTTOM w0.508: R2193.1 213.18,61.19 213.6,60.77 213.6,59.24 212.45,58.1 v1(212.45,57.57) ; v1(80.03,139.88) 80.03,139.41 81.06,138.38 81.06,138.3 81.77,137.58 81.77,133.56 83.22,132.12 v1(85.63,132.12) ; U5.1 24.8,166.61 v1(24.16,167.24) ; C56.1 v1(55.51,5.65)
  vias: v1(4.25,94.47) v1(4.23,93.86) v1(9.31,154.72) v1(14.89,128.18) v1(78.62,158.35) v1(78.8,158.91) v1(88.93,157.74) v1(90.81,159.6) v1(156.88,92.75) v1(156.88,92.11) v1(157.56,92.82) v1(157.56,92.21) v1(157.54,91.58) v1(158.17,92.77) v1(158.17,92.16) v1(158.15,91.53) v1(158.78,92.11) v1(158.78,91.48) v1(173.14,73.06) v1(173.16,71.89) v1(173.77,73.06) v1(178.39,121.88) v1(178.75,122.39) v1(178.95,121.52) v1(179.08,122.92) v1(179.31,122.03) v1(179.64,122.57) v1(183.73,113.5) v3(4.66,72.22) v3(5.18,72.62) v3(5.18,71.82) v3(5.69,72.21) v3(14.69,132.19) v3(15.32,131.94) v3(55.18,73.19) v3(55.3,76.36) v3(55.3,75.73) v3(55.3,75.09) v3(55.3,74.46) v3(55.3,73.82) v3(55.81,73.19) v3(55.94,76.36) v3(55.94,75.73) v3(55.94,75.09) v3(55.94,74.46) v3(55.94,73.82) v3(82.08,171.49) v3(82.97,171.49) v3(93.51,171.36) v3(95.28,173.26) v3(173.45,142.59) v3(173.43,141.96) v3(173.41,141.31) v3(173.41,140.68) v3(174.13,90.71) v3(174.63,90.33) v3(175.09,89.88) v3(175.57,89.39) v4(7.97,98.5)
+5V_RUN_U37:
  vias: v2(52.28,77.89)
+5V_USB_PWR1:
  vias: v1(256.1,103.69) v1(256.1,103.06) v1(256.65,104.2) v1(256.73,103.62) v1(256.73,103.03) v1(262.61,107.73) v1(262.61,107.1) v1(263.24,107.73) v1(263.24,107.1) v1(263.76,107.45) v3(260.26,115.35) v3(260.26,114.72) v3(260.89,115.35) v3(260.89,114.72) v4(256.18,116.16)
+5V_USB_PWR2:
  vias: v1(257.43,103.68) v1(257.43,103.05) v1(258.07,103.68) v1(258.07,103.05) v1(258.66,103.67) v1(263.62,129.04) v1(264.91,133.02) v1(265.03,132.39) v1(265.57,133.03) v1(265.7,132.39) v4(259.08,103.07)
+5VALWP: length 31.6
  IN4 w0.254: v1(243.11,64.4) 243.11,64.43 242.48,65.06 241.26,65.06 234.2,58 v1(234.2,57.26)
  IN4 w0.381: v3(234.6,55.08) 234.6,55.66 239.99,61.05 244.18,61.05 245.04,60.18 245.04,59.14 246.05,58.14 v3(246.05,57.08)
  BOTTOM w0.203: v3(246.05,57.08) 246.18,57.22 PU101.14
  BOTTOM w0.254: PR101.1 243.17,64.34 v1(243.11,64.4)
  vias: v2(229.88,57.52)
+VCC_4021: length 15.2
  TOP w0.254: U29.1 170.82,136.18 171.08,136.44
  TOP w0.508: v1(167.72,138.57) R392.2 ; 171.08,136.44 v2(171.84,137.2) 172.16,137.51 172.56,137.51 173.52,138.47 C1180.1 C318.1 173.87,137.58 v1(173.19,136.89) 173.57,136.51 R394.2
  BOTTOM w0.508: v1(167.72,138.57) 167.8,138.49 170.87,138.49 172.47,136.89 v1(173.19,136.89)
+VCC_CORE: length 161
  TOP w0.254: 57.9,68.82 57.9,69.17 57.21,69.86 57.21,73.34 57.64,73.77 59.55,73.77 60.36,74.59 RC66.1 ; PR544.1 58.84,38.39 v1(58.71,38.52) ; PL501.1 v1(52.74,48.3) ; v1(82.12,59.75) JCPU1.Y25 ; PL500.1 52.74,68.87 v1(53.12,69.25) ; PL502.1 v1(52.74,59.09) ; PR555.1 54.26,38.39 v1(54.14,38.52) ; v1(56.45,38.49) 56.55,38.39 PR512.2
  TOP w0.279: v1(79.12,59.75) JCPU1.Y28 ; 78.61,67.28 JCPU1.AH29 ; 74.61,67.28 JCPU1.AH33 ; v1(73.12,65.75) JCPU1.AF34 73.61,65.28 ; 78.61,68.28 JCPU1.AJ29 ; 78.61,61.28 JCPU1.AB29 v1(78.12,61.75) ; JCPU1.V26 81.61,57.28 ; JCPU1.AB31 76.61,61.28 ; JCPU1.AF35 72.61,65.28 ; v1(79.12,61.75) JCPU1.AB28 79.61,61.28 ; JCPU1.AD33 74.61,63.28 ; JCPU1.AF25 v1(82.12,65.75) ; JCPU1.AG32 75.61,66.28 ; 72.61,67.28 JCPU1.AH35 ; v1(78.12,59.75) JCPU1.Y29 ; JCPU1.AD35 72.61,63.28 ; v1(80.12,59.75) JCPU1.Y27 ; JCPU1.AF32 75.61,65.28 ; 73.61,67.28 JCPU1.AH34 ; 73.61,64.28 JCPU1.AE34 v1(73.12,64.75) ; 81.61,68.28 JCPU1.AJ26 ; JCPU1.AD34 73.61,63.28 ; JCPU1.AF33 74.61,65.28 ; 81.61,67.28 JCPU1.AH26 ; v1(81.12,58.75) JCPU1.W26 ; JCPU1.AA34 73.61,60.28 ; JCPU1.AB32 75.61,61.28 ; JCPU1.AB25 v1(82.12,61.75) ; 75.61,67.28 JCPU1.AH32 ; v1(81.12,59.75) JCPU1.Y26 ; 80.61,61.28 JCPU1.AB27 v1(80.12,61.75) ; 81.61,61.28 JCPU1.AB26 v1(81.12,61.75) ; JCPU1.AC34 73.61,62.28 ; 72.61,68.28 JCPU1.AJ35 ; 77.61,61.28 JCPU1.AB30
  TOP w0.305: JCPU1.AD28 v1(79.12,63.75) ; JCPU1.AD30 v1(77.12,63.75) ; JCPU1.Y34 v1(73.12,59.75) ; v1(75.12,66.75) JCPU1.AG32 ; JCPU1.AD25 v1(82.12,63.75) ; JCPU1.AJ34 v1(73.12,68.75) ; JCPU1.AE30 v1(77.12,64.75) ; JCPU1.AG26 v1(81.12,66.75) ; v1(72.14,63.74) JCPU1.AD35 ; v1(82.12,52.75) JCPU1.N25 ; JCPU1.W27 v1(80.12,58.75) ; JCPU1.AD31 v1(76.12,63.75) ; JCPU1.AH31 v1(76.12,67.75) ; JCPU1.Y30 v1(77.12,59.75) ; v1(72.14,65.75) JCPU1.AF35 ; JCPU1.AC30 v1(77.12,62.75) ; JCPU1.AE26 v1(81.12,64.75) ; JCPU1.AD27 v1(80.12,63.75) ; JCPU1.AJ35 v1(72.17,68.77) ; JCPU1.Y35 v1(72.17,59.75) ; JCPU1.AA28 v1(79.12,60.75) ; v1(82.12,51.75) JCPU1.M25 ; v1(82.12,53.75) JCPU1.P25 ; v1(81.12,57.75) JCPU1.V26 ; v1(74.12,65.75) JCPU1.AF33 ; JCPU1.Y33 v1(74.12,59.75) ; JCPU1.AC32 v1(75.12,62.75) ; JCPU1.AA32 v1(75.12,60.75) ; v1(82.12,57.75) JCPU1.V25 ; v1(76.12,61.75) JCPU1.AB31 ; JCPU1.AJ31 v1(76.12,68.75) ; v1(73.12,60.75) JCPU1.AA34 ; JCPU1.AH35 v1(72.14,67.75) ; JCPU1.AH33 v1(74.12,67.75) ; JCPU1.Y32 v1(75.12,59.75) ; JCPU1.AH34 v1(73.12,67.75) ; JCPU1.AC26 v1(81.12,62.75) ; JCPU1.AJ25 v1(82.12,68.75) ; JCPU1.AH25 v1(82.12,67.75) ; JCPU1.AB30 v1(77.12,61.75) ; JCPU1.AC28 v1(79.12,62.75) ; JCPU1.AD26 v1(81.12,63.75) ; JCPU1.AB35 v1(72.14,61.76) ; JCPU1.AF29 v1(78.12,65.75) ; JCPU1.AG34 v1(73.12,66.75) ; v1(75.12,61.75) JCPU1.AB32 ; JCPU1.AH32 v1(75.12,67.75) ; JCPU1.AH27 v1(80.12,67.75) ; JCPU1.Y31 v1(76.12,59.75) ; JCPU1.AB34 v1(73.12,61.75) ; JCPU1.AH30 v1(77.12,67.75) ; JCPU1.AD29 v1(78.12,63.75) ; JCPU1.AH29 v1(78.12,67.75) ; JCPU1.AJ30 v1(77.12,68.75) ; v1(82.12,50.75) JCPU1.L25 ; v1(82.12,56.75) JCPU1.U25 ; JCPU1.AA26 v1(81.12,60.75) ; JCPU1.AH26 v1(81.12,67.75) ; JCPU1.AF26 v1(81.12,65.75) ; JCPU1.AJ32 v1(75.12,68.75) ; JCPU1.AJ33 v1(74.12,68.75) ; v1(75.12,65.75) JCPU1.AF32 ; JCPU1.AH28 v1(79.12,67.75) ; JCPU1.AG30 v1(77.12,66.75) ; JCPU1.AE32 v1(75.12,64.75) ; JCPU1.AF31 v1(76.12,65.75) ; JCPU1.AA30 v1(77.12,60.75) ; v1(82.12,55.75) JCPU1.T25 ; JCPU1.G25 82.54,46.28 v1(82.12,46.7) ; JCPU1.AE28 v1(79.12,64.75) ; JCPU1.F25 v1(82.12,45.75) ; JCPU1.AF30 v1(77.12,65.75) ; JCPU1.AD32 v1(75.12,63.75) ; v1(73.12,62.75) JCPU1.AC34 ; JCPU1.AJ26 v1(81.12,68.75) ; v1(74.12,63.75) JCPU1.AD33 ; v1(82.12,54.75) JCPU1.R25 ; JCPU1.AB33 v1(74.12,61.75) ; v1(81.12,56.75) JCPU1.U26 81.59,56.28 ; JCPU1.AF27 v1(80.12,65.75) ; JCPU1.J25 v1(82.12,48.75) ; v1(73.12,63.75) JCPU1.AD34 ; JCPU1.AJ29 v1(78.12,68.75) ; JCPU1.AJ27 v1(80.12,68.75) ; v1(81.12,49.75) JCPU1.K26 ; JCPU1.AJ28 v1(79.12,68.75) ; JCPU1.AF28 v1(79.12,65.75) ; JCPU1.AG28 v1(79.12,66.75)
  TOP w0.381: JCPU1.K25 82.59,49.22 v1(82.12,48.75)
  IN1 w0.254: v1(53.12,69.25) 52.93,69.06 52.93,68.72 53.16,68.49 55.82,68.49 57.57,66.74 57.57,50.84 58.58,49.82 58.58,38.64 v1(58.71,38.52) ; v1(52.74,59.09) 53.33,59.09 55.16,57.26 55.71,57.26 56.8,56.17 56.8,49.89 57.69,49 57.69,40.61 56.3,39.22 56.3,38.64 v1(56.45,38.49) ; v1(52.74,48.3) 52.87,48.3 53.37,47.79 54.55,47.79 55.15,47.18 55.15,40.3 54.01,39.15 54.01,38.64 v1(54.14,38.52)
  vias: v1(83.12,68.75) v1(83.12,67.75) v1(83.12,65.75) v1(83.12,63.75) v1(83.12,61.75) v1(83.12,59.75) v1(83.12,57.75) v1(83.12,56.75) v1(83.12,55.75) v1(83.12,54.75) v1(83.12,53.75) v1(83.12,52.75) v1(83.12,51.75) v1(83.12,50.75) v1(83.12,48.75) v3(50.2,67.6) v3(50.2,66.71) v3(50.2,64.68) v3(50.2,63.66) v3(50.2,62.65) v3(50.2,61.63) v3(50.2,60.62) v3(50.2,52.49) v3(50.2,51.47) v3(50.2,50.46) v3(50.2,49.44) v3(50.2,48.42) v3(50.25,65.97) v3(50.3,65.31) v3(50.96,67.22) v3(50.96,66.2) v3(50.96,65.19) v3(50.96,63.16) v3(50.96,62.14) v3(50.96,61.12) v3(50.96,60.11) v3(50.96,53) v3(50.96,51.98) v3(50.96,50.96) v3(50.96,49.95) v3(50.96,49.19) v3(50.96,48.55) v3(50.96,47.92) v3(51.11,64.37) v3(51.47,59.22) v3(51.75,63.74) v3(51.72,49.44) v3(51.72,48.42) v3(51.85,59.98) v3(51.85,53.38) v3(52.38,64.37) v3(53.02,63.74) v3(53.63,59.98) v3(53.63,49.69) v3(53.63,48.42) v3(54.14,49.06) v3(54.49,66.63) v3(54.52,65.92) v3(54.52,65.19) v3(54.52,64.17) v3(54.52,63.16) v3(54.52,62.14) v3(54.52,61.12) v3(54.52,60.11) v3(54.52,59.22) v3(54.64,53.63) v3(54.64,52.23) v3(54.64,50.96) v3(54.64,49.69) v3(54.64,48.42) v3(54.85,54.9) v3(55.28,53) v3(55.28,51.6) v3(55.28,50.33) v3(55.28,49.06) v3(55.41,66.46) v3(55.41,65.57) v3(55.41,63.79) v3(55.41,62.65) v3(55.41,60.62) v3(55.41,59.73) v3(55.41,58.33) v3(55.79,50.96) v3(55.79,49.69) v3(55.79,48.42) v3(66.46,68.31) v3(66.46,66.08) v3(66.46,65.39) v3(66.46,63.61) v3(66.46,62.32) v3(66.46,61.05) v3(66.46,59.78) v3(66.46,58.51) v3(66.43,57.24) v3(85.76,66.71) v3(85.71,65.03) v3(85.71,63.29) v3(85.71,61.38) v3(85.71,59.48) v3(85.71,57.57) v3(85.71,55.59) v3(85.71,53.76) v3(85.71,51.86) v3(85.71,49.95) v3(85.71,48.05) v3(88.93,64.3) v3(88.93,63.66) v3(89.32,64.93) v3(89.57,64.3) v3(89.95,64.93) v3(90.33,64.3) v3(90.59,64.93) v3(91.35,67.73) v3(91.35,67.09) v3(91.35,66.46) v4(62.7,53.13)
+VCCADAC: length 5.6
  TOP w0.254: v1(30.64,108.77) 30.64,108.76 UH1.P45
  BOTTOM w0.102: 30.67,108.75 30.6,108.75 30.29,108.43 v2(30.29,108.13)
  BOTTOM w0.508: LH1.2 29.6,110.72 CH20.1 30.95,110.67 CH18.1 30.95,109.43 31.33,109.05 CH19.1 30.67,108.75 v1(30.64,108.77)
+VCCIO2PCH: length 172.4
  TOP w0.305: v1(36.79,94.4) 36.51,94.4 UH1.AJ12 36.2,95.18 36.1,95.29 UH1.AJ14
  TOP w0.508: v1(86.32,31.18) 86.37,31.13 87.05,31.13 87.38,31.46 87.38,33.02 CC137.1 ; RC106.2 CC137.1 ; CC137.1 91.49,38.85 106.61,38.85 112.61,44.84 112.61,78.9 111.62,79.89 110.87,79.89 110.3,80.47 110.3,82.81 109.53,83.58 109.28,83.58 103.77,89.09 99.07,89.09 96.86,86.88 v2(93.2,86.88) 87.42,86.88 84.39,89.91 84.39,93.14 83.21,94.32 74.13,94.32 70.16,90.36 58.84,90.36 54.98,94.22 54.82,94.22 52.79,96.25 v1(52.79,97.06)
  BOTTOM w0.254: 39.35,94.83 39.15,95.03 39.15,95.3 39.65,95.79 41.31,95.79 41.82,95.29 41.82,94.78 41.26,94.78 41.23,94.8 40.08,94.8 40.05,94.83 39.35,94.83
  BOTTOM w0.508: v1(36.79,94.4) 36.79,94.55 37.35,95.11 38.62,95.11 38.69,95.03 39.15,95.03 ; 41.82,94.78 CH60.1 43.46,94.78 CH62.1 CH61.1 44.37,94.79 45.8,96.23 47.2,96.23 47.89,96.91 50.46,96.91 51.39,97.84 52.04,97.84 52.79,97.09 v1(52.79,97.06) ; v1(86.32,31.18) 86.32,31.14 R105.2
+VCCIO2PCH_R: length 5.3
  TOP w0.508: JCPU1.A23 84.59,40.04 84.51,39.96 84.51,39 85.25,38.26 v2(85.25,36.43) RC106.1
+VCCIO_OUT: length 306.5
  TOP w0.254: JXDP1.44 72.2,16.19 v1(72.22,16.17) ; v1(141.11,134.91) 142.38,136.18 148.4,136.18 148.83,135.75 155.99,135.75 R399.1
  TOP w0.279: v1(72.32,10.45) 72.3,10.45 72.2,10.55 JXDP1.43
  TOP w0.457: JCPU1.AN35 71.15,73.72 71.15,80.24
  TOP w0.508: v1(57.21,74.55) 56.73,75.03 56.73,77.22 57.01,77.5 v1(57.01,77.8) ; v1(86.22,80.76) 84.69,82.28 RC60.1 ; v1(73.19,80.76) 71.67,80.76 71.15,80.24 ; v1(85.58,31.43) 85.58,31.58 79,38.16 71.59,38.16 68.61,41.13 v1(62.57,41.13) ; RC44.1 76.06,80.94 v1(75.88,80.76)
  IN1 w0.254: v1(146.11,111.57) 145.86,111.82 145.86,115.56 146.04,115.74 146.04,128.1 141.11,133.03 v1(141.11,134.91)
  IN1 w0.508: v1(72.22,16.17) 72.22,17.97 72.98,18.73 72.98,21.09 75.62,23.73 76.78,23.73 82.95,29.91 84.24,29.91 84.63,30.3 85.34,30.3 85.68,30.64 85.68,31.33 v1(85.58,31.43)
  IN2 w0.508: v1(73.19,80.76) 71.11,78.67 58.42,78.67 57.54,77.8 v1(57.01,77.8) ; v1(57.21,74.55) 57.21,74.28 56.54,73.61 56.54,47.17 v1(62.57,41.13) ; v1(72.32,10.45) 72.32,11.42 72.88,11.97 72.88,14.23 72.22,14.9 v1(72.22,16.17)
  BOTTOM w0.254: v1(146.11,111.57) 145.16,112.51 143.7,112.51 140.51,109.32 139.84,109.32 135.09,104.57 v4(129.49,104.57) 115.9,104.57 113.52,102.19 109.91,102.19 107.65,99.93 107.65,97.75 104,94.09 99.78,94.09 98.15,92.47 98.15,89.52 94.32,85.68 94.32,82.92 91.63,80.22 86.62,80.22 86.22,80.63 v1(86.22,80.76)
  BOTTOM w0.508: v1(72.22,16.17) 72.22,16.72 CC66.1 ; v1(57.21,74.55) 57.63,74.13 58.84,74.13 58.91,74.2 RC63.1 ; v1(86.22,80.76) 85.58,80.12 76.51,80.12 v1(75.88,80.76) v1(73.19,80.76) ; RC128.1 57.87,78.65 57.02,77.8 v1(57.01,77.8) ; PR500.2 PR503.2 PR504.2 50.96,22.13 59.39,13.7 59.39,10.82 61.03,9.18 71.89,9.18 72.32,9.61 v1(72.32,10.45) 72.32,10.73 73.06,11.47 CC65.1 ; v1(62.57,41.13) 63.2,41.77 RC65.2
+VCCST: length 15.8
  TOP w0.457: JCPU1.AK31 v1(76.12,69.75)
  BOTTOM w0.254: 73.08,70.78 72.65,70.34 72.65,69.56 72.96,69.25 75.63,69.25 v1(76.12,69.75) 75.62,70.25 74.82,70.25 74.3,70.78 73.08,70.78 ; 73.08,70.78 72.96,70.9
  BOTTOM w0.508: 72.96,70.9 72.42,71.44 v2(69.49,71.44) 69.3,71.44 68.94,71.79 CC78.1
GND: length 2200.4
  TOP w0.102: RC70.2 v4(59.58,28.05) ; v1(105.32,169.91) v4(105.32,170.52) ; v1(90.08,34.5) 89.38,34.5 v4(89.35,34.48) ; v1(126.15,159.09) v4(126.15,159.65) ; v1(114.55,136.05) v4(115.13,136.05) ; v1(134.67,141.74) 135.45,141.74 v4(135.45,141.74) ; v4(151.38,169.15) 151.41,169.17 v1(152.05,169.17) ; v4(137.02,158.52) 137.04,158.54 v1(137.67,158.54) ; 23.75,104.75 24.43,104.07 25,104.07 UH1.B35 ; JCPU1.V10 v1(98.12,56.75) ; v1(98.33,165.87) v4(98.33,166.44)
  TOP w0.127: v1(45.77,107.27) 45.77,107.31 45.27,107.81 44.31,107.81 43.99,107.49 43.99,107.44 UH1.BE41 ; v1(30.49,100.58) 30.46,100.58 ; v1(31.15,95.71) 31.15,95.72 ; v1(71.85,158.89) v4(71.85,159.6) ; v1(30.49,98.96) 30.46,98.96
  TOP w0.203: v1(26.63,154.49) 26.59,154.54 U9.43 ; v1(41.95,100.66) 41.95,99.94 UH1.BB25 41.92,99.12 UH1.BC22 41.79,98.69 41.54,98.44 41.54,98.03 UH1.AY20 41.81,97.32 v1(41.87,97.32) 41.9,97.32 42.05,97.47 UH1.BD19 ; v1(41.95,100.66) 42.35,101.06 UH1.BC28 ; v1(41.95,100.66) 41.79,100.82 41.79,100.95 41.39,101.35 41.33,101.35 UH1.AY29 ; v1(41.95,100.66) 41.67,100.38 UH1.AY26 ; UH1.D25 25.89,99.83 25.89,99.36 25.68,99.15 25.15,99.15 UH1.B23 ; UH1.P43 30.36,107.5 v1(30.69,107.18) ; U629.41 v1(32.88,153) ; v1(35.04,147.84) 35.23,148.03 U629.53 ; U630.33 61.7,143.07 v1(61.62,143.15) ; v1(65.64,134.67) 65.57,134.74 U630.57 ; v1(63.81,134.69) 63.97,134.85 U630.53 ; v1(40.62,157.62) 40.62,157.21 39.61,156.2 U629.18 ; U629.57 v1(36.83,147.84) ; U63.11 123.07,165.24 C554.2 ; U629.33 v1(32.88,156.2) ; U630.18 v1(68.37,143.07) ; U9.26 v1(17.79,155.33) ; U630.41 v1(61.58,139.87) ; U629.8 v1(39.58,152.2) ; U630.8 v1(68.39,139.07) ; U9.38 v1(23.26,152.77) ; UH1.AV6 UH1.AV7 ; U9.35 v1(22.06,152.77) ; v1(37.19,107.18) 37.3,107.07 38.01,107.07 38.01,107.1 UH1.AP43 38.49,107.5 v1(38.82,107.18) ; U57.11 v1(44.28,32.19) ; v1(67.6,10.45) 67.7,10.55 JXDP1.25
  TOP w0.229: v1(25.86,102.35) 25.86,102.16 26.33,101.69 26.33,101.59 UH1.F29
  TOP w0.254: 49.3,135.95 49.3,135.95 JEDP1.40 ; 49.31,140.96 49.32,140.95 JEDP1.30 ; JEDP1.23 49.5,144.45 v1(49.18,144.13) ; v1(32.47,95.71) 32.47,95.62 32.79,95.3 UH1.Y14 ; v1(32.47,95.71) 33.05,95.71 UH1.AA16 34.12,96.77 UH1.AD18 ; v1(32.47,95.71) 32.29,95.53 32.29,95.51 32.14,95.35 UH1.V14 ; v1(32.47,95.71) 32.8,96.04 UH1.Y16 ; v1(32.47,95.71) 32.14,96.04 UH1.V16 ; UH1.K15 28.34,95.86 28.05,95.57 v1(28.05,95.41) 28.05,95.29 27.76,94.99 UH1.H13 ; UH1.K33 28.36,103.34 28.1,103.6 v1(28.1,103.85) 28.1,103.99 27.8,104.29 UH1.H36 ; v1(37.19,107.18) 36.87,107.5 UH1.AK43 UH1.AK45 ; 33.94,107.94 v1(33.94,107.18) 34.25,106.87 UH1.AD40 ; JEDP1.12 51.26,149.95 v1(51.35,149.86) ; UH1.AJ6 36.2,91.5 35.72,91.02 v1(35.57,91.02) UH1.AG2 ; UH1.AR2 38.82,90.92 v1(38.59,91.15) ; UH1.AJ18 36.1,97 v1(36.43,97.33) 36.1,97.66 UH1.AJ20 ; v1(259.18,130.13) D16.3 ; UH1.AB38 33.56,105.28 33.24,104.96 v1(33.13,104.96) 33.08,104.96 32.8,104.68 UH1.Y36 ; 49.32,145.45 49.32,145.45 JEDP1.21 ; UH1.AJ22 35.77,98.88 v1(35.77,98.96) 35.77,99.03 UH1.AJ24 ; JEDP1.22 49.27,144.95 49.26,144.96 ; UH1.AD16 34.12,96.04 v1(34.45,95.71) ; UH1.AJ38 36.14,105.28 35.87,105.01 v1(35.71,105.01) ; v1(25.89,92.62) 25.81,92.53 25.49,92.53 25.48,92.52 UH1.B7 ; UH1.AG26 35.44,100.25 v1(35.11,100.58) ; UH1.P32 30.16,102.94 UH1.R34 ; UH1.D25 25.99,99.94 v1(25.99,100.8) 25.78,100.8 25.7,100.72 UH1.B27 ; v1(96.12,46.75) 96.59,47.22 JCPU1.H11 ; UH1.N35 29.75,104.09 30.17,103.67 30.53,103.67 UH1.R34 ; UH1.D42 26,106.97 26.68,106.97 v1(26.7,106.94) ; UH1.L2 v1(29.07,91.02) 29.09,91.02 29.73,91.65 UH1.N6 ; v1(34.45,95.71) 34.27,95.53 34.27,95.51 34.12,95.35 UH1.AD14 33.64,94.82 UH1.AB12 ; v1(34.45,95.71) 35.03,95.71 UH1.AG16 35.86,95.69 36.42,95.69 v1(36.43,95.71) ; v1(34.45,95.71) 34.78,96.04 UH1.AE16 ; UH1.U38 31.39,104.99 v1(31.2,104.99) 30.94,104.99 30.7,105.22 UH1.R38 ; JCPU1.M11 v1(97.12,50.75) ; 39.53,97.81 39.53,97.75 39.83,97.45 v1(39.83,97.32) ; UH1.AF8 34.81,92.49 v1(34.71,92.49) 34.63,92.49 34.25,92.87 UH1.AD8 ; 39.53,96.84 39.51,96.84 39.18,96.51 39.18,96.29 v1(39.19,96.28) 39.18,96.27 39.18,96.2 39.53,95.86 39.53,95.77 39.81,95.49 v1(39.81,95.29) 39.81,95.19 40.12,94.88 UH1.AV13 ; 23.75,104.75 22.18,104.75 v1(22.12,104.68) ; UH1.B39 25.82,105.6 v1(26.02,105.4) ; UH1.F43 27.03,107.53 UH1.G44 ; UH1.G38 27.17,105.28 28.01,105.28 v1(28.23,105.5) ; JCPU1.AL19 88.65,70.28 v1(89.12,70.75) ; v1(35.11,100.58) 34.78,100.91 UH1.AE28 ; v1(35.11,100.58) 35.44,100.91 UH1.AG28 ; v1(41.54,106.41) 41.51,106.39 UH1.BA40 41.75,105.6 UH1.BD39 ; UH1.AN40 38.15,106.48 38.15,106.93 38.01,107.07 ; 49.32,140.45 49.33,140.45 JEDP1.31 ; UH1.D4 26.16,90.97 v1(26.53,90.97) ; UH1.AL38 37.49,105.28 37.66,105.1 v1(37.68,105.12) 37.73,105.12 UH1.AN36 ; v1(38.82,107.18) 39.15,107.5 UH1.AT43 ; UH1.U10 31.43,93.25 v1(31.12,93.25) 31.07,93.2 31,93.2 UH1.R8 ; UH1.W44 v1(32.32,107.18) 31.99,107.5 31.91,107.5 31.5,107.1 UH1.U42 31.28,107.3 31.28,107.33 UH1.T43 31.02,107.5 v1(30.69,107.18) UH1.R44 ; v1(41.83,102.67) 41.84,102.66 41.84,102.65 42.15,102.35 UH1.BD31 ; RH146.2 23.4,112.87 22.51,111.98 CH16.2 ; UH1.N10 29.38,93.17 v1(29.16,93.17) ; UH1.R34 30.7,103.43 31,103.13 31.45,103.13 31.68,103.36 UH1.U34 31.97,103.49 v1(32.17,103.69) 32.19,103.66 32.49,103.66 UH1.Y34 ; UH1.R2 v1(30.69,91.02) ; UH1.AW2 40.45,90.97 v1(40.42,90.99) 40.12,91.3 UH1.AV6 ; UH1.H17 27.76,96.85 28.05,97.14 v1(28.05,97.32) 28.05,97.45 28.36,97.75 UH1.K20 ; 33.94,90.26 v1(33.94,91.02) 34.25,91.32 UH1.AD6 ; UH1.G8 27.25,92.83 v1(27.75,92.83) 27.77,92.81 UH1.H7 ; JCPU1.W10 97.59,58.22 v1(97.12,57.75) ; UH1.K29 28.05,101.66 28.05,102.04 UH1.H31 ; UH1.AD30 34.12,101.88 v1(33.79,102.21) 34.12,102.54 UH1.AD32 33.64,103.09 UH1.AB34 ; v1(39.89,99.91) 39.89,99.64 UH1.AV24 ; UH1.AY10 41.54,93.9 41.84,94.21 v1(41.84,94.19) 41.87,94.22 UH1.BD11 ; v1(39.76,93.4) 39.76,93.43 39.69,93.51 39.69,93.74 39.53,93.89 39.53,93.9 ; v1(30.49,100.58) 30.16,100.25 UH1.P26 ; UH1.AV31 40.13,102.38 39.84,102.67 v1(39.84,102.87) 39.84,103.01 40.13,103.3 UH1.AV33 ; UH1.F20 26.21,97.81 v1(25.86,97.47) UH1.B19 ; v1(36.43,95.71) 36.43,95.77 36.1,96.1 UH1.AJ16 ; v1(36.43,95.71) 36.76,95.37 UH1.AK14 36.76,95.12 UH1.AL12 37.18,94.71 37.42,94.95 UH1.AM14 37.42,95.3 37.73,95.61 v1(37.73,95.71) 37.73,95.71 38.29,95.16 UH1.AP13 ; UH1.K10 28.55,93.51 28.39,93.67 28.3,93.67 28.25,93.71 v1(28.25,93.71) 28.25,93.71 28.18,93.79 27.87,93.79 UH1.H10 ; UH1.H26 27.76,100.43 28.05,100.72 28.05,100.79 28.13,100.87 ; UH1.AY7 41.75,92.4 v1(41.99,92.64) 42.05,92.59 UH1.BD7 ; UH1.F8 26.56,92.79 v1(26.89,92.46) ; UH1.AN8 38.12,92.91 37.96,93.08 37.7,93.08 v1(37.68,93.1) 37.65,93.08 37.36,93.08 37.19,92.91 UH1.AL8 ; UH1.AF38 35.14,105.28 34.84,104.99 v1(34.74,104.99) ; v1(98.12,53.73) 97.59,54.26 JCPU1.R10 ; 39.53,100.38 39.53,100.44 39.83,100.75 v1(39.83,100.82) 39.83,101.05 39.53,101.36 ; UH1.AM16 37.41,96.11 37.09,95.79 v1(37.09,95.71) 36.76,96.04 UH1.AK16 ; UH1.B15 25.86,95.84 v1(25.88,95.86) UH1.F15 ; UH1.Y8 32.66,92.97 32.9,93.2 v1(33.18,93.2) 33.34,93.2 UH1.AB8 ; UH1.B31 v1(25.86,102.35) 26.35,102.83 26.35,103.11 26.55,103.31 UH1.F33 ; D14.3 257.84,113.13 v1(257.6,113.37) ; UH1.W2 v1(32.32,91.02) ; UH1.U16 31.48,96.05 31.15,95.72 30.82,96.05 UH1.R16 ; U29.2 170.32,136.5 v1(170.06,136.76) 169.82,136.52 U29.3 ; UH1.R14 30.82,95.37 v1(31.15,95.71) ; UH1.M22 29.91,98.79 UH1.P22 30.16,98.65 30.46,98.96 30.16,99.26 UH1.P24 30.12,99.4 UH1.M24 ; UH1.L44 v1(29.07,107.18) ; 30.46,100.58 30.16,100.89 UH1.P28 UH1.P30 ; JCPU1.AJ11 v1(97.12,68.75) ; v1(27.64,91.18) 27.64,91.16 27.38,90.91 UH1.G2 ; UH1.BB42 41.43,107.09 v1(41.35,107.17) ; UH1.AV22 39.83,98.5 v1(39.83,98.36) ; JEDP1.14 v1(51.82,148.95) ; JCPU1.L11 v1(97.12,49.75) ; JCPU1.E25 v1(82.12,43.75) ; UH1.AL2 v1(37.19,91.22) ; UH1.AY36 41.75,104.29 v1(42.07,103.97) UH1.BD35 ; UH1.AG44 v1(35.57,107.18) ; JCPU1.AK11 v1(97.12,69.75) ; U29.6 v1(168.32,136.88) ; UH1.B11 v1(25.86,94.22)
  TOP w0.279: v1(105.12,51.75) JCPU1.N3 ; JCPU1.AL15 v1(92.12,70.75) ; v1(103.12,67.75) JCPU1.AH4 ; v1(103.12,40.75) JCPU1.B4 ; JCPU1.AL23 84.59,70.29 v1(84.14,70.75) ; JCPU1.M6 v1(102.12,50.75) ; JCPU1.K8 v1(99.12,48.75) ; v1(105.12,40.75) JCPU1.B2 ; v1(70.62,19.59) 70.62,19.67 70.65,19.65 70.65,18.96 70.7,18.91 JXDP1.38 ; JXDP2.7 30.8,121.59 31.17,121.22 v1(31.2,121.22) 31.83,121.22 32.3,121.69 JXDP2.1 ; JCPU1.AG6 v1(102.12,66.75) ; JCPU1.AB9 v1(98.12,61.75) ; v1(104.12,72.75) JCPU1.AN4 ; JCPU1.AP13 v1(95.12,73.75) ; JCPU1.G4 v1(103.12,45.75) ; JCPU1.AC11 v1(97.12,62.75) ; v1(63.28,16.17) 63.2,16.25 JXDP1.8 ; v1(96.12,45.75) JCPU1.G11 ; v1(97.12,67.75) JCPU1.AH10 ; v1(94.12,40.75) JCPU1.B13 ; JCPU1.T7 v1(101.12,54.75) ; v1(82.13,42.74) 82.13,42.73 82.59,43.25 JCPU1.D25 ; v1(100.12,46.75) JCPU1.H7 ; JCPU1.AR19 v1(89.12,74.75) ; JCPU1.W4 v1(103.12,57.75) ; JCPU1.AL12 v1(95.12,70.75) ; v1(102.12,67.75) JCPU1.AH5 ; v1(20.3,118.55) JXDP2.50 ; JXDP2.37 23.3,120.79 v1(23.48,120.61) ; v1(94.12,41.75) JCPU1.C13 ; v1(24.8,124.32) 24.8,124.31 JXDP2.31 ; v1(100.12,43.75) JCPU1.E7 ; JCPU1.W6 v1(101.12,57.75) ; v1(97.12,41.75) JCPU1.C10 ; JCPU1.AG11 v1(97.12,66.75) ; v1(97.12,43.75) JCPU1.E10 ; JXDP2.32 v1(24.8,115.53) 24.68,115.66 23.63,115.66 23.3,115.98 JXDP2.38 ; JCPU1.AE4 v1(103.12,64.75) ; v1(86.2,75.8) 86.59,75.41 JCPU1.AT21 ; JCPU1.W7 v1(100.12,57.75) ; v1(20.68,124.88) 20.3,124.5 JXDP2.49 ; JXDP1.1 v1(61.7,10.45) ; v1(73.12,41.75) JCPU1.C34 ; JXDP1.14 64.7,19.1 v1(64.8,19.21) ; JCPU1.N6 v1(102.12,51.75) ; v1(103.12,43.75) JCPU1.E4 ; JCPU1.AL6 v1(101.12,70.75) ; JXDP2.25 26.3,123.94 26.68,124.32 v1(27.8,124.32) JXDP2.19 ; JXDP1.7 v1(63.2,13.5) ; JCPU1.AE7 v1(100.12,64.75) ; JCPU1.J26 v1(81.12,48.75) ; v1(103.12,41.75) JCPU1.C4 ; JCPU1.AA11 v1(97.12,60.75) ; JXDP1.50 v1(73.7,16.17) ; v1(103.12,42.75) JCPU1.D4 ; v1(101.12,47.75) JCPU1.H6 ; v1(105.12,48.75) JCPU1.K3 ; v1(85.16,74.75) 85.59,74.31 JCPU1.AR22 ; JCPU1.AN21 86.59,72.35 v1(86.2,72.75) ; JCPU1.K7 v1(100.12,48.75) ; v1(106.12,64.75) JCPU1.AE1 ; v1(67.93,16.17) 67.93,16.34 67.7,16.58 JXDP1.26 ; v1(94.12,42.75) JCPU1.D13 ; JCPU1.AM13 v1(95.12,71.75) ; v1(98.12,44.75) JCPU1.F9 ; JCPU1.AE3 v1(104.12,64.75) ; JXDP1.2 61.7,16.49 61.5,16.29 v1(61.5,16.17) ; JCPU1.AR16 v1(92.12,74.75) ; JCPU1.T3 v1(105.12,54.75) ; JXDP2.14 29.3,115.61 v1(29.18,115.48) 30.36,115.48 30.8,115.92 JXDP2.8 ; v1(91.12,42.75) JCPU1.D16 ; v1(104.12,67.75) JCPU1.AH3 ; v1(79.12,44.75) JCPU1.F28 ; JCPU1.AR7 v1(101.12,74.75) ; JCPU1.AN19 v1(89.12,72.75) ; v1(83.12,41.75) JCPU1.C24 ; JCPU1.AL7 v1(100.12,70.75) ; JCPU1.H26 v1(81.12,47.75) ; JCPU1.R11 v1(97.12,53.75) ; v1(103.12,39.75) JCPU1.A4 ; v1(77.12,47.75) JCPU1.J30 ; JCPU1.J28 v1(80.12,47.75) ; JCPU1.K29 v1(78.12,48.75) ; v1(96.12,44.75) JCPU1.F11 ; JCPU1.J6 v1(102.12,48.75) ; JCPU1.L6 v1(102.12,49.75) ; v1(91.12,41.75) JCPU1.C16 ; v1(104.12,61.75) JCPU1.AB3 ; JCPU1.F26 v1(81.12,44.75) ; JCPU1.AT7 v1(101.12,75.75) ; JXDP1.13 v1(64.7,13.5) ; JCPU1.AT19 v1(89.12,75.75) ; JCPU1.AP16 v1(92.12,73.75) ; JCPU1.K4 v1(104.12,48.75) ; JCPU1.AE6 v1(101.12,64.75) ; v1(97.12,46.75) JCPU1.H10 ; v1(107.12,61.75) JCPU1.AB1 ; v1(78.12,45.75) JCPU1.G29 ; v1(79.12,41.75) JCPU1.C28 ; v1(97.12,40.75) JCPU1.B10 ; JCPU1.AL18 v1(89.12,70.75) ; JCPU1.AM16 v1(92.12,71.75) ; v1(94.12,39.75) JCPU1.A13 ; v1(102.12,46.75) JCPU1.G5 ; JCPU1.N5 v1(103.12,51.75) ; JCPU1.T9 v1(99.12,54.75) ; JCPU1.AP4 v1(104.12,73.75) ; v1(80.12,39.75) JCPU1.A27 ; JCPU1.G27 v1(80.12,45.75) ; v1(82.59,39.48) JCPU1.A25 ; v1(78.12,42.75) JCPU1.D29 ; JCPU1.P11 v1(97.12,52.75) ; JCPU1.T4 v1(104.12,54.75) ; JCPU1.AP19 v1(89.12,73.75) ; v1(17.71,115.58) 17.75,115.58 17.8,115.64 JXDP2.60 ; JXDP2.2 32.3,115.97 32.27,115.94 32.27,115.86 v1(31.99,115.58) ; v1(104.12,39.75) JCPU1.A3 ; JCPU1.N10 v1(98.12,51.75) ; JCPU1.W1 106.65,58.28 v1(106.12,57.75) ; JCPU1.N9 v1(99.12,51.75) ; JCPU1.AT4 v1(104.12,75.75) ; JCPU1.AT13 v1(95.12,75.75) ; v1(100.12,42.75) JCPU1.D7 ; JCPU1.AP10 v1(98.12,73.75) ; v1(91.12,39.75) JCPU1.A16 ; JCPU1.AM10 v1(98.12,71.75) ; JCPU1.Y11 v1(97.12,59.75) ; v1(105.12,45.75) JCPU1.G2 ; v1(105.12,75.75) JCPU1.AT3 ; v1(97.12,39.75) JCPU1.A10 ; JCPU1.K2 105.59,49.21 v1(105.99,48.81) ; JCPU1.K1 v1(107.12,48.75) ; JCPU1.AM7 v1(101.12,71.75) ; v1(97.12,44.75) JCPU1.F10 ; JCPU1.AN13 v1(95.12,72.75) ; JCPU1.N7 v1(101.12,51.75) ; JCPU1.AR4 v1(104.12,74.75) ; JCPU1.AN16 v1(92.12,72.75) ; JCPU1.G1 107.12,45.75 v1(107.12,45.62) ; JCPU1.T1 v1(107.12,54.75) ; JCPU1.AF11 v1(97.12,65.75) ; JCPU1.AL2 v1(106.12,70.75) ; JXDP1.37 v1(70.7,10.37) ; JXDP2.20 27.8,115.99 27.37,115.56 v1(26.3,115.56) JXDP2.26 ; v1(93.12,44.75) JCPU1.F14 ; v1(75.12,41.75) JCPU1.C32 ; v1(92.12,44.75) JCPU1.F15 ; JCPU1.AN10 v1(98.12,72.75) ; JCPU1.R5 v1(103.12,53.75) ; JCPU1.AB10 v1(98.12,60.75) ; v1(100.12,41.75) JCPU1.C7 ; JCPU1.N4 v1(104.12,51.75) ; JCPU1.AL17 v1(90.12,70.75) ; JXDP1.20 v1(66.2,19.21) ; JCPU1.AL9 v1(98.12,70.75) ; JCPU1.AL11 v1(96.12,70.75) ; v1(105.12,70.75) JCPU1.AL3 ; v1(101.12,44.75) JCPU1.F6 ; v1(94.12,43.75) JCPU1.E13 ; v1(91.12,43.75) JCPU1.E16 ; v1(18.68,124.88) 18.55,124.88 17.8,124.13 JXDP2.59 ; JCPU1.T6 v1(102.12,54.75) ; v1(95.12,44.75) JCPU1.F12 ; JCPU1.AT10 v1(98.12,75.75) ; v1(105.12,67.75) JCPU1.AH2 ; JCPU1.AL1 v1(107.12,70.75) ; v1(106.12,43.75) JCPU1.E1 ; v1(80.12,42.75) JCPU1.D27 ; JCPU1.AL10 v1(97.12,70.75) ; JCPU1.AT16 v1(92.12,75.75) ; v1(76.12,42.75) 76.37,43.03 76.37,43.07 76.54,43.24 76.56,43.24 JCPU1.D31 ; v1(99.12,67.75) JCPU1.AH8 ; v1(106.12,41.75) JCPU1.C1 ; JCPU1.W9 v1(98.12,57.75) ; v1(100.12,67.75) JCPU1.AH7 ; v1(72.12,42.75) JCPU1.D35 ; JCPU1.N1 v1(107.12,51.75) ; v1(81.12,41.75) JCPU1.C26 ; v1(103.12,44.75) JCPU1.F4 ; v1(104.12,45.75) JCPU1.G3 ; JCPU1.AL14 v1(93.12,70.75) ; JCPU1.AD7 v1(101.12,63.75) ; v1(105.12,41.75) JCPU1.C2 ; JCPU1.AP7 v1(101.12,73.75) ; JCPU1.AE9 v1(98.12,64.75) ; JCPU1.AR10 v1(98.12,74.75) ; JCPU1.AR2 v1(106.12,74.75) ; v1(100.12,39.75) JCPU1.A7 ; v1(99.12,44.75) JCPU1.F8 ; v1(100.12,44.75) JCPU1.F7 ; JXDP1.49 v1(73.7,13.5) ; v1(73.12,40.75) JCPU1.B34 ; v1(69.3,16.17) 69.2,16.27 JXDP1.32 ; JCPU1.AE10 v1(97.12,64.75) ; JCPU1.K10 v1(97.12,48.75) ; v1(103.12,68.75) JCPU1.AJ5 ; JCPU1.M28 v1(79.12,50.75) ; v1(107.12,73.75) JCPU1.AP1 ; JCPU1.AL8 v1(99.12,70.75) ; v1(96.12,47.75) JCPU1.J11 ; JCPU1.AB4 103.56,61.28 v1(103.12,61.72) ; v1(91.12,40.75) JCPU1.B16 ; v1(106.12,67.75) JCPU1.AH1 ; v1(106.12,72.75) JCPU1.AN2 ; JCPU1.AL5 v1(102.12,70.75) ; JCPU1.K9 v1(98.12,48.75) ; v1(97.12,42.75) JCPU1.D10 ; JXDP2.13 v1(29.3,124.32) ; JCPU1.AF6 v1(102.12,65.75) ; v1(101.12,67.75) JCPU1.AH6 ; JCPU1.AR13 v1(95.12,74.75) ; JCPU1.AM4 v1(104.12,71.75) ; v1(77.12,41.75) JCPU1.C30 ; JXDP1.31 v1(69.2,10.45) ; JCPU1.AN7 v1(101.12,72.75) ; v1(100.12,61.75) JCPU1.AB7 ; JCPU1.U11 v1(97.12,55.75) ; JCPU1.AM19 v1(89.12,71.75) ; JCPU1.T10 v1(98.12,54.75) ; JCPU1.AF8 v1(100.12,65.75) ; JCPU1.AD11 v1(97.12,63.75) ; JCPU1.AK5 v1(103.12,69.75) ; JCPU1.W3 v1(104.12,57.75) ; JCPU1.AL4 v1(104.12,70.75) ; JXDP1.19 v1(66.2,13.5) ; JCPU1.N2 v1(106.12,51.75) ; JCPU1.V11 v1(97.12,56.75) ; v1(98.12,67.75) JCPU1.AH9 ; JXDP1.59 v1(76.2,10.45) ; JCPU1.K5 v1(103.12,48.75) ; v1(101.12,61.75) JCPU1.AB6 ; JCPU1.P5 v1(103.12,52.75) ; v1(100.12,40.75) JCPU1.B7
  TOP w0.305: JCPU1.K35 72.59,49.24 v1(72.12,48.76) ; JMXM1.214 78,97.97 v1(78.16,98.13) ; JMXM1.244 70.5,97.92 v1(70.32,98.11) 69.45,98.11 69,97.65 JMXM1.250 ; v1(75.13,47.76) 75.59,48.22 JCPU1.J32 ; v1(43.32,108.54) 43.18,108.41 UH1.BD45 42.65,108.33 UH1.BD44 ; JCPU1.W25 v1(82.12,58.75) ; JCPU1.AT34 v1(73.12,75.75) ; JMXM1.107 v1(106.75,106.14) ; v1(25.15,106.51) 25.13,106.51 24.94,106.7 UH1.A41 UH1.A43 UH1.A44 ; JMXM1.227 75.25,104.01 75.03,103.79 74.08,103.79 73.75,104.12 JMXM1.233 73.75,106.11 v1(73.81,106.11) ; v1(80.12,72.75) JCPU1.AN27 ; v1(160.82,37.5) 160.78,37.46 JDIMM3.170 ; JMXM1.142 v1(98,97.93) ; v1(38.64,105.12) 38.97,105.12 UH1.AT38 UH1.AT36 ; JCPU1.R26 v1(81.12,54.75) ; JCPU1.N33 v1(74.12,52.75) ; v1(39.21,101.85) 39.35,101.7 39.35,101.56 39.53,101.38 39.53,101.36 ; JCPU1.AA27 v1(80.12,60.75) ; JDIMM3.190 160.74,31.46 v1(160.82,31.53) ; JCPU1.AN24 v1(83.12,72.75) ; JMXM1.94 v1(110,97.93) ; v1(79.79,106.17) 79.79,106.16 79.75,106.12 JMXM1.209 ; JUSH1.1 v1(49.05,7.78) ; JMXM1.148 v1(96.5,97.93) ; JMXM1.136 v1(99.5,97.93) ; JMXM1.124 v1(102.5,97.93) ; JCPU1.AE29 v1(78.12,64.75) ; JMXM1.256 67.5,98.43 v1(67.34,98.59) ; UH1.AM32 UH1.AM30 UH1.AM28 37.51,100.99 v1(37.85,100.65) ; UH1.AM32 38.06,102.61 UH1.AP31 ; UH1.AM32 37.18,102.85 UH1.AL34 36.89,103.49 v1(36.69,103.69) 36.69,103.68 36.5,103.49 UH1.AJ34 ; v1(86.05,28.01) 85.98,28.09 JAPS1.8 ; UH1.BE2 43.26,89.73 v1(43.47,89.52) ; UH1.BE2 43.18,90.39 UH1.BD2 ; UH1.BE2 UH1.BE3 ; v1(72.11,73.75) 72.58,73.28 JCPU1.AP35 ; JCPU1.AE31 v1(76.12,64.75) ; JCPU1.AR25 v1(82.12,74.75) ; JCPU1.AK29 v1(78.12,69.75) ; v1(72.12,45.77) 72.12,45.77 72.59,46.24 JCPU1.G35 ; JMXM1.221 76.75,103.77 v1(76.62,103.63) ; v1(81.12,55.76) 81.14,55.76 81.14,55.73 81.59,55.28 JCPU1.T26 ; 30.21,105.4 30.59,105.4 UH1.R38 ; 30.21,105.4 UH1.N39 29.78,105.88 30.21,106.31 v1(30.21,106.72) 30.23,106.72 v1(30.69,107.18) ; 30.21,105.4 30.21,104.57 UH1.N35 ; JMXM1.169 v1(89.75,106.14) ; v1(88.12,41.75) JCPU1.C19 ; JMXM1.125 v1(102.25,106.14) ; UH1.BA1 UH1.BC1 ; UH1.BC1 UH1.BD1 ; UH1.BC1 42.14,89.58 42.53,89.19 v1(42.53,88.91) ; JCPU1.R30 v1(77.12,54.75) ; UH1.M17 29.55,96.58 v1(29.23,96.26) ; JCPU1.AG31 v1(76.12,66.75) ; JMXM1.161 v1(93.25,106.14) ; UH1.K29 28.13,101.13 28.13,100.87 v1(28.15,100.87) ; JCPU1.T33 v1(74.12,55.75) ; v1(24.04,89.85) 24.59,90.41 UH1.A2 UH1.A4 UH1.A5 ; JCPU1.P26 81.59,53.28 81.11,53.76 v1(81.12,53.76) ; v1(88.12,39.75) JCPU1.A19 ; JCPU1.AK34 v1(73.12,69.75) ; JCPU1.V28 v1(79.12,57.75) ; UH1.U28 31.88,100.58 v1(32.47,100.58) 32.14,100.25 UH1.V26 32.8,99.52 UH1.Y24 33.46,98.7 UH1.AA22 UH1.AA20 33.46,97.65 v1(33.79,97.32) 33.79,97.25 UH1.AD18 ; v1(28.23,105.5) 28.25,105.47 28.34,105.47 UH1.K39 28.75,105.9 28.49,106.16 v1(28.23,106.16) 27.91,106.47 UH1.H40 27.77,106.92 v1(27.69,107) 27.47,107 UH1.F43 ; v1(32.17,106.29) 32.36,106.47 UH1.Y40 32.66,106.83 v1(32.32,107.18) ; JCPU1.M32 75.59,51.27 v1(75.11,50.79) ; JDIMM3.150 v1(160.81,43.46) ; v1(74.06,57.76) 74.06,57.75 JCPU1.V34 ; JCPU1.W35 v1(72.12,58.75) ; UH1.R14 30.82,94.81 UH1.R12 30.47,94.7 v1(30.24,94.47) 29.96,94.75 UH1.N12 ; JMXM1.100 v1(108.5,97.93) ; JMXM1.296 v1(57.5,97.93) ; JIO1.84 11.32,86.4 ; JCPU1.AC35 v1(72.14,62.75) ; JMXM1.163 v1(91.25,106.14) ; v1(85.16,70.75) 85.59,70.32 JCPU1.AL22 ; JCPU1.AP34 v1(73.12,73.75) ; JCPU1.E19 88.59,44.22 v1(88.12,43.75) ; JCPU1.AM32 75.59,71.28 v1(75.07,70.75) ; v1(73.11,50.82) 73.57,51.28 JCPU1.M34 ; JCPU1.AK26 v1(81.12,69.75) ; JCPU1.AK32 v1(75.12,69.75) ; JCPU1.AG27 v1(80.12,66.75) ; JMXM1.187 85.25,104.13 v1(85.05,103.93) ; JDEG2.1 167.09,113.74 166.82,114.01 v1(166.51,114.01) ; JCPU1.AM23 84.59,71.3 v1(84.14,71.75) ; JCPU1.AL31 v1(76.12,70.75) ; JDIMM3.156 160.66,41.66 v1(160.82,41.82) ; JAPS1.10 v1(86.98,28.01) ; JCPU1.N29 v1(78.12,52.75) ; v1(87.14,70.75) 87.59,70.3 JCPU1.AL20 ; JCPU1.F21 v1(87.12,44.75) ; UH1.AM26 37.75,99.84 v1(37.75,99.78) ; JCPU1.A33 74.59,40.22 v1(74.12,39.75) ; v1(160.82,34.96) 160.72,35.06 JDIMM3.178 ; JCPU1.N31 v1(76.12,52.75) ; JMXM1.208 79.5,95.93 79.84,95.59 81,95.59 ; JMXM1.83 v1(112.75,103.87) ; JMXM1.155 v1(94.75,106.14) ; JCPU1.D33 74.59,43.22 v1(74.12,42.75) ; v1(74.1,45.77) 74.59,46.26 JCPU1.G33 ; v1(81.01,95.59) 81,95.59 ; 81,95.59 JMXM1.202 ; JCPU1.A31 76.59,40.23 v1(76.11,39.75) ; v1(86.6,95.69) 86.5,95.79 JMXM1.180 ; JCPU1.AA29 v1(78.12,60.75) ; JCPU1.D22 v1(85.12,42.75) ; JCPU1.AN34 v1(73.12,72.75) ; JMXM1.131 v1(100.75,106.14) ; v1(88.12,40.75) JCPU1.B19 ; v1(60.5,97.93) JMXM1.284 60.5,96.03 60.87,95.67 61.76,95.67 62,95.91 JMXM1.278 ; JMXM1.89 v1(111.25,106.14) ; UH1.AP24 38.13,99.4 v1(37.75,99.78) ; JCPU1.AC29 v1(78.12,62.75) ; v1(24.62,89.28) 25.13,89.78 UH1.B1 25.23,89.8 UH1.B2 ; JMXM1.272 v1(63.5,97.93) ; JCPU1.AC27 v1(80.12,62.75) ; JCPU1.G31 76.59,46.25 v1(76.11,45.76) ; v1(115.38,97.93) 115.38,97.78 115.5,97.65 JMXM1.72 ; JSPI1.17 v1(55.66,90.47) 55.66,90.82 55.5,90.97 JSPI1.18 ; JCPU1.E22 85.59,44.22 v1(85.12,43.75) ; JMXM1.281 v1(61.75,106.71) ; v1(85.17,71.74) 85.17,71.73 85.17,71.69 JCPU1.AM22 ; JCPU1.W33 v1(74.12,58.75) ; v1(89.15,30.05) 88.98,29.88 JAPS1.14 ; 9.41,84.6 JIO1.89 ; JMXM1.181 v1(86.75,106.14) ; JCPU1.AN30 v1(77.12,72.75) ; JCPU1.F23 v1(85.12,45.75) ; v1(86.2,71.75) 86.59,71.35 JCPU1.AM21 ; UH1.U39 31.89,105.88 v1(32.17,105.6) 31.85,105.28 UH1.U38 ; UH1.AK24 36.85,99.27 37.33,99.27 UH1.AM24 37.42,99.37 37.75,99.71 v1(37.75,99.78) ; JMXM1.287 60.25,106.86 v1(60.28,106.89) ; v1(33.79,100.58) 33.79,100.66 UH1.AA28 33.37,101.07 32.88,101.07 UH1.Y28 ; JMXM1.73 v1(115.25,106.14) ; JMXM1.95 v1(109.75,106.14) ; v1(75.32,98.13) 75,97.81 JMXM1.226 ; v1(85.12,39.75) JCPU1.A22 ; 11.49,88.2 JIO1.78 ; JCPU1.AC31 v1(76.12,62.75) ; JMXM1.160 v1(93.5,97.93) ; JCPU1.AP27 v1(80.12,73.75) ; JCPU1.F20 v1(87.12,45.75) ; UH1.AL8 36.98,92.91 v1(36.66,93.23) 36.34,92.91 UH1.AJ8 ; JCPU1.AT24 v1(83.12,75.75) ; JMXM1.130 v1(101,97.93) ; v1(78.11,39.75) 78.59,40.23 JCPU1.A29 ; JMXM1.113 v1(105.25,106.14) ; JCPU1.V32 v1(75.12,57.75) ; JCPU1.AE33 v1(74.12,64.75) ; v1(160.82,40.04) 160.64,39.86 JDIMM3.162 ; v1(55.51,106.36) 55.75,106.12 JMXM1.305 ; v1(77.11,44.76) 77.59,45.25 JCPU1.F30 ; JCPU1.AA35 v1(72.12,60.75) ; v1(77.11,50.76) 77.59,51.24 JCPU1.M30 ; JMXM1.175 v1(88.25,106.14) ; JMXM1.293 58.75,104.19 58.43,103.87 57.53,103.87 57.25,104.15 JMXM1.299 57.25,106.29 v1(57.15,106.4) ; JMXM1.203 81.25,103.86 81.57,103.54 v1(81.67,103.54) ; JCPU1.AC25 v1(82.12,62.75) ; JDIMM3.134 160.65,48.26 v1(160.82,48.42) ; JCPU1.AA33 v1(74.12,60.75) ; JUSH1.4 v1(50.55,7.75) ; JCPU1.R28 v1(79.12,54.75) ; JMXM1.245 70.75,103.94 v1(70.8,103.9) 71.92,103.9 72.25,104.23 JMXM1.239 ; JCPU1.F17 v1(90.12,44.75) ; UH1.AV40 40.21,106.38 v1(40.68,106.38) ; JIO1.3 9.15,110.4 9.43,110.68 10.75,110.68 11.21,110.22 11.21,109.31 11.62,108.9 v1(11.77,108.9) ; v1(85.12,41.75) JCPU1.C22 ; JCPU1.T31 v1(76.12,55.75) ; JCPU1.AM20 87.59,71.29 v1(87.14,71.75) ; JMXM1.194 83,97.94 83.04,97.98 83.04,97.95 v1(83.02,97.93) ; JCPU1.R32 v1(75.12,54.75) ; JCPU1.AR31 v1(76.12,74.75) ; JCPU1.R34 v1(73.12,54.75) ; JCPU1.AL24 v1(83.12,70.75) ; v1(69.25,103.87) JMXM1.251 ; JMXM1.118 v1(104,97.93) ; JMXM1.174 v1(88,97.93) ; UH1.E1 UH1.D1 25.85,89.41 v1(25.99,89.27) ; JCPU1.AK28 v1(79.12,69.75) ; v1(106.97,97.93) 107,97.9 JMXM1.106 ; UH1.D42 25.62,107.35 v1(25.62,107.42) 25.23,107.8 UH1.B44 25.15,107.88 UH1.B45 UH1.C45 UH1.E45 ; JCPU1.V30 v1(77.12,57.75) ; JMXM1.119 v1(103.75,106.14) ; v1(73.13,47.77) 73.59,48.23 JCPU1.J34 ; JMXM1.232 73.5,97.72 73.04,98.18 v1(72,98.18) JMXM1.238 ; JCPU1.AR34 v1(73.12,74.75) ; JMXM1.149 v1(96.25,106.14) ; v1(78.12,66.75) JCPU1.AG29 ; JCPU1.AT33 v1(74.12,75.75) ; JCPU1.F18 v1(89.12,45.75) ; JMXM1.137 v1(99.25,106.14) ; JCPU1.U27 v1(80.12,56.75) ; v1(27.47,98.37) 27.47,98.51 27.75,98.79 UH1.H22 UH1.H24 ; JCPU1.F24 v1(84.12,45.75) ; JCPU1.AK25 v1(82.12,69.75) ; v1(74.13,48.76) 74.59,49.22 JCPU1.K33 ; JMXM1.168 v1(89.5,97.93) 90.7,97.93 91,97.62 JMXM1.162 ; JCPU1.AR26 v1(81.12,74.75) ; JCPU1.AA31 v1(76.12,60.75) ; v1(85.12,40.75) JCPU1.B22 ; JMXM1.290 v1(59,97.93) ; JMXM1.220 76.5,97.99 v1(76.36,98.13) ; JCPU1.N35 v1(72.12,52.75) ; UH1.AY15 42.01,95.86 v1(42.05,95.82) 42.35,96.13 UH1.BC16 42.76,95.84 UH1.BD15 ; 11.28,85.2 JIO1.88 ; v1(86.2,70.75) 86.59,70.35 JCPU1.AL21 ; JCPU1.K31 76.59,49.22 v1(76.13,48.76) ; JMXM1.101 v1(108.25,106.14) ; JCPU1.AE25 v1(82.12,64.75) ; JCPU1.AE35 v1(72.14,64.76) ; JCPU1.AG25 v1(82.12,66.75) ; JMXM1.215 v1(78.25,106.19) ; JMXM1.154 v1(95,97.93) ; v1(33.94,91.02) 33.84,91.12 UH1.AA4 32.42,91.12 v1(32.32,91.02) 31.68,91.65 UH1.U6 ; JCPU1.AG33 v1(74.12,66.75) ; v1(78.11,55.76) 78.11,55.76 JCPU1.T29 ; JCPU1.AG35 v1(72.14,66.74) ; JCPU1.L26 v1(81.12,50.75) ; JSPI1.19 54.59,91.42 53.63,91.42 v1(53.58,91.48) 53.58,91.76 53.79,91.97 JSPI1.20 ; JCPU1.AE27 v1(80.12,64.75) ; JCPU1.AA25 v1(82.12,60.75) ; JMXM1.82 v1(113,97.93) ; v1(88.12,45.75) JCPU1.F19 ; JCPU1.M26 v1(81.12,51.75) ; JCPU1.T35 v1(72.12,55.75) ; JMXM1.112 v1(105.5,97.93) ; v1(136.21,90.33) 136.21,90.25 ; JMXM1.143 v1(97.75,106.14) ; JCPU1.AC33 v1(74.12,62.75) ; JCPU1.AM24 v1(83.12,71.75) ; JMXM1.88 v1(111.5,97.93) ; JAPS1.12 v1(87.98,28.01) ; JCPU1.AM25 v1(82.12,71.75) ; v1(88.12,42.75) JCPU1.D19
  TOP w0.356: v1(160.82,83.22) 160.66,83.06 JDIMM3.26 ; JDIMM1.161 137.49,40.25 135.4,40.25 135.24,40.09 v1(135.24,40.12) 135.29,40.07 135.29,39.41 136.34,38.35 JDIMM1.167 ; JDIMM1.196 147.77,29.65 v1(148.21,30.1) 148.36,29.95 151.19,29.95 JDIMM3.195 ; v1(142.99,35.34) 143.23,35.34 144.75,36.85 JDIMM1.172 ; JDIMM1.178 147.1,35.05 v1(148.36,33.79) ; JDIMM3.153 151.19,42.55 149.52,42.55 149.06,42.1 ; JDIMM1.150 147.08,43.45 147.74,44.11 147.74,45.02 v1(147.66,45.1) 147.5,45.25 JDIMM1.144 ; JDIMM1.48 148.24,76.45 148.71,76.93 v1(148.71,78.01) ; JDIMM3.25 148.76,83.36 v1(148.67,83.27) 148.67,82.88 150,81.55 151.19,81.55 JDIMM3.31 ; v1(160.82,81.44) 160.63,81.26 JDIMM3.32 ; JIO1.43 8.82,98.4 9.18,98.76 v1(9.18,99.6) JIO1.39 ; v1(147.8,37.22) 148.47,36.55 151.19,36.55 JDIMM3.173 ; JDIMM3.3 149.65,89.96 v1(149.48,90.12) ; v1(9.23,96.89) 9.03,96.89 8.74,96.6 JIO1.49 ; v1(160.82,72.56) 160.52,72.86 JDIMM3.60 ; v1(135.8,83.22) 135.93,83.35 JDIMM1.25 ; 135.1,42.55 135.7,43.15 JDIMM1.151 ; JIO1.28 14.25,103.2 v1(14.31,103.26) ; JDIMM3.66 160.72,71.06 v1(160.82,71.16) ; JDIMM1.46 147.85,77.05 148.15,77.36 148.15,77.76 v1(147.97,77.94) 147.68,77.65 JDIMM1.44 ; JDIMM1.9 136.3,88.15 v1(136.15,88.3) ; JDIMM1.71 135.97,69.55 ; JDIMM3.19 151.16,85.2 149.32,85.2 v1(149.25,85.13) ; JDIMM3.46 v1(160.82,77.06) ; JDIMM3.151 149.77,43.16 148.89,44.04 v1(148.89,44.61) 149.24,44.96 JDIMM3.145 ; v1(147.91,79.64) 147.91,79.69 147.68,79.45 JDIMM1.38 ; JDIMM3.136 v1(160.82,47.66) ; JDIMM1.3 136.59,89.95 v1(136.21,90.33) ; JIO1.34 13.02,101.37 v1(9.48,101.37) 7.88,101.37 JIO1.33 ; JDIMM1.127 135.57,50.35 134.86,49.64 v1(134.86,49.6) ; v1(149.57,39.83) 149.89,40.15 151.19,40.15 JDIMM3.161 ; JIO1.67 v1(9.13,91.2) ; JDIMM1.37 136.14,79.75 ; JDIMM1.49 136.1,76.15 ; JDIMM3.48 160.59,76.46 v1(160.82,76.24) ; JDIMM1.19 136.58,85.15 v1(136.23,85.51) ; v1(6.26,102.7) 6.75,103.2 JIO1.27 ; JDIMM3.138 159.41,47.05 160.52,47.05 v1(160.82,46.75) ; v1(147.97,83.34) 147.68,83.05 JDIMM1.26 ; JDIMM3.72 160.57,69.26 v1(160.82,69.51) ; v1(147.79,85.13) 147.51,84.85 JDIMM1.20 ; v1(135.91,30.11) 136.07,29.95 JDIMM1.195 ; JIO1.89 6.78,84.6 v1(6.59,84.8) ; JDIMM3.44 160.59,77.66 v1(160.82,77.89) ; JDIMM3.155 151.19,41.95 149.21,41.95 149.06,42.1 ; JIO1.21 9.71,105 v1(9.74,105.03) ; JDIMM1.55 136.2,74.35 ; v1(135.97,77.96) 135.98,77.95 JDIMM1.43 ; JIO1.88 v1(14.39,85.2) ; JDIMM3.133 150.29,48.56 149.69,47.97 v1(149.69,47.71) ; v1(148.08,31.84) 148.03,31.79 ; 148.03,31.79 148.03,32 146.78,33.25 JDIMM1.184 ; 148.03,31.79 147.69,31.45 JDIMM1.190 ; JIO1.22 v1(11.77,105) ; JDIMM3.172 159.41,36.85 160.52,36.85 v1(160.82,36.56) ; 149.06,42.1 148.95,41.98 v1(148.95,39.82) ; JDIMM3.128 160.58,50.06 160.59,50.07 v1(160.82,50.07) ; v1(160.82,85) 160.68,84.86 JDIMM3.20 ; v1(144.34,51.24) 144.42,51.17 144.42,50.42 144.78,50.05 JDIMM1.128 ; v1(160.82,79.45) 160.81,79.46 JDIMM3.38 ; JDIMM3.184 160.28,33.26 160.61,32.93 161.07,32.93 v1(161.59,33.45) ; JDIMM1.145 136.47,44.95 134.88,46.54 v1(134.88,47.11) 134.88,47.18 134.81,47.25 134.81,47.84 135.52,48.55 JDIMM1.133 ; JDIMM3.127 150.18,50.36 149.11,49.29 v1(149.11,47.69) ; JDIMM1.65 136.11,71.35 ; v1(160.82,86.65) 159.41,86.65 JDIMM3.14 ; JDIMM3.185 151.19,32.95 149.38,32.95 148.68,32.26 v1(148.68,31.76) ; JDIMM1.32 147.68,81.25 147.97,81.54 147.97,81.59 v1(147.94,81.62) 147.97,81.65 147.97,82.15 147.66,82.45 JDIMM1.28 ; JDIMM1.54 146.83,74.65 v1(147.18,74.31) ; JDIMM1.179 136.21,34.75 135.63,35.33 v1(135.63,35.48) ; JDIMM3.28 v1(160.82,82.46) ; JDIMM3.43 151.19,77.95 149.58,77.95 v1(149.6,77.94) ; JDIMM1.189 135.51,31.75 134.98,32.28 v1(134.98,32.66) ; v1(148.2,37.65) 148.2,37.7 148.86,38.36 JDIMM3.167 ; v1(135.47,47.11) 135.47,47.18 135.89,46.75 JDIMM1.139 ; v1(160.82,44.99) 160.56,45.25 159.41,45.25 JDIMM3.144 ; v1(147.99,86.73) 148.03,86.76 148.03,88.08 147.66,88.45 JDIMM1.8 ; v1(149.18,34.94) 149.36,34.76 JDIMM3.179 ; JDIMM1.2 148.07,90.25 v1(148.22,90.11) ; JDIMM3.196 159.41,29.65 160.52,29.65 v1(160.82,29.95) ; v1(147.2,86.75) 147.2,86.72 147.13,86.65 JDIMM1.14 ; JDIMM3.8 160.66,88.46 v1(160.82,88.3) ; RH132.2 15.38,97.09 14.49,97.98 14.03,97.98 13.85,97.8 JIO1.46 ; JDIMM3.49 151.19,76.15 150.11,76.15 149.46,75.51 v1(149.46,74.28) 149.54,74.36 JDIMM3.55 ; JDIMM3.11 153.16,87.56 v1(153.81,86.91) ; v1(147.43,41.67) 147.42,41.65 JDIMM1.156 ; v1(147.37,36.82) 146.73,37.45 JDIMM1.170 ; v1(160.82,74.46) 160.62,74.65 159.41,74.65 JDIMM3.54 ; JIO1.9 9.69,108.6 v1(9.71,108.57) ; JDIMM1.173 135.74,36.55 134.99,35.8 v1(134.99,35.47) ; JDIMM1.185 135.92,32.95 v1(135.62,32.65) 135.92,32.35 JDIMM1.187 ; JDIMM1.13 136.23,86.95 ; JDIMM3.187 151.19,32.35 149.91,32.35 v1(149.32,31.76) 149.32,31.75 151.19,31.75 JDIMM3.189 ; JDIMM1.31 136.19,81.55 ; v1(148.29,47.69) 148.29,47.86 147.9,48.25 JDIMM1.134 ; JIO1.16 10.63,106.8 10.47,106.64 9.93,106.64 v1(9.79,106.5) 9.62,106.67 8.9,106.67 8.76,106.8 JIO1.15 ; v1(149.77,45.81) 149.77,46.39 150.14,46.76 JDIMM3.139 ; JDIMM3.65 150.07,71.36 v1(149.56,71.87) 149.66,71.96 JDIMM3.63 ; JDIMM3.168 159.41,38.05 160.73,38.05 v1(160.82,38.14) ; JDIMM1.136 147.63,47.65 147.71,47.74 v1(147.71,47.69) 147.08,47.05 JDIMM1.138 ; v1(11.77,108.9) 12.07,108.6 JIO1.10 ; JDIMM1.168 147.31,38.05 148.29,39.03 v1(148.29,39.83) 148.28,39.84 145.81,39.84 JDIMM1.162 ; 136.18,72.55 JDIMM1.61 ; JIO1.120 v3(14.51,75.6) ; v1(136.23,71.89) 136.29,71.95 JDIMM1.63 ; v1(149.57,79.64) 149.57,79.71 149.62,79.75 151.19,79.75 JDIMM3.37 ; JDIMM3.9 150.13,88.16 149.51,87.54 v1(149.51,86.7) 149.77,86.96 JDIMM3.13 ; v1(143.72,71.47) 143.73,71.47 143.75,71.47 144.17,71.05 JDIMM1.66 ; v1(160.81,89.95) 160.51,90.25 159.41,90.25 JDIMM3.2 ; JIO1.61 6.31,93 v1(1.99,88.68) ; JIO1.4 14.66,110.4 v1(14.69,110.37) ; JDIMM1.60 147.15,72.85 v1(147.23,72.93) ; JIO1.55 v1(9.33,94.8) ; JDIMM3.71 151.19,69.55 149.71,69.55 149.67,69.52 v1(149.29,69.52) ; JDIMM1.155 136.54,41.95 136.39,41.81 135.49,41.81 135.04,42.26 v1(135.04,42.49) ; JDIMM1.11 136.19,87.55
  TOP w0.381: v1(83.89,133.74) 83.76,133.61 Q110.4 ; v1(75.12,69.75) 75.59,70.22 JCPU1.AL32 ; C744.2 108.2,155.52 v1(107.68,155.52) ; v1(83.12,66.76) 82.63,66.28 JCPU1.AG25 ; JCPU1.F32 75.62,45.28 v1(76.11,45.76) ; JMXM1.312 50.3,99.48 48.27,97.45 v1(48.27,95.82) ; v1(149.46,74.28) 149.46,73.21 150.12,72.55 151.19,72.55 JDIMM3.61 ; v1(12.61,129.17) 12.43,128.99 12.07,128.99 11.86,129.21 UH2.3 ; Q110.1 81.34,130.97 C1174.2 ; JCPU1.AT32 v1(76.12,74.75) ; JCPU1.AT30 77.59,75.95 v1(77.6,75.96) ; v1(37.42,139.53) 37.57,139.68 Q346.4 ; v1(42.3,30.36) 42.16,30.5 Q81.4 ; JCPU1.AC25 82.65,62.28 v1(83.12,62.75) ; v1(83.12,64.76) 82.64,64.28 JCPU1.AE25 ; v1(74.1,45.77) 73.61,45.28 JCPU1.F34 ; JDIMM1.153 135.1,42.55 v1(135.04,42.49) ; v1(78.12,69.75) 77.65,69.28 JCPU1.AK30 ; v1(105.83,158.66) 105.28,159.21 105.28,160.61 105.75,161.08 C1353.2 ; v1(128.76,48.77) 128.3,48.31 RD46.2 ; U15.3 v1(125.3,145.31) ; v1(38.31,113.57) 38.31,113.45 38.69,113.07 CH13.1 ; U20.7 79.97,116.1 v1(80.88,117) ; JCPU1.W25 82.66,58.28 v1(83.12,58.74) ; PU1.2 v1(4.46,87.56) ; RH119.2 17.92,93.71 18.3,93.71 v1(18.4,93.61) 18.53,93.74 18.91,93.74 CH7.1 ; JCPU1.AT27 v1(81.12,74.75) ; v1(43.24,81.82) 43.24,81.8 43.67,81.37 RH230.2 ; v1(147.61,69.55) 147.31,69.25 JDIMM1.72 ; v1(83.12,60.77) 82.63,60.28 JCPU1.AA25 ; JCPU1.AR28 v1(80.12,73.75)
  TOP w0.432: v1(57.36,135.3) 57.57,135.1 Q304.4 ; Q304.1 56.27,132.77 56.69,133.2 v1(57.32,133.2)
  TOP w0.457: RH116.1 v1(27.47,113.57) ; v1(20.62,166.44) 21.09,165.98 C1334.2 ; C1332.2 v1(24.1,148.78) ; RH176.2 47.74,109.33 47.25,108.85 v1(47.18,108.85) ; v1(65.72,131.99) 65.64,132.07 65.64,132.54 R139.2 ; Q336.4 27.68,149.37 v1(28.23,149.92) ; v1(63.62,132) 63.62,132.59 R137.2 ; v1(27.82,162.8) 27.54,163.08 C86.2 R66.1 ; R138.2 62.65,132.61 62.65,132.14 v1(62.79,132) ; C695.2 83.74,117.5 82.74,116.5 v1(82.36,116.5) ; v1(18.25,100.85) 17.97,101.13 CH9.2 ; v1(25.42,152.94) 25.44,152.93 Q336.1 ; JSATA1.4 170.3,50.91 169.78,51.42 v1(169.78,51.6) ; v1(40.43,142.28) 40.37,142.28 Q346.1 ; v1(64.82,131.98) 64.61,132.18 R141.2 ; RH115.1 v1(26.45,113.57) ; RH117.1 28.46,112.91 v1(28.46,113.57) ; v1(18.83,96.43) CH77.2 ; v1(35.39,163.74) 35.39,164.78 D73.1 ; R116.2 v1(36.36,145.25) R123.2
  TOP w0.508: PC510.2 51.88,20.23 v1(51.52,20.58) 51.52,21.02 51.29,21.25 PR521.2 PC509.1 ; C1340.2 10.02,165.4 v1(9.67,165.06) ; C503.2 65.92,147.85 v1(65.55,148.22) ; v1(96.99,159.7) 96.88,159.8 R892.1 ; C770.2 125.45,161.12 v1(125.87,160.7) ; PC920.2 v3(85.81,67.35) ; D22.1 v1(58.41,154.86) ; v1(30.39,159.01) 30.31,158.94 R96.1 C504.2 ; v1(115.3,144.22) 115.6,144.22 116.15,143.67 C633.2 116.63,143.23 C638.1 ; C370.2 171.67,143.56 v1(171.65,143.58) ; v1(173.14,134.48) C319.2 R424.2 ; v1(17.86,85.48) 17.46,85.89 C725.2 C724.2 ; C703.2 v1(122.97,124.62) ; v3(172.4,146.2) 173,146.2 173.01,146.2 C485.1 175.04,146.2 175.04,146.2 v3(175.68,146.2) ; R74.1 C402.2 v1(15.2,153.83) ; v1(83.7,127.57) 83.55,127.42 R2160.2 C696.2 ; v1(58.07,29) RC70.2 ; v1(265.08,125) 264.55,124.47 D17.1 ; C15.2 82.79,167.12 v1(82.81,167.14) ; CD2.2 131.35,85.9 130.96,85.51 v1(130.89,85.51) ; D21.1 55.75,148.69 55.46,148.4 v1(55.46,147.64) ; v1(57.93,140.11) 57.93,140.33 58.61,141.01 R136.2 ; R54.2 C23.2 75.29,164.82 v1(75.6,164.51) ; C14.2 80.88,167.02 v1(81.01,167.14) ; C287.2 v1(163.48,140.57) ; JUSH1.22 v1(48.68,4.05) ; v1(170.06,141.62) 170.72,141.62 C330.2 170.84,141.3 170.52,140.98 v1(170.04,140.98) ; v1(73.71,161.95) 72.54,163.12 C20.2 R53.2 ; C734.2 107.55,164.32 v1(108.01,164.78) 108.47,164.32 C1352.2 ; R935.2 v3(141.13,104.05) ; v1(93.87,144.16) 94.1,143.93 C634.2 ; U4.2 145.53,139.33 145.96,139.76 v1(146.59,139.76) ; v1(253.51,111.26) 254.7,110.08 JPB1.8 ; JODD1.7 v1(38.49,42.96) ; CD1.2 v1(130.21,85.48) ; CD87.2 v1(164.37,28.87) ; R61.1 v1(28.69,152.44) ; PR525.1 v1(55.71,22.08) ; v1(37.63,51.34) 36.86,50.58 JODD1.1 ; v1(136.13,100.59) 136.43,100.9 JMXM1.311 ; v1(126.98,92.82) 128.1,91.7 JDIMM1.205 ; JSPI1.21 59.17,94.12 v1(59.34,94.3) ; v1(125.04,169.57) 125.08,169.53 R717.2 ; v1(148.17,95.84) 148.17,95.82 147.73,96.26 JDIMM3.205 ; R491.1 23.08,149.12 v1(23.43,148.78) ; JDEG2.11 168.14,120.34 v1(170.61,122.81) ; C761.2 123.94,169.45 v1(123.21,168.73) 122.73,168.25 C545.2 ; R430.2 v1(173.16,129.88) ; JKB1.20 v1(175.55,118.5) ; RH81.1 18.89,90.96 v1(18.4,90.96) ; v1(83.5,112.08) 82.63,111.21 R492.1 ; C702.2 125.64,124.18 v1(125.64,123.86) ; v1(79.18,130.21) 78.77,130.62 D88.1 ; v3(19.85,66.46) 19.85,67.6 19.02,68.43 PQ8.6 19.02,70.89 PR22.2 ; C494.2 R122.2 v1(29.45,148.19) ; v1(177.02,137.32) 176.21,136.51 R820.1 ; v3(85.81,60.11) 86.23,60.11 PC926.2 ; v1(37.88,83.55) RH62.2 ; PC918.2 86.23,63.92 v3(85.81,63.92) ; U6.2 82.61,165.07 v1(82.76,165.21) ; PR509.1 47.25,25.77 v1(46.62,25.77) ; PC936.2 55.94,65.06 v3(55.89,65.01) ; v1(255.16,104.68) 255.16,102.47 JPB1.7 ; RC58.2 v1(77.25,80.73) ; v1(174.19,139.29) 174.23,139.29 174.86,138.66 C1180.2 C318.2 ; JDIMM3.206 142.41,21.56 v1(140.06,19.21) ; v3(169.55,55.84) 170.68,54.72 JSATA1.7 ; v1(94.4,153.19) Q52.3 ; JAPS1.17 80.49,25.98 v1(82.84,23.63) ; C290.2 146.26,140.46 v1(145.79,140.93) 145.39,140.53 U7.3 ; RC40.1 69.71,81.27 69.24,80.79 69.1,80.79 69.07,80.82 v1(69.02,80.82) ; JIO1.142 12.29,66.58 v1(12.71,66.15) ; C502.2 59.09,135.67 v1(58.68,136.08) ; v1(126.88,25.89) 127.09,26.1 JDIMM1.206 ; C756.2 v1(183.17,111.59) ; C784.2 v1(66.62,148.04) ; PC917.2 86.23,62.01 v3(85.81,62.01) ; v1(15.91,167.19) 15.91,166.66 16.25,166.32 C1337.2 ; CD65.2 v1(164.3,27.98) ; JSATA1.1 169.67,47.1 v1(169.5,46.92) ; PC309.2 13.34,139.96 v1(13.29,140.02) ; RH47.2 v1(31.78,83.55) ; v1(29.7,149.69) 29.78,149.77 C97.1 ; PC209.2 126.91,87.23 v1(126.91,90.33) ; C327.2 v1(159.67,135.55) ; PC937.2 55.91,58.99 v3(55.89,58.96) ; v1(48.35,134.86) JEDP1.41 ; v1(166.51,113.32) 167.08,112.75 JDEG2.12 ; v1(15.61,165.21) C1336.2 ; C793.2 260.6,104.11 v1(260.71,104) ; CH17.2 v1(48.47,86.14) ; RH55.2 RH54.2 v1(33.82,83.55) ; C637.1 104.77,140.55 v1(105.19,140.13) ; JWL1.1 v1(229.49,20.58) ; v1(124.88,166.93) U63.15 ; PC919.2 86.38,65.67 v3(85.78,65.67) ; CC137.2 86.52,35.76 86.79,36.03 v1(87.23,36.03) ; C478.2 v1(129.7,145.76) ; C428.2 C429.2 40.17,33.18 v1(40.42,32.93) ; R73.1 18.35,150.38 17.69,150.38 v1(17.59,150.28) ; v1(39.05,76.54) 38.74,76.85 PC515.2 PC516.2 ; PC527.1 v1(61.25,21.12) ; PR514.1 47.16,24.8 46.9,25.07 v1(46.64,25.07) ; R63.1 v1(29.29,159.04) ; PR507.1 v1(46.64,26.58) ; PWRSW1.2 v1(112.56,166.48) ; v1(53.58,91.48) 52.29,91.48 51.73,92.03 50.2,92.03 QH3.3 ; v1(3.92,78.9) 3.82,79 C721.2 ; RD43.2 129.04,83.88 v1(129.04,83.24) ; C624.2 C639.2 98.14,133.97 98.45,133.67 v1(98.45,133.27) ; C480.2 v1(161.49,141.2) ; JAPS1.18 92.3,27.01 v1(91.8,27.51) ; C544.2 44.66,35.75 C549.2 43.75,36.33 v1(43.62,36.46) ; JSATA1.13 v1(169.63,67.42) ; R1611.2 C773.2 v1(39.42,127.54) ; C479.2 v1(158.24,141.2) ; C704.2 v1(106.21,117.03) ; JSATA1.11 v1(169.86,64.88) ; R418.2 162.34,132.24 161.5,131.4 v1(161.5,131.1) ; v1(76.54,162.47) 76.54,163.28 76.26,163.56 R55.2 C22.2 ; v1(122.37,166.65) C554.2 ; v1(125.74,83.27) 125.28,83.73 RC109.2 ; CD20.2 131.35,46.29 v1(131.38,46.26) ; C1174.2 81.31,130.72 v1(80.81,130.21) ; v1(42.96,161) 42.39,160.42 C783.2 ; C486.2 v1(169.46,141.32) ; JSPI1.22 57.1,81.16 v1(56.22,81.16) ; Q87.3 150.68,110.94 150.34,111.29 v1(150.02,111.29) 149.74,111.01 C774.2 ; R1000.2 C695.2 ; v1(39.56,159.83) 39.56,159.6 39.86,159.29 C495.2 ; JEDP1.43 v1(46.4,144.09) ; JKB1.16 v1(175.55,116.5) ; PQ3.3 1.92,82.59 v1(1.8,82.71) 1.81,82.73 PR12.1 ; R82.2 v1(38.01,140.47) ; RH132.2 15.63,96.28 v1(16.11,95.79) 16.43,96.11 QC5.3 ; v1(18.29,166.5) 18.33,166.47 C1333.2 18.32,165.74 C1335.2 ; v1(14.69,110.37) 14.87,110.2 C723.2 16.47,110.2 16.54,110.27 CH78.2 ; JUSH1.21 v1(61.5,4.05) ; C359.2 v1(71.6,113.78) ; PC1.2 v1(151.8,96.12) ; v1(23.4,113.6) RH146.2 ; PC941.2 57.02,67.97 v3(55.89,69.1) ; JWL1.4 v1(230.79,18.2) ; v1(166.04,141.32) C484.2 167.04,140.85 166.72,140.53 U10.3 ; JODD1.4 v1(38.41,46.77) ; R783.2 v3(70.14,167.3) ; PC542.1 v1(57.9,23.58) ; JWL1.5 v1(226.19,18.17) ; RH56.2 v1(32.8,83.55) ; v1(108.87,162.16) 108.87,161.26 108.37,160.75 C1355.2 ; JKB1.15 v1(181.31,116.5) ; C278.2 v1(163.04,131.15) ; v1(125.66,48.78) 125.26,48.37 RC110.2 ; JPB1.5 251.29,107.3 v1(250.77,107.82) 251.25,108.3 JPB1.6 ; YH2.2 v1(39.89,116.22) ; C767.2 v1(42.12,33.12) ; R337.1 v1(58.15,143.04) ; v1(58.5,142.29) C560.2 R101.1 ; v3(55.89,61.81) PC943.2 ; C758.2 v1(183.12,114.41) ; C289.2 140.88,141.65 v1(140.72,141.81) ; PC526.1 v1(58.96,20.86) ; C1339.2 13.04,165.68 13.27,165.91 C1338.2 v3(13.54,165.14) ; D33.1 v1(120.18,123.9) ; C329.2 10.42,132.73 v1(9.81,132.12) ; v1(33.59,147.79) 33.77,147.61 R121.2 ; v1(42.07,112.96) 42.05,112.94 CH14.1 ; CH64.2 v1(42.83,113.57) ; C779.2 v1(113.95,154.6) ; v1(58.37,137.37) 58.44,137.45 C98.2 R3722.2 ; PC525.1 v1(58.96,21.75) ; PR529.1 v1(60.23,21.12) ; PC4.2 v1(157.87,25) ; C558.2 v1(67.47,131.93) ; C763.2 v1(2.45,72.17) ; CH63.2 v1(43.98,114.08) ; R420.2 v1(160.82,135.29) ; v1(94.4,154.34) R843.1 ; YH2.4 v1(39.91,114.62) ; JKB1.19 v1(181.4,118.5)
  BOTTOM w0.102: v4(20.81,129.94) 20.29,130.47 v3(19.59,130.47) ; v4(145.8,102.09) 145.75,102.14 v3(144.94,102.14) ; PBATT1.9 PBATT1.8 ; v1(226.93,80.02) 226.91,80 226.91,79.58 v4(226.46,79.13) ; v4(33.61,148.45) 33.59,148.42 v1(33.59,147.79)
  BOTTOM w0.127: C481.2 v4(150.58,168.12)
  BOTTOM w0.203: v1(229.91,86.32) 229.85,86.38 U638.3 ; U19.20 81.8,155.32 81.52,155.04 81.52,154.39 v1(81.71,154.2) ; PU1001.5 151.7,116.37 v3(151.73,116.35) ; U638.19 v1(232.25,84.01) ; U34.11 v1(55.01,109.84) ; v1(231.05,86.33) 231.05,87.92 ; v1(175.42,77.15) 175.47,77.1 PU200.3 ; v1(175.55,76.03) 175.82,76.3 PU200.1 ; U35.11 U35.15 ; U19.10 86.62,156.35 86.9,156.07 87.03,156.07 ; v1(82.2,159.55) 82,159.55 81.6,159.95 U19.30
  BOTTOM w0.254: JDOCK1.69 91.2,117.12 v1(91.37,116.95) ; JDOCK1.51 86.7,119.11 v1(86.19,119.62) ; JDOCK1.25 79.2,117.26 v1(78.96,117.03) ; JDOCK1.31 80.7,117.18 v1(80.88,117) 81.87,117 82.2,117.33 JDOCK1.37 ; v1(245.22,86.13) 245.21,86.14 U22.18 ; JDOCK1.32 v1(80.7,127.57) ; U22.31 v1(240.58,83.35) ; v1(106.12,72.75) 106.34,72.75 106.85,72.24 109.14,72.24 v4(109.18,72.27) RC49.2 ; v1(93.48,124.78) 93.3,124.78 92.7,125.38 JDOCK1.76 ; v1(103.36,127.57) 103.36,127.59 103.2,127.43 JDOCK1.114 ; JDOCK1.8 v1(74.7,127.57) ; v1(258.43,98.89) U45.1 ; PU1001.14 147.82,120.28 v3(147.79,120.26) ; CH30.2 29.74,98.14 CH51.2 ; JDOCK1.58 88.2,125.38 88.73,124.85 v1(89.7,124.85) JDOCK1.64 ; v1(104.86,124.91) 104.7,125.07 JDOCK1.120 ; JDOCK1.119 104.7,119.36 105.09,119.75 v1(105.7,119.75) JDOCK1.123 ; v1(109.2,119.7) JDOCK1.137 ; JDOCK1.81 94.2,119.45 v1(94.34,119.59) ; CH45.2 37.07,101.64 CH48.2 38.08,102.4 38.85,102.4 39.21,102.03 v1(39.21,101.85) ; PU700.4 v1(177.73,45.88) ; JDOCK1.93 97.2,119.35 v1(96.86,119.7) 96.7,119.54 JDOCK1.91 ; v1(53.42,96.84) 53.04,96.45 CE2.2 53.04,95.03 52.49,94.47 C746.2 ; CH25.2 39.66,103.05 v1(39.84,102.87) ; JDOCK1.7 v1(74.7,117) ; JDOCK1.50 v1(85.2,127.57) 86.34,127.57 86.7,127.21 JDOCK1.52 ; v3(151.7,118.58) 151.7,118.57 PU1001.5 ; JDOCK1.20 v3(77.7,127.59) ; RP4.5 229.26,68.2 v1(229.07,68.01) 228.76,68.32 RP4.6 ; U637.3 v1(214.44,65.06) ; JDOCK1.43 83.7,117.48 82.71,116.5 v1(82.36,116.5) ; PU1001.32 155.57,120.28 v3(155.59,120.31) ; RH147.2 RH148.2 23.48,104.51 23.96,104.99 24.93,104.99 RH118.1 ; v1(98.51,124.88) 98.7,125.07 JDOCK1.96 ; JDOCK1.63 89.7,119.37 89.52,119.55 v1(89.52,119.7) 89.2,119.38 JDOCK1.61 ; v1(37.75,99.78) 37.75,99.68 CH37.2 ; JDOCK1.108 101.7,125.4 101.19,124.89 v1(100.2,124.89) JDOCK1.102 ; v1(102.7,116.44) 102.8,116.44 103.2,116.84 JDOCK1.113 ; CH79.2 20.56,105.32 20.1,104.86 20.1,104.56 19.54,104 v1(19.39,104) ; JDOCK1.1 v1(73.2,119.62) ; v1(106.21,117.03) 106.21,117.18 106.2,117.19 JDOCK1.125 ; JDOCK1.107 101.7,119.78 101.33,120.15 v1(101.23,120.15) 100.97,120.15 100.2,119.38 JDOCK1.101 ; JDOCK1.19 v1(77.7,117) ; v1(245.27,82.9) 245.04,83.14 U22.24 ; JDOCK1.26 v3(79.2,127.59) ; RP4.7 228.26,68.19 v1(228.05,67.98) 227.76,68.27 RP4.8 ; v1(215.81,68.06) 216.37,67.5 U637.6 ; JDOCK1.126 106.2,125.42 107.35,124.27 v1(107.45,124.27) 107.7,124.52 JDOCK1.132 ; PU1001.23 151.7,124.31 151.42,124.6 151.42,125.31 PR1018.2 ; v1(22.49,100.82) 22.49,100.7 22.82,100.37 22.85,100.37 22.88,100.33 24.05,100.33 CH53.2 ; JDOCK1.47 84.7,119.25 85.02,119.57 v1(85.33,119.57) 85.2,119.44 JDOCK1.49 ; JDOCK1.87 v1(95.7,119.62) ; JDOCK1.14 v3(76.2,127.59) ; JDOCK1.131 v1(107.7,119.57) ; JDOCK1.57 88.2,119.39 87.89,119.7 87.69,119.7 v1(87.64,119.64) 87.65,119.64 87.7,119.59 JDOCK1.55 ; JDOCK1.95 v1(98.7,119.71) ; JDOCK1.70 v1(91.2,125.03) ; U22.3 v1(239.08,90.31) ; v1(109.2,124.32) JDOCK1.138 ; JDOCK1.13 v1(76.2,117)
  BOTTOM w0.279: v1(93.48,124.78) 93.61,124.78 94.2,125.37 JDOCK1.82 ; JDOCK1.44 v1(83.7,127.57) ; v1(91.37,116.95) 92.29,116.95 92.7,117.37 JDOCK1.75 ; JDOCK1.88 95.7,125.27 95.79,125.18 95.79,124.55 v1(95.74,124.5) ; JDOCK1.94 v1(97.2,125.03) ; JDOCK1.38 v1(82.2,127.57)
  BOTTOM w0.305: v1(168.22,39.13) 168.2,39.15 U88.5 ; v1(160.81,43.46) 160.51,43.16 JDIMM4.151 ; v1(136.21,90.33) 136.21,90.28 136.24,90.25 JDIMM2.2 ; U88.15 171.45,41.4 v1(171.74,41.11) 171.53,40.9 U88.16 ; v1(106.66,160.11) 106.66,160.67 106.75,160.75 U51.B66 ; v1(160.82,34.96) 160.62,34.76 JDIMM4.179 ; U88.12 169.7,43.64 v1(169.93,43.88) 170.2,43.61 U88.13 ; U51.B18 107.75,151.67 107.93,151.49 107.93,150.33 v1(107.98,150.28) ; JDIMM4.133 160.68,48.56 v1(160.82,48.42) ; v1(103.87,160.46) 103.75,160.58 U51.B60 ; v1(123.37,103.44) 123.4,103.44 123.37,103.4 U17.3 ; v1(160.82,40.04) 160.7,40.16 JDIMM4.161 ; U88.10 v1(168.7,43.85) ; CH15.2 CH76.2 20.02,107.48 CH80.2 20.02,107.43 v1(20.66,106.79) ; v1(100.75,160.44) U51.B54 ; v1(31.15,95.71) 31.15,95.79 31.73,96.38 CH54.2 ; U51.B11 v1(107.68,155.52)
  BOTTOM w0.318: U46.B27 213.87,81.77 213.87,81.73 v1(214.03,81.57)
  BOTTOM w0.356: v1(147.43,41.67) 147.15,41.95 JDIMM2.155 ; JDIMM2.3 145.8,89.95 148.06,89.95 v1(148.22,90.11) ; v1(149.51,86.7) 149.55,86.74 149.55,87.95 150.06,88.45 151.19,88.45 JDIMM4.8 ; JDIMM2.185 144.84,32.95 143.67,31.78 v1(143.62,31.78) ; JDIMM4.71 160.76,69.56 v1(160.82,69.51) ; JDIMM4.139 159.41,46.75 v1(160.82,46.75) ; JDIMM4.11 v1(160.79,87.56) ; JDIMM2.32 136.24,81.25 ; JDIMM4.184 151.19,33.25 149.75,33.25 149.32,32.82 v1(149.32,31.76) 149.62,31.45 151.19,31.45 JDIMM4.190 ; JDIMM4.134 149.99,48.26 149.69,47.97 v1(149.69,47.71) ; JDIMM2.37 145.8,79.75 147.77,79.75 147.91,79.61 v1(147.91,79.64) ; v1(160.82,85) 160.66,85.16 JDIMM4.19 ; v1(160.82,86.65) 160.51,86.96 JDIMM4.13 ; v1(147.2,86.75) 147.2,86.94 147.19,86.95 JDIMM2.13 ; JDIMM4.38 151.19,79.45 149.78,79.45 149.57,79.66 v1(149.57,79.64) ; JDIMM2.31 145.8,81.55 147.87,81.55 v1(147.94,81.62) ; JDIMM4.162 151.19,39.85 149.59,39.85 v1(149.57,39.83) 149.57,41.08 150.15,41.66 JDIMM4.156 ; v1(149.18,34.94) 149.3,35.06 JDIMM4.178 ; JDIMM2.20 136.2,84.85 ; JDIMM4.25 160.68,83.36 v1(160.82,83.22) ; JDIMM2.54 136.12,74.65 ; JDIMM2.55 147.13,74.35 v1(147.18,74.31) ; v1(135.8,83.22) 135.97,83.05 JDIMM2.26 ; JDIMM2.139 146.77,46.75 v1(147.71,47.69) ; v1(160.82,88.3) 160.68,88.16 JDIMM4.9 ; JDIMM2.9 145.8,88.15 147.96,88.15 148.03,88.08 148.03,87.84 ; v1(161.59,33.45) 161.08,32.94 160.46,32.94 160.44,32.96 JDIMM4.185 ; JDIMM4.26 149.98,83.06 149.77,83.27 v1(148.67,83.27) 149.49,82.45 151.19,82.45 JDIMM4.28 ; v1(149.11,47.69) 149.11,48.98 150.18,50.06 JDIMM4.128 ; JDIMM2.145 146.73,44.95 146.87,45.1 v1(147.66,45.1) ; 148.03,87.84 148.03,86.76 v1(147.99,86.73) ; 148.03,87.84 147.74,87.55 145.8,87.55 JDIMM2.11 ; JDIMM2.60 136.22,72.85 ; JDIMM4.196 148.65,29.66 v1(148.21,30.1) ; JDIMM4.136 149.74,47.66 v1(149.69,47.71) ; v1(160.82,29.95) 160.81,29.96 JDIMM4.195 ; JDIMM4.153 157.57,42.56 v1(157.34,42.33) ; JDIMM4.55 159.41,74.35 160.71,74.35 v1(160.82,74.46) ; JDIMM2.46 136.23,77.05 ; JDIMM4.155 160.68,41.96 v1(160.82,41.82) ; JDIMM4.167 159.41,38.35 160.6,38.35 v1(160.82,38.14) ; JDIMM4.14 150.29,86.66 149.25,85.63 v1(149.25,85.13) 149.53,84.86 JDIMM4.20 ; JDIMM4.144 150.14,45.26 149.77,45.63 v1(149.77,45.81) ; JDIMM4.168 148.62,38.06 148.22,37.65 v1(148.2,37.65) 148.4,37.46 JDIMM4.170 ; JDIMM2.43 145.8,77.95 147.96,77.95 v1(147.97,77.94) ; JDIMM4.63 160.77,71.96 v1(160.82,71.92) ; JDIMM4.49 160.74,76.16 v1(160.82,76.24) ; JDIMM2.170 137.6,37.45 135.62,37.45 ; JDIMM4.54 149.84,74.66 v1(149.46,74.28) 149.46,75.91 150.01,76.45 151.19,76.45 JDIMM4.48 ; JDIMM2.156 137.6,41.65 135.87,41.65 v1(135.04,42.49) 135.99,43.45 JDIMM2.150 ; JDIMM2.162 135.48,39.85 135.48,39.95 135.24,40.19 v1(135.24,40.12) 135.24,40.09 ; 136.19,47.65 JDIMM2.136 ; v1(135.63,35.48) 136.06,35.05 JDIMM2.178 ; 135.93,82.45 JDIMM2.28 ; JDIMM4.189 160.59,31.76 v1(160.82,31.53) ; 135.91,30.14 v1(135.91,30.11) 135.85,30.17 135.85,31.23 136.07,31.45 JDIMM2.190 ; v1(148.29,39.83) 147.97,40.15 145.8,40.15 JDIMM2.161 ; v1(149.48,90.12) 149.62,90.26 JDIMM4.2 ; JDIMM2.184 137.6,33.25 136.22,33.25 v1(135.62,32.65) ; JDIMM2.179 147.4,34.75 v1(148.36,33.79) ; v1(147.79,85.13) 147.76,85.15 145.8,85.15 JDIMM2.19 ; v1(160.82,77.89) 160.74,77.96 JDIMM4.43 ; JDIMM4.150 149.8,43.46 148.89,44.37 v1(148.89,44.61) ; JDIMM4.61 v1(160.82,72.56) ; v1(147.61,69.55) JDIMM2.71 ; JDIMM4.46 151.19,77.05 149.82,77.05 149.6,77.27 v1(149.6,77.94) 149.88,77.65 151.19,77.65 JDIMM4.44 ; 136.13,48.75 136.13,49.54 136.64,50.05 JDIMM2.128 ; JDIMM2.49 145.8,76.15 147.94,76.15 148.71,76.93 v1(148.71,78.01) ; JDIMM4.187 160.76,32.36 v1(160.8,32.32) ; JDIMM2.72 136.31,69.25 ; JDIMM2.63 147.04,71.95 v1(147.15,71.84) ; v1(160.82,71.16) 160.61,71.36 JDIMM4.65 ; JDIMM2.44 136.29,77.65 v1(135.97,77.96) ; JDIMM4.37 160.51,79.76 v1(160.82,79.45) ; v1(149.69,47.71) 149.69,47.29 149.92,47.06 JDIMM4.138 ; JDIMM2.127 144.64,50.35 144.42,50.57 144.42,51.17 v1(144.34,51.24) ; JDIMM2.144 136.05,45.25 ; v1(160.82,81.44) 160.7,81.56 JDIMM4.31 ; v1(160.82,36.56) JDIMM4.173 ; JDIMM2.172 137.6,36.85 135.48,36.85 134.99,36.36 134.99,35.49 134.99,35.48 v1(134.99,35.47) ; v1(148.08,31.84) 147.99,31.75 145.8,31.75 JDIMM2.189 ; JDIMM2.133 147.61,48.55 148.29,47.86 v1(148.29,47.69) ; v1(160.82,50.07) 160.53,50.36 JDIMM4.127 ; v1(135.47,47.11) 135.47,47.18 135.59,47.05 JDIMM2.138 ; v1(147.23,72.93) 146.85,72.55 145.8,72.55 JDIMM2.61 ; v1(147.97,83.34) 147.96,83.35 145.8,83.35 JDIMM2.25 ; JDIMM2.134 136.26,48.25 ; JDIMM2.151 144.52,43.15 143.65,42.28 v1(143.65,42.03) 143.71,41.97 144.28,41.97 144.86,42.55 JDIMM2.153 ; JDIMM4.145 160.78,44.96 v1(160.82,44.99) ; JDIMM2.38 136.26,79.45 ; JDIMM2.66 136.2,71.05 ; v1(147.8,37.22) 148.17,36.85 151.19,36.85 JDIMM4.172 ; JDIMM4.60 150.2,72.86 149.82,72.48 149.82,72.12 v1(149.56,71.87) 149.82,71.61 149.82,71.49 150.24,71.06 JDIMM4.66 ; JDIMM4.32 149.97,81.26 148.85,80.15 v1(148.85,79.64) ; v1(149.29,69.52) 149.66,69.52 149.93,69.25 151.19,69.25 JDIMM4.72 ; JDIMM2.8 136.3,88.45 v1(136.15,88.3) ; JDIMM2.173 145.8,36.55 147.1,36.55 v1(147.37,36.82) 147.16,37.02 147.16,38.07 146.88,38.35 145.8,38.35 JDIMM2.167 ; JDIMM2.187 147.54,32.35 147.63,32.45 148.24,32.45 148.65,32.04 148.65,31.79 v1(148.68,31.76) 148.68,31.35 147.29,29.95 145.8,29.95 JDIMM2.195 ; JDIMM2.48 136.27,76.45 ; 136.01,38.05 JDIMM2.168 ; JDIMM2.14 136.18,86.65 ; 135.91,30.05 136.31,29.65 JDIMM2.196 ; JDIMM4.3 160.81,89.96 v1(160.81,89.95)
  BOTTOM w0.381: PQ204.1 164.56,77.61 PC216.2 ; v1(236.28,32.02) 236.28,30.8 JSIM1.12 ; JSIM1.16 250.6,22.77 v1(250.61,22.77) ; v1(61.73,89.32) 61.73,89.49 61.27,89.95 C1216.2 ; U39.18 160.45,112.05 C553.2 ; U14.3 62.28,102.62 62.5,102.84 v1(62.77,102.84) ; C296.2 50.72,152.99 U3.3 ; v1(152.69,152.77) 153.31,153.39 PQ1080.4 ; PC217.2 168.65,82.67 168.11,82.14 168.11,81.77 167.83,81.49 PQ205.4 ; CH29.2 32.93,99.96 32.47,100.42 v1(32.47,100.58) ; U25.3 66.98,102.28 v1(67.16,102.09) ; PQ204.4 168.57,78.91 PC219.2 ; v1(35.11,100.58) 35.11,100.77 35.29,100.95 CH71.2 ; CH34.2 33.51,101.26 33.79,100.98 v1(33.79,100.58) ; v1(169.78,51.6) 169.99,51.8 PQ710.1 ; CH24.2 13.83,103.74 v1(14.31,103.26) ; PU1080.3 152.92,149.53 153.15,149.76 153.15,150.3 v1(153.17,150.33) ; v1(30.49,98.96) 29.84,98.96 CH51.2 ; PQ1071.4 230.52,70.28 v1(229.95,69.71) ; UC2.3 112.83,80.97 113.09,80.71 v1(113.39,80.71) ; PU1081.3 150.77,151.77 v1(150.35,152.18) ; v1(169.5,46.92) 169.84,47.27 Q29.4 ; v1(236.28,25.16) 236.27,25.16 JSIM1.13 ; v1(19.47,103.11) 19.21,103.36 CH66.2 ; CH60.2 42.17,93.86 v1(41.84,94.19) ; RH131.1 v1(22.77,83.55) RH142.1 ; RH118.1 25.23,104.79 25.84,105.4 v1(26.02,105.4) ; U27.3 57.33,101.75 57.74,101.33 58.43,101.33 ; U39.25 160.84,116.6 160.46,116.98 C551.2 ; U58.3 v1(18.27,153.17) ; PQ710.4 171.42,53.77 171.18,54.01 PR717.2 ; PQ205.1 164.37,80.19 PC220.2 ; JSIM1.17 250.6,31.28 v1(250.61,31.28) ; CH40.2 29.48,96.01 v1(29.23,96.26) ; v1(154.61,150.53) PQ1080.1 ; CH75.2 18.78,104.23 19.01,104 v1(19.39,104) ; Q29.1 172.37,48.57 172.52,48.42 PC744.1 ; JDIMM2.65 143.87,71.35 143.75,71.47 143.73,71.47 v1(143.72,71.47) ; v1(37.88,83.55) 37.51,83.55 37.28,83.78 37.28,83.78 36.96,84.1 36.96,84.1 36.9,84.16 RH223.2 ; U39.11 169.23,112.05 C552.2 ; CH5.1 24.62,89.06 v1(24.62,89.28) ; PU704.3 v1(239.67,62.46) ; v1(235.9,63.66) 235.87,63.69 PQ706.4 ; v1(34.07,114.41) 34.37,114.11 34.37,113.1 CH28.2 ; v1(11.77,108.9) 11.97,108.9 12.58,109.51 C548.2 13.29,109.38 13.77,108.91 UH3.3 ; U50.3 91.59,146.3 91.47,146.42 91.47,146.95 v1(91.58,147.05) ; PD3.1 197.2,23.68 v1(196.82,23.3) ; R656.2 169.1,114.44 168.66,114 U39.8 ; v1(228.76,62.57) 227.87,62.57 227.46,62.15 PQ707.4 ; U16.3 v1(85.05,103.93) ; CH62.2 43.47,93.76 42.35,92.64 v1(41.99,92.64) ; v1(225.17,65.2) 226.16,64.21 PQ707.1 ; PD2.1 199.21,23.67 v1(198.8,23.26) ; v1(10.31,92.95) 10.4,93.04 11.64,93.04 v4(11.92,92.76) 12.42,92.26 CH57.2 ; v1(33.79,97.32) 33.79,97.22 34.5,96.51 CH49.2 ; PQ706.1 v1(233.08,61.76) ; v1(232.04,67.45) 232.04,68.11 231.82,68.32 PQ1071.1
  BOTTOM w0.432: CH19.2 32.24,108.93 31.86,109.31 CH18.2
  BOTTOM w0.457: CH32.2 44.99,98.54 v1(44.99,99.3) 44.99,99.92 CH52.2 ; v1(218.7,90.33) 218.7,90.08 219.06,89.72 C709.2 ; Q339.4 v1(241.9,67.94) ; v1(214.03,90.41) 214.28,90.16 R102.1 ; v3(66.46,66.79) 63.28,66.79 PC905.2 v3(66.46,67.57) ; v1(45.6,103.36) 45.6,102.56 CH31.2 45.65,102.44 v1(45.65,101.36) ; v1(232.68,91.87) 233.08,91.47 C450.2 ; C615.2 253.08,92.77 v1(253.77,93.46) ; RC14.2 111.67,78.12 v1(111.11,78.67) ; CH26.2 45.56,105.7 v1(45.22,106.04) ; v1(29.47,113.8) 29.42,113.75 29.42,113.24 29.93,112.74 30.27,112.74 CH20.2 ; CH21.2 38.22,117.52 37.07,116.37 37.07,115.71 v1(37.19,115.58) ; v1(90.08,34.5) 90.2,34.38 RC72.2 ; CE1.2 47.81,94.04 v1(47.81,93.34) ; PC407.2 v1(259.22,28.41) ; PC728.2 v1(216.05,59.78) 215.93,59.9 C1312.2 ; v1(44.94,86.95) 44.94,87.62 RH209.2 ; C90.2 81.62,103.54 v1(81.67,103.54) ; v1(32.47,95.71) 32.56,95.8 CH39.2 ; CH33.2 42.83,103.21 v1(42.07,103.97) ; PR225.2 v1(169.62,83.3) ; Q339.1 v1(245.36,69.24)
  BOTTOM w0.508: R801.1 v1(259.63,142.56) ; v1(23.48,120.61) 23,120.13 CH50.2 ; JFAN1.1 14.16,131.02 v1(14.56,131.43) ; JMINI4.4 146.57,139.74 v1(146.59,139.76) ; v1(169.71,50.56) 172,50.56 172.67,51.22 PR758.2 ; v1(182.86,91.88) 182.75,92 CD46.2 CD45.2 ; v1(95.06,141.48) 94.95,141.58 JMINI3.50 ; Q338.3 v1(261.33,104) ; v1(214.92,92.09) 215.59,92.09 C714.2 ; C713.2 v1(206.61,82.94) ; PC1002.2 v1(175.73,37.83) ; Y3.2 129.15,155.01 v1(129.12,154.98) ; CH6.1 18.5,93.51 v1(18.4,93.61) ; R75.1 v1(241.99,92.98) ; PC935.2 v3(55.89,58.96) ; v1(219.52,67.96) 219.76,68.2 219.76,68.79 219.16,69.38 R757.2 ; v1(209.16,76.74) C710.2 ; PC1009.2 v1(144.81,119.29) ; JMINI2.9 v1(259.14,85.4) ; v3(199.11,25.69) 198.67,25.69 198.01,26.35 PQ1083.6 ; v1(58.07,29) 58.02,28.95 57.01,28.95 PR558.1 ; 87.03,156.07 C1181.2 v1(88.65,156.07) ; C301.2 58.75,149.35 v1(59.04,149.64) ; PC1081.1 v1(150.96,155.26) ; JMINI2.27 259.29,75 v1(258.89,74.6) 259.28,74.2 JMINI2.29 ; v1(258.59,155.42) 259.14,155.42 C482.2 259.14,156.18 v1(258.59,156.18) ; v1(124.67,155.51) 124.72,155.46 125.81,155.46 C471.2 ; v1(166.02,30.52) CD60.2 CD59.2 ; v1(91.3,133.26) 91.3,135.24 JMINI3.54 ; v3(246.44,55.45) 247.05,54.84 PC117.2 ; C364.2 v1(13.34,133.11) 12.88,133.57 JFAN1.5 ; CH43.2 30.23,100.33 v1(30.49,100.58) 29.85,101.21 CH73.2 ; CH61.2 CH62.2 ; v1(163.09,76.63) 163.09,77.09 PR217.2 ; v3(55.89,69.1) 57.04,67.94 PC940.2 ; PR405.2 264.5,34.78 v1(263.81,35.47) ; v1(219.62,72.3) R514.2 ; v1(134.62,149.67) 134.69,149.74 JMINI4.21 ; v1(60.28,106.89) 59.48,107.69 59.48,109.61 R301.2 ; PC733.1 v1(228.76,62.57) ; PC5.2 v1(174.1,30.97) ; PC217.2 168.73,82.93 168.99,83.2 v1(168.99,83.3) ; v1(26.63,162.34) v4(26.01,162.34) C46.2 ; v1(97.75,133.25) 97.75,134.64 JMINI3.43 ; v1(44.23,147.99) 44.59,147.99 C555.2 ; v1(40.62,157.62) 40,157 JRTC1.2 ; v1(134.67,144.33) 135.14,144.33 135.33,144.14 JMINI4.15 ; R115.2 v4(30.31,150.3) v1(29.7,149.69) ; CH46.2 34.12,93.94 33.39,93.2 v1(33.18,93.2) ; R62.1 v1(243.75,93) ; v1(107.55,147.23) 107.67,147.34 R1983.2 ; R431.2 46.14,144.36 v1(46.4,144.09) ; v1(78.75,162.06) 79.03,161.78 C1182.2 ; C496.2 v1(244.56,80.4) ; CH19.2 32.32,108.67 v1(32.32,107.18) ; v1(166.99,89.6) 166.99,91.4 JDIMM4.205 ; JMINI4.26 147.47,151.74 C606.1 148.04,151.88 v1(148.24,151.67) ; JDIMM4.206 v1(169.96,26.11) ; CMOS1.1 69.03,24.83 v1(69.36,24.5) ; PC791.2 v3(184.31,46.25) ; v1(120.6,137.22) 120.6,137.22 JMINI3.53 ; C607.1 149.01,162.98 v1(149.26,162.72) ; v1(40.88,70.24) 41.39,69.73 PC500.2 ; C470.2 v1(126.15,159.09) ; PR717.2 171.18,55.23 v1(171.48,55.54) ; v1(164.87,79.4) 164.87,79.53 164.32,80.07 PC220.2 ; JRTC1.4 38.58,153.2 v1(39.58,152.2) ; JMINI4.43 v1(137.67,158.54) ; v3(216.32,54.52) PR748.2 PC732.2 ; JMINI4.35 v1(137.89,155.34) ; PC215.2 177,80.25 v1(177.43,79.82) ; C88.2 236.99,79.28 v1(236.72,79.55) ; v1(96.3,146.59) 96.35,146.59 96.94,146 Q45.3 ; CH55.2 18,90.38 18.4,90.78 v1(18.4,90.96) 18.89,90.96 CH44.2 ; C436.2 C543.2 v1(124.77,109.36) ; v1(92.36,149.79) 92.44,149.72 R883.1 ; C712.2 v1(207.22,85.51) ; JMINI2.4 252.29,87.39 v1(250.88,87.39) 250.82,87.34 C614.2 C617.2 ; R429.1 v1(105.89,147.33) C737.2 ; v1(245.53,37.48) C631.2 ; U53.4 54.39,84.87 54.01,85.25 53.25,85.25 52.87,84.87 v1(52.54,84.87) ; v1(101.18,135.99) 100.95,135.76 100.95,134.64 JMINI3.35 ; 58.43,101.33 59.12,100.64 v1(59.12,99.92) ; 62.59,62.95 63.89,64.25 v3(66.46,64.25) ; 62.59,62.95 PC907.2 63.66,61.68 v3(66.46,61.68) ; 62.59,62.95 v3(66.46,62.95) ; PQ1011.3 160.06,103.37 160.68,103.99 v1(160.68,106.11) ; v1(257.28,106.42) 256.7,107.01 U2.9 ; v1(257.59,135.16) 258.1,135.67 C794.2 ; C360.2 120.4,112.07 123.54,115.2 v1(123.88,115.2) ; v1(160.64,115.23) 160.41,115.23 159.97,114.78 CE3.2 ; R733.2 108.38,144.9 107.75,144.28 v1(107.75,144.26) 107.75,142.84 JMINI3.18 ; CH23.2 30.51,106.41 v1(30.21,106.72) ; C716.2 222.67,91.15 222.67,90.44 v1(222.75,90.36) 222.75,89.84 R803.2 ; CD61.2 CD62.2 v1(167.8,30.52) ; PR1018.2 152.01,125.48 v3(152.01,124.75) ; v1(33.94,91.02) 34.57,90.38 CH59.2 ; C743.2 108.03,164.81 v1(108.01,164.78) ; JSIM1.18 v1(248.14,34.43) ; v1(149.97,147.99) 150.26,147.7 PQ1082.3 ; v1(255.16,104.68) 255.18,104.67 R747.2 ; v1(162.72,48.17) 162.42,48.47 CD64.2 161.96,47.47 CD63.2 ; CH65.2 35.01,95.32 34.63,95.71 v1(34.45,95.71) ; C782.2 94.92,147.15 93.89,147.15 v1(93.89,146.01) ; v1(172.7,46.26) 173.08,46.65 PC783.2 PR732.1 PC744.1 ; JMINI3.21 106.55,134.64 v1(106.55,133.26) ; v1(29.18,115.48) 29.8,114.85 CH58.2 ; v1(9.76,126.85) 10,126.85 10.62,126.23 JFAN1.6 ; JMINI4.29 134.66,152.94 v1(134.65,152.94) 134.65,152.56 135.08,152.14 JMINI4.27 ; RD50.2 v1(178.98,90.64) ; v1(55.96,77.07) 55.96,77.14 55.56,77.54 C357.2 ; JMINI3.29 103.35,134.64 103.35,135.66 103.67,135.98 v1(103.87,135.98) 104.15,135.7 JMINI3.27 ; JMINI3.34 101.35,141.75 v1(101.61,141.49) ; v1(15.91,92.39) 15.97,92.45 16.71,92.45 ME1.1 ; v1(106.55,168.49) 106.33,168.27 R876.2 ; v1(51.32,150.77) 52.27,150.77 R1137.2 ; RD20.1 v1(131.99,32.54) ; v3(245.93,54.06) 246.48,54.06 246.69,53.85 PC107.2 ; C757.2 104.07,165.21 v1(104.02,165.16) 103.97,165.21 C735.2 ; CH35.2 35.42,98.41 35.77,98.76 v1(35.77,98.96) ; v1(30.62,143.67) 30.37,143.43 PC16.2 ; U62.2 48.37,151.42 C298.2 48.7,151.47 v1(49.08,151.85) 49.26,151.85 49.59,151.52 49.75,151.52 50.06,151.22 50.06,150.33 50.4,149.98 C248.2 ; v1(253.68,72.2) JMINI2.34 ; JFAN2.6 v1(177.55,149.38) ; PC216.2 164.23,76.85 164,76.62 v1(163.75,76.62) ; v1(257.84,111.62) 258.33,112.1 D15.1 ; v1(20.3,118.55) 20.3,118.91 20.89,119.49 CH2.2 ; CE9.2 91.98,113.29 v1(93.13,114.44) ; Q55.3 v1(253.77,93.46) ; JMINI4.18 143.15,148.54 v1(142.79,148.89) ; R869.1 v1(94.4,155.61) ; PC717.2 v1(187.74,54.85) ; PC119.2 v3(240.95,56.31) ; CH27.2 31.73,103.25 v1(32.17,103.69) ; PC212.2 v1(189.65,75.79) ; C765.2 117.45,146.67 C547.2 117.89,147.23 v1(118.45,147.79) ; CH56.2 16.75,90.43 16.01,90.43 v1(15.76,90.18) ; PR102.1 v3(250.06,63.37) ; v1(145.91,161.34) 144.24,161.34 JMINI4.50 ; RC77.2 66.88,12.81 v1(66.2,13.5) ; v1(242.7,78.12) 242.73,78.15 R59.1 ; C611.2 C610.2 v1(264.97,70.41) ; PC786.2 v3(175.64,56.26) ; v1(105.32,169.91) 104.61,169.91 JTAG1.2 ; CH41.2 v1(33.94,107.18) ; v1(39.83,98.36) 39.83,98.59 39.8,98.62 CH36.2 ; R564.2 217.76,60.48 217.47,60.48 R551.2 216.9,60.02 v1(217.07,59.85) PC727.2 ; PC8.2 v1(29.24,143.55) ; v1(126.98,92.82) 128.1,91.7 JDIMM2.205 ; PC204.2 v3(175.29,68.64) ; v1(64.7,13.5) 65.19,13.01 RC76.2 ; v1(247.56,77) 248.32,76.24 C612.2 ; v1(237.22,33.35) JSIM1.11 ; R562.2 128.6,154.6 128.85,154.34 129.38,154.34 v1(129.62,154.58) ; CH38.2 v1(40.61,118.45) ; v1(131.43,158.89) 131.61,158.71 C608.2 ; C1167.2 v1(154.21,168.57) ; v4(119.92,159.95) v1(119.34,160.54) ; v1(216.95,52.74) 217.21,53 PC731.2 ; v1(165.15,40.57) C392.2 ; v1(103.4,147.17) 103.03,147.53 C1348.2 103.04,147.93 103.91,147.93 C1349.2 C739.2 ; C594.2 v1(247.56,75.22) ; v1(257.84,91.45) JMINI2.53 ; v1(209.38,72.96) 209.58,73.16 209.58,73.65 209.12,74.1 C718.2 C717.2 C708.2 ; PC735.2 v1(230.18,62.77) ; Y3.4 v1(127.45,159.93) ; v1(156.82,109.93) 156.09,109.21 PR1031.1 ; PR746.2 226.91,59.33 226.7,59.13 v1(226.7,58.68) ; v3(180.63,27.6) 180.3,27.6 PC1005.2 ; v3(240.43,42.52) PC105.2 PC106.2 ; C604.2 C605.2 v1(133.64,158.61) ; v1(168.11,79.49) 168.46,79.13 PC219.2 PR220.2 ; v1(103.97,167.07) 104.61,167.07 C736.2 ; v1(258.91,151.81) 259.81,151.81 U8.2 ; C719.2 v1(226.93,80.02) ; v1(32.47,100.58) 31.73,101.32 CH74.2 ; RC55.2 109.38,82.08 v1(109.69,82.38) ; v1(237.03,92.98) 237.02,92.97 R81.2 ; PC1004.2 v1(186.09,29.88) ; U5.2 26,163.68 v1(26.7,162.98) ; v1(253.68,75.4) JMINI2.26 ; C53.2 v1(53.03,7.99) ; CH4.1 25.32,92 25.89,92.57 v1(25.89,92.62) ; v1(123.35,159.04) R558.2 ; v1(72.37,19.44) 72.37,18.27 CC66.2 ; C777.2 95.39,151.8 94.92,151.33 v1(94.66,151.33) ; v1(39.56,159.83) 39.56,159.5 39.25,159.19 37.23,159.19 JRTC1.3 ; JMINI3.4 116.55,142.84 v1(116.55,141.34) ; v1(170.32,114.45) 170.3,114.44 R656.2 ; PC905.2 64.02,69.1 v3(66.46,69.1) ; JMINI4.53 v1(138.85,135.69) ; v1(115.02,154.72) 114.51,155.23 C742.2 ; v1(111.92,85.49) 112.12,85.68 CC138.2 ; v1(149.23,144.41) 149.08,144.56 C595.2 ; C1341.2 v1(242.86,93) ; CH68.2 CH67.2 CH69.2 35.04,121.09 v1(35.16,121.22) ; PC704.2 v1(180.2,44.11) ; R804.2 210.7,72.86 v1(210.6,72.96) ; C406.2 v1(167.29,70.01) ; v1(126.88,25.89) 127.09,26.1 JDIMM2.206 ; C483.2 v1(153.2,168.57) ; CH47.2 36.28,95.86 v1(36.43,95.71) ; C1347.2 v1(106.78,147.29) ; PQ1010.3 v1(217.26,48.62) ; RH76.2 v1(40.93,81.39) ; v1(36.43,97.33) 36.28,97.48 CH22.2 ; C52.2 54.64,7.4 v1(54.64,8.04) ; v1(177.3,87.44) 177.73,87.44 RC111.2 ; v1(253.68,65.8) JMINI2.50 ; C16.2 83.42,134.21 v1(83.89,133.74) ; C781.2 v1(94.4,156.5) ; C313.2 v1(258.59,157.2) ; R775.1 v1(219.74,92.7) ; Q22.3 49.3,156.57 v1(49.13,156.73) ; Q326.3 v1(25.42,152.94) ; C551.2 C48.2 159.13,117.27 159.52,117.66 v1(159.95,117.66) ; RC59.2 v1(90.08,34.5) ; CD72.2 184.21,88.53 v1(184.01,88.73) 183.99,88.75 CD71.2 ; PU703.4 v3(222.67,54.52) ; v1(58.58,77.43) 58.91,77.76 RC41.1 ; PR104.1 v1(243.15,63.32) ; v1(114.55,136.05) 114.55,134.64 JMINI3.9 ; C629.2 v1(242.22,37.48) ; C760.2 55.62,106.53 55.51,106.41 v1(55.51,106.36) ; v3(249.41,61.73) PR105.2 ; v1(134.67,141.74) 134.78,141.74 JMINI4.9 ; CD83.2 v1(170.47,30.52) ; C95.2 67.04,98.89 v1(67.34,98.59) ; PC1006.2 154.02,113.05 154.02,112.49 v1(153.5,111.97) ; v1(35.11,100.58) 35.11,99.96 CH42.2 ; v1(100.62,165.24) 100.64,165.21 C780.2 ; v1(235.24,79.44) 235.05,79.63 R79.2 ; PC116.2 v3(251.62,56.35) ; JSIM1.5 v1(242.08,34.28) ; CH70.2 33.92,104.99 33.16,104.99 v1(33.13,104.96) ; v1(28.15,100.87) 28.13,100.84 28.17,100.84 28.6,100.42 CH72.2 ; v1(153.04,112.55) 153.18,112.68 153.18,113.45 ; v1(114.99,150.95) 114.99,151.57 114.08,152.49 PC746.2 ; PC114.1 v3(247.86,64.03) ; R17.1 v1(221.01,72.25) ; v1(104.02,144.18) 104.02,144.21 104.05,144.23 104.55,143.73 JMINI3.26 ; C87.2 235.32,92.31 v1(234.82,92.81) ; v1(257.84,62.15) JMINI2.54 ; JFAN2.1 175.9,141.55 v1(175.93,141.58) ; JMINI2.37 261.5,71 261.97,71.47 v1(261.97,71.79) 261.96,71.8 JMINI2.35 ; PR1026.1 v3(207.09,37.81) ; PC302.2 17.52,136.66 PC303.2 16.95,137.59 v1(16.24,138.3) ; JMINI3.15 112.15,134.65 112.15,135.98 v1(112.1,136.03) ; PC213.2 v1(184.69,77.7) ; v1(244.71,37.48) 244.71,36.89 C628.2 ; PR1003.2 v1(184.95,28.99) ; C391.2 v1(173.13,42.5) ; PC702.1 v1(177.5,42.66) ; v1(158.45,111.75) C550.2 C553.2 ; v1(226.91,71.94) 226.62,71.66 Q322.3 ; PC205.2 v3(176.2,68.64) ; v1(142.85,155.15) 143.06,154.94 JMINI4.34 ; CD82.2 v1(171.36,30.52) ; R2141.1 224.96,88.24 v1(224.59,87.87) ; v1(36.83,147.84) 36.91,147.92 C499.2 ; PC1080.1 153.5,147.61 v1(153.7,147.81) ; PC1008.2 v1(144.56,118.15) ; RC71.2 v1(82.84,31.81) ; v1(18.73,162.57) 19.29,162.57 20.14,163.42 C47.2 19.34,163.99 v1(18.55,163.21) ; v1(85.05,103.93) 85.05,103.93 R39.2 ; C395.2 v1(167.29,69.12) ; v1(73.7,16.17) 74.09,16.56 74.09,17.36 74.44,17.71 R566.2 ; C56.2 v1(55.51,8.04) ; C740.2 v1(98.33,165.87) ; C552.2 169.54,111.45 v1(169.06,110.97) ; C1313.2 v1(214.33,60.41) ; v1(48.47,86.14) 47.53,85.2 U52.4 ; PR106.2 v1(243.2,62.35) ; PC736.2 v1(230.16,61.89) ; RH97.1 31.32,107.81 v1(30.69,107.18) ; v1(139.23,163.92) 138.15,164.99 JMINI4.54 ; v1(128.3,101.08) R14.2 ; v1(111.57,166.08) 111.57,165.95 111.07,165.45 C741.2 ; CE8.2 97.06,113.73 97.24,113.9 v1(97.24,114.44) ; v1(239.7,92.98) R77.2 239.72,92.31 C497.2 ; C481.2 v1(152.05,169.17) ; C616.2 v1(240.95,37.48) ; v1(44.64,156.5) 44.48,156.35 PC2.2 ; v3(244.79,54.76) 244.8,54.77 PC118.2 ; C453.2 234.92,89.88 234.12,89.08 v1(234.08,89.08) ; PC1003.2 v1(175.73,35.39) ; v1(258.99,68.6) JMINI2.43 ; RD37.1 v1(167.67,34.2) ; JSIM1.10 v1(240.68,34.3) ; CC65.2 73.06,13.04 73.51,13.5 v1(73.7,13.5) ; v1(259.12,77.4) JMINI2.21 ; v3(184.06,51.73) 183.9,51.88 PC745.2 ; RH187.2 27.47,98.79 v1(27.47,98.37) ; PQ7.3 v1(29.99,145.39) ; PC210.2 v1(184.69,78.97) ; v3(55.89,61.81) PC942.2 ; C630.2 v1(243.49,37.48) ; v1(102.33,144.99) R1069.2 C747.2 ; RC42.2 108.72,82.38 v1(108.82,82.38) ; PR224.2 v1(162.67,80.07) ; C119.2 v1(248.64,83.41) ; v1(113.95,154.6) 113.93,154.57 112.78,154.57 C1345.2 ; PR1001.2 v3(229.47,38.57) ; U35.15 v1(120.84,110.27) ; JMINI2.15 v1(258.67,83) ; C435.2 v1(52.71,106.69) ; v1(253.68,78.6) JMINI2.18 ; PR1028.2 v1(144.81,122.97) ; PR404.2 v1(264.45,36.74) ; v1(168.69,30.52) CD81.2 CD84.2 ; PC938.2 v3(55.89,65.01) ; C715.2 v1(257.42,107.55) ; PC120.2 v3(240.18,61.64)
  vias: v1(6.58,78) v1(6.64,77.13) v1(6.64,75.86) v1(6.64,74.71) v1(6.64,73.57) v1(6.79,114.36) v1(14.99,107.72) v1(17.31,112.48) v1(19.21,145.07) v1(19.36,161.4) v1(19.6,152.72) v1(20.23,158.79) v1(20.23,157.14) v1(20.23,155.48) v1(21.12,145.69) v1(22.09,151.23) v1(22.12,162.61) v1(22.26,158.79) v1(22.26,157.14) v1(22.26,155.48) v1(22.28,107.4) v1(23.91,158.79) v1(23.91,157.14) v1(23.91,155.48) v1(23.91,145.07) v1(26.17,166.71) v1(27.19,109.81) v1(28.15,164.96) v1(29.32,154.72) v1(29.37,152.03) v1(31.86,150.56) v1(34.45,161.78) v1(36.15,110.35) v1(36.23,156.37) v1(36.23,154.72) v1(36.23,151.67) v1(36.23,150.02) v1(37.58,31.13) v1(38.87,160.97) v1(39.45,163.23) v1(39.51,161.63) v1(39.61,122.31) v1(39.61,121.73) v1(39.79,72.21) v1(40.67,72.21) v1(41.16,47.46) v1(41.13,46.01) v1(45.17,92.21) v1(45.69,158.66) v1(45.88,35.85) v1(45.88,35.27) v1(46.14,90.49) v1(46.21,141.23) v1(46.34,134.86) v1(46.95,134.86) v1(47.56,103.87) v1(47.84,154.95) v1(48.69,154.68) v1(48.68,88.45) v1(49.01,105.42) v1(49.28,154.7) v1(49.28,141.45) v1(49.28,138.45) v1(49.26,136.69) v1(49.31,139.58) v1(49.79,89.34) v1(49.95,77) v1(51.11,19.39) v1(54.28,155.61) v1(56.74,155.95) v1(57.21,156.4) v1(57.82,5.75) v1(59.14,112.43) v1(60.92,112.48) v1(62.05,99.46) v1(62.68,112.48) v1(62.81,126.58) v1(63.67,148.14) v1(63.75,128.86) v1(63.76,109.59) v1(63.95,142.36) v1(63.95,140.07) v1(63.95,137.78) v1(64.32,107.2) v1(64.97,142.36) v1(64.97,140.07) v1(64.97,137.78) v1(65.99,142.36) v1(65.99,140.07) v1(65.99,137.78) v1(66.2,46.31) v1(66.23,45.68) v1(69.25,158.89) v1(69.66,158.41) v1(70.65,158.89) v1(70.82,15.66) v1(71.24,158.89) v1(72.4,148.99) v1(72.86,140.46) v1(72.89,135.19) v1(72.89,133.86) v1(72.92,137.59) v1(73.06,144.74) v1(74.06,144.18) v1(74.51,138) v1(75.43,108.96) v1(76.44,137.91) v1(78.57,137.88) v1(78.82,140.52) v1(79.41,158.15) v1(80.04,121.37) v1(80.45,123.76) v1(80.55,137.96) v1(81.72,138.52) v1(82.2,156.75) v1(83.24,130.21) v1(83.59,136.65) v1(83.6,158.15) v1(85,159.55) v1(84.92,156.75) v1(85.07,30.92) v1(86.75,31.74) v1(86.98,91.86) v1(87.13,110.04) v1(87.46,129.11) v1(88.1,33.31) v1(88.88,91.1) v1(88.91,110.04) v1(90.03,129.6) v1(90.92,91.1) v1(91.25,109.76) v1(92.57,110.04) v1(92.79,91.98) v1(94.85,109.92) v1(94.83,92.16) v1(96.1,110.02) v1(96.12,89.9) v1(96.94,128.84) v1(97.49,110.48) v1(97.47,91.43) v1(98.76,92.37) v1(99.81,110.15) v1(100.57,93.1) v1(101.33,110.15) v1(101.75,158.54) v1(101.76,156.5) v1(101.76,154.34) v1(101.99,132.37) v1(102.37,92.37) v1(102.55,110.48) v1(103.79,158.66) v1(103.75,156.52) v1(103.79,154.34) v1(103.89,109.64) v1(104.1,92.34) v1(104.19,29.67) v1(104.31,29) v1(104.9,29) v1(105.37,132.47) v1(105.83,156.5) v1(105.83,154.34) v1(106.13,110.48) v1(107.37,109.59) v1(107.37,91.55) v1(107.96,93.03) v1(109.15,109.61) v1(109.15,91.55) v1(110.3,91.35) v1(111.24,92.82) v1(111.87,91.6) v1(112.1,110.22) v1(113.01,92.8) v1(113.9,110.22) v1(114.41,148.6) v1(114.42,148) v1(114.46,92.09) v1(115.45,146.59) v1(120.25,106.11) v1(120.33,149.64) v1(120.35,101.05) v1(121.19,152.18) v1(121.19,149.9) v1(121.34,106.11) v1(121.52,160.39) v1(121.52,148.93) v1(121.73,32.53) v1(122.06,160.64) v1(122.34,151.04) v1(122.6,32.53) v1(123.48,152.18) v1(123.48,150) v1(123.48,32.53) v1(124.39,150.51) v1(124.37,32.54) v1(124.6,97.93) v1(124.88,106.72) v1(124.85,106.11) v1(125.03,138.59) v1(125.18,97.93) v1(125.26,32.54) v1(125.76,97.93) v1(126.02,106.72) v1(126.02,106.11) v1(126.15,32.52) v1(126.27,135.32) v1(126.35,97.93) v1(126.93,97.93) v1(127.03,32.54) v1(127.19,106.11) v1(127.52,97.93) v1(127.77,106.11) v1(127.92,32.53) v1(128.05,111.8) v1(128.05,111.16) v1(128.18,109.89) v1(128.18,108.62) v1(128.1,97.93) v1(128.33,135.42) v1(128.38,107.48) v1(128.35,106.11) v1(128.43,138.59) v1(128.69,97.93) v1(128.69,54.72) v1(128.82,60.77) v1(128.81,60.18) v1(128.94,106.11) v1(128.91,32.53) v1(129.27,54.72) v1(129.4,34.18) v1(129.85,54.72) v1(129.98,50.28) v1(129.98,34.18) v1(130.46,54.72) v1(130.56,50.28) v1(130.82,135.29) v1(131.83,138.59) v1(133.1,135.93) v1(134.22,47.11) v1(134.43,85.51) v1(134.93,88.3) v1(135.01,85.51) v1(135.16,83.22) v1(135.37,77.99) v1(135.54,88.3) v1(135.59,85.51) v1(135.64,71.89) v1(140.17,87) v1(140.16,84.97) v1(140.18,79.8) v1(140.14,47.39) v1(140.16,38.92) v1(140.21,81.91) v1(140.25,33.81) v1(140.33,90.26) v1(140.34,74.58) v1(140.33,44.27) v1(140.36,36.89) v1(140.3,28.48) v1(140.57,31.78) v1(140.67,71.47) v1(140.61,42.03) v1(140.7,35.33) v1(140.72,73.05) v1(140.8,45.85) v1(140.8,40.45) v1(140.99,76.61) v1(140.95,30.25) v1(141.05,83.45) v1(141.17,78.13) v1(141.21,88.64) v1(141.69,87.01) v1(141.69,84.97) v1(141.66,47.39) v1(141.68,38.92) v1(141.74,81.91) v1(141.7,79.8) v1(141.76,36.89) v1(141.77,33.81) v1(141.84,90.26) v1(141.87,74.58) v1(141.85,44.27) v1(141.83,28.48) v1(142.09,31.78) v1(142.2,71.47) v1(142.13,42.03) v1(142.53,76.61) v1(143.02,73.05) v1(143.09,45.86) v1(143.09,40.45) v1(143.09,36.89) v1(143.18,47.39) v1(143.22,87) v1(143.21,84.97) v1(143.26,81.91) v1(143.23,79.8) v1(143.2,38.92) v1(143.3,33.81) v1(143.24,30.25) v1(143.34,83.45) v1(143.39,74.58) v1(143.38,44.27) v1(143.35,28.48) v1(143.49,78.14) v1(143.52,90.26) v1(143.51,88.64) v1(144.05,76.61) v1(147.81,72.91) v1(148.55,45.81) v1(148.67,71.84) v1(149.16,45.81) v1(152.56,96.05) v1(153.2,96.05) v1(153.67,47.72) v1(153.62,44.63) v1(153.78,78.06) v1(153.8,90.17) v1(153.82,76.41) v1(153.84,74.37) v1(153.87,39.27) v1(153.87,33.81) v1(153.92,84.85) v1(153.92,79.61) v1(153.96,71.09) v1(154.09,83.2) v1(154.03,37.12) v1(154.14,81.65) v1(154.24,72.83) v1(154.28,42.32) v1(154.21,28.43) v1(154.44,88.44) v1(154.46,46.18) v1(154.57,40.8) v1(154.66,35.56) v1(154.61,31.77) v1(154.72,30.25) v1(155.2,47.72) v1(155.15,44.63) v1(155.32,90.17) v1(155.34,86.91) v1(155.34,76.41) v1(155.36,74.37) v1(155.39,39.27) v1(155.4,33.81) v1(155.45,84.85) v1(155.45,79.61) v1(155.51,71.11) v1(155.57,37.13) v1(155.66,81.65) v1(155.74,28.43) v1(155.81,42.32) v1(156.07,78.06) v1(156.13,31.77) v1(156.39,83.19) v1(156.6,143.83) v1(156.55,72.83) v1(156.67,44.63) v1(156.72,88.44) v1(156.72,47.72) v1(156.75,46.18) v1(156.73,40.8) v1(156.85,90.17) v1(156.86,86.91) v1(156.87,76.41) v1(156.88,74.37) v1(156.88,35.56) v1(156.97,84.85) v1(156.97,79.61) v1(156.93,39.25) v1(156.92,33.81) v1(157.05,71.09) v1(157,30.25) v1(157.19,81.65) v1(157.11,37.12) v1(157.26,28.44) v1(158.3,143.83) v1(161.55,143.85) v1(163.51,143.93) v1(164.19,143.9) v1(164.25,34.39) v1(164.25,33.69) v1(166.05,143.9) v1(166.54,48.27) v1(167.8,134.66) v1(167.8,133.26) v1(167.8,131.86) v1(169.07,134.66) v1(169.07,133.26) v1(169.07,131.86) v1(169.11,118.79) v1(169.25,143.55) v1(169.58,72.17) v1(169.69,118.81) v1(170.47,134.66) v1(170.47,133.26) v1(170.47,131.86) v1(170.71,143.74) v1(178.49,140.71) v1(180.27,76.45) v1(208.09,58.02) v1(215.78,83.47) v1(215.81,81.19) v1(215.81,79.03) v1(216.57,64.3) v1(216.62,65.77) v1(217.29,65.06) v1(217.97,83.6) v1(217.92,81.27) v1(217.97,79.03) v1(217.99,65.72) v1(218.09,64.3) v1(218.99,92.74) v1(220.12,83.55) v1(220.13,81.32) v1(220.13,79.03) v1(223.6,65.52) v1(223.99,64.07) v1(225.59,56.42) v1(226.22,56.42) v1(226.86,56.42) v1(227.52,92.01) v1(229.09,86.88) v1(229.24,79.67) v1(229.68,89.16) v1(230.78,91.87) v1(230.77,75.88) v1(231.2,89.14) v1(231.76,86.35) v1(233.01,86.9) v1(233.61,78.7) v1(236.64,19.09) v1(239.38,84.42) v1(239.45,87.28) v1(240.14,80.63) v1(240.84,85.88) v1(241.97,81.16) v1(242.3,87.28) v1(242.3,84.36) v1(243.75,80.66) v1(247.73,86.09) v1(247.94,89.72) v1(249.83,81.67) v1(249.84,79.83) v1(250.24,19.09) v1(253.4,89.65) v1(253.72,70.1) v1(253.81,106.26) v1(254.12,113.13) v1(257.58,76.79) v1(257.61,75.55) v1(257.96,72.41) v1(258.04,73.78) v1(258.86,121.18) v1(259.11,100.94) v1(259.11,100.3) v1(260.68,119.59) v1(260.84,120.48) v1(261.55,125.39) v1(261.55,124.8) v1(263.18,58.08) v1(265.08,58.08) v1(266.1,58.05) v1(267.5,57.06) v1(267.62,62.9) v1(267.62,62.27) v1(267.62,61.63) v1(267.62,61) v1(271.91,126.83) v1(271.91,126.2) v1(272.55,126.83) v1(272.55,126.2) v1(272.58,122.1) v1(272.58,121.46) v1(273.22,122.1) v1(273.22,121.46) v3(0.51,84.75) v3(0.51,79.67) v3(0.51,74.59) v3(1.39,89.92) v3(3.69,95.34) v3(4.73,76.24) v3(4.73,75.6) v3(4.73,74.97) v3(4.88,99.47) v3(5.37,77.51) v3(5.37,76.87) v3(5.37,76.24) v3(5.37,75.6) v3(5.37,74.97) v3(5.42,68.93) v3(5.75,104.55) v3(5.99,65.31) v3(6.01,114.7) v3(6.01,109.62) v3(6,77.51) v3(6,76.87) v3(6,76.24) v3(6,75.6) v3(6.51,163.88) v3(6.51,158.8) v3(6.51,153.72) v3(6.51,148.64) v3(6.51,143.56) v3(7.86,177.26) v3(7.86,172.18) v3(7.85,167.11) v3(8.26,133.35) v3(8.26,128.34) v3(9.18,70.52) v3(9.18,69.89) v3(10.45,172.63) v3(11.07,71.82) v3(11.02,65.31) v3(11.26,138.35) v3(11.72,71.79) v3(11.97,120.89) v3(12.06,176.16) v3(12.09,172.66) v3(14.39,70.52) v3(14.39,69.89) v3(14.33,66.04) v3(16.19,65.31) v3(17.31,171.49) v3(17.74,88.2) v3(18.45,130.47) v3(19.72,127.93) v3(20.61,128.56) v3(20.61,127.93) v3(20.86,66.33) v3(21.18,65.31) v3(21.5,66.33) v3(22.13,66.33) v3(22.77,66.33) v3(22.82,172.17) v3(22.96,140.6) v3(22.96,139.93) v3(22.94,139.24) v3(23.08,177.17) v3(23.02,138.59) v3(23.02,75.09) v3(23.28,75.73) v3(23.4,66.33) v3(23.66,140.65) v3(23.63,139.96) v3(23.63,139.25) v3(23.69,138.57) v3(23.66,75.09) v3(23.91,75.73) v3(24.77,66.04) v3(25.18,139.94) v3(25.22,141.23) v3(25.21,140.6) v3(25.87,141.23) v3(25.84,140.59) v3(25.87,139.95) v3(26.3,65.31) v3(26.45,171.23) v3(27.33,176.43) v3(27.34,173.14) v3(27.72,169.33) v3(28.1,66.08) v3(30.13,169.33) v3(30.51,173.26) v3(31.28,171.23) v3(31.36,65.31) v3(31.66,176.47) v3(32.53,73.72) v3(33.21,73.76) v3(34.61,53.46) v3(34.61,48.38) v3(34.61,43.3) v3(34.61,38.22) v3(34.61,33.14) v3(35.29,176.79) v3(35.62,172.75) v3(35.72,63.68) v3(35.73,58.6) v3(35.94,28.07) v3(36.01,18.5) v3(36.01,12.76) v3(36.81,23.35) v3(36.86,18.2) v3(36.86,15.78) v3(37.35,21.85) v3(37.37,8.51) v3(37.63,19.34) v3(37.75,14.64) v3(37.75,11.34) v3(37.85,25.16) v3(39.15,14.26) v3(39.2,21.04) v3(40.55,14.64) v3(40.55,11.34) v3(40.95,21.85) v3(41.03,172.19) v3(41.46,6.63) v3(44.64,73.52) v3(44.64,72.76) v3(44.64,71.87) v3(44.64,70.98) v3(44.64,70.09) v3(44.64,67.5) v3(44.64,66.53) v3(44.64,63.87) v3(44.66,4.38) v3(44.69,0.54) v3(44.89,58.41) v3(44.89,57.64) v3(44.89,56.76) v3(44.89,55.87) v3(44.89,54.98) v3(45.12,162.34) v3(45.15,65.65) v3(45.15,64.76) v3(45.12,61.89) v3(45.12,61.12) v3(45.12,60.36) v3(45.37,163.87) v3(45.58,74.92) v3(45.58,74.25) v3(46.01,160.95) v3(46.11,172.19) v3(46.21,74.28) v3(46.26,43.72) v3(46.26,42.71) v3(46.26,41.82) v3(46.26,40.93) v3(46.26,40.17) v3(46.54,58.41) v3(46.54,57.64) v3(46.54,56.76) v3(46.54,55.87) v3(46.54,54.98) v3(46.92,73.52) v3(46.92,72.76) v3(46.92,71.87) v3(46.92,70.98) v3(46.92,70.09) v3(46.92,67.55) v3(46.92,66.53) v3(46.92,63.87) v3(47.66,160.18) v3(48.42,43.72) v3(48.42,42.71) v3(48.42,41.82) v3(48.42,40.93) v3(48.42,40.17) v3(48.97,172.74) v3(48.93,160.44) v3(49.32,178.17) v3(49.69,161.33) v3(50.06,0.51) v3(50.2,162.72) v3(51.98,27.19) v3(51.98,26.2) v3(51.98,25.21) v3(52.93,26.2) v3(53.88,27.19) v3(54.14,166.53) v3(54.64,173.77) v3(54.9,167.8) v3(55.15,172.5) v3(55.14,0.51) v3(55.28,175.3) v3(56.73,168.5) v3(56.8,176.19) v3(56.93,171.49) v3(58.58,167.68) v3(58.96,172.88) v3(59.09,164.76) v3(59.22,174.79) v3(59.34,166.15) v3(60.22,0.51) v3(65.03,163.87) v3(65.3,0.51) v3(65.37,174.55) v3(65.67,163.87) v3(66.2,73.95) v3(66.2,73.19) v3(66.2,72.53) v3(66.2,71.77) v3(70.38,0.51) v3(70.45,174.55) v3(75.46,0.51) v3(75.53,174.55) v3(80.54,0.51) v3(80.61,174.55) v3(81.09,10.73) v3(81.09,5.65) v3(81.44,15.32) v3(85.51,19.31) v3(85.69,174.55) v3(85.81,58.2) v3(85.81,56.22) v3(85.81,54.39) v3(85.81,52.49) v3(85.81,50.58) v3(85.81,48.68) v3(88.68,58.41) v3(88.68,57.44) v3(89.44,58.41) v3(89.44,57.44) v3(89.7,63.16) v3(89.7,62.52) v3(89.7,61.89) v3(90.2,58.41) v3(90.2,57.44) v3(90.33,63.16) v3(90.33,62.52) v3(90.33,61.89) v3(90.89,22.31) v3(93.33,67.68) v3(93.33,65.8) v3(93.33,63.99) v3(93.33,61.96) v3(93.33,60.06) v3(93.33,58.15) v3(93.33,56.22) v3(93.33,54.34) v3(93.33,52.41) v3(93.33,50.66) v3(93.33,48.63) v3(94.52,22.32) v3(100.11,20.61) v3(100.49,21.75) v3(100.75,19.34) v3(100.93,175.09) v3(104.17,19.34) v3(104.81,20.61) v3(106.01,175.09) v3(107.78,19.91) v3(111.09,175.09) v3(112.86,19.91) v3(116.17,175.09) v3(117.94,19.91) v3(121.25,175.09) v3(123.02,19.91) v3(126.33,175.09) v3(128.02,19.91) v3(129.07,165.77) v3(129.7,164.25) v3(130.08,167.93) v3(131.06,15.14) v3(131.41,175.09) v3(131.61,163.36) v3(131.86,168.57) v3(133.64,164.25) v3(134.27,165.77) v3(135.8,15.14) v3(136.49,175.09) v3(141.13,103.29) v3(141.23,15.14) v3(141.57,175.09) v3(144.05,102.14) v3(146.41,15.15) v3(146.65,175.09) v3(150,122.01) v3(149.97,120.28) v3(149.97,118.55) v3(151.7,122.01) v3(151.73,175.09) v3(151.7,120.28) v3(152,16.95) v3(152.14,15.91) v3(153.42,122.01) v3(153.42,120.28) v3(153.42,118.55) v3(154.47,173.52) v3(155.61,17.82) v3(155.67,15.81) v3(155.94,16.76) v3(156.81,175.09) v3(158.14,173.5) v3(160.18,126.15) v3(160.56,124.5) v3(160.94,127.8) v3(161.65,15.15) v3(161.83,123.48) v3(163.74,123.48) v3(164.5,84.36) v3(164.5,83.73) v3(165.01,124.62) v3(165.17,84.35) v3(165.17,83.69) v3(165.64,57.95) v3(165.77,62.52) v3(165.77,60.11) v3(165.77,54.39) v3(165.79,52.89) v3(165.9,63.69) v3(165.9,61.5) v3(165.9,59.09) v3(165.9,56.68) v3(165.9,55.15) v3(166.29,73.01) v3(166.29,72.38) v3(166.28,71.74) v3(166.28,44.23) v3(166.28,43.6) v3(166.28,42.96) v3(166.65,15.14) v3(167.67,60.49) v3(171.73,15.14) v3(173.14,38.39) v3(173.14,37.76) v3(173.14,37.12) v3(173.14,36.49) v3(173.36,173.55) v3(173.64,76.87) v3(174.28,76.87) v3(176.05,171.98) v3(176.84,15.14) v3(177.2,130.39) v3(177.2,69.89) v3(177.2,69.25) v3(177.21,135.69) v3(177.4,77.53) v3(177.4,76.67) v3(177.63,49.11) v3(177.63,47.89) v3(177.83,71.16) v3(177.83,70.52) v3(177.83,69.89) v3(177.83,69.25) v3(178.17,125.11) v3(178.27,77.53) v3(178.27,76.67) v3(178.23,48.5) v3(178.47,71.16) v3(178.47,70.52) v3(178.47,69.89) v3(178.47,69.25) v3(178.62,162.03) v3(178.62,156.95) v3(178.72,167.55) v3(178.88,51.85) v3(178.85,51.22) v3(178.85,49.11) v3(178.84,47.9) v3(179.1,71.16) v3(179.1,70.52) v3(179.1,69.89) v3(179.1,69.25) v3(179.73,148.69) v3(179.74,144.05) v3(179.74,138.78) v3(179.74,71.16) v3(179.74,70.52) v3(179.74,69.89) v3(179.74,69.25) v3(180.26,155.67) v3(180.37,71.16) v3(180.37,70.52) v3(180.37,69.89) v3(180.37,69.25) v3(180.54,169.93) v3(180.54,164.4) v3(180.81,76.15) v3(181.28,160.15) v3(181.9,17.56) v3(181.94,15.15) v3(182.74,157.17) v3(183.59,124.01) v3(184.18,16.17) v3(184.84,119.66) v3(185.07,47.92) v3(185.07,47.15) v3(185.07,46.39) v3(185.71,47.53) v3(185.71,46.77) v3(185.84,105.57) v3(185.84,51.22) v3(186.47,47.53) v3(186.47,46.77) v3(186.6,48.3) v3(186.72,106.84) v3(186.82,114.97) v3(186.98,17.44) v3(187.02,15.15) v3(187.36,48.3) v3(187.36,47.53) v3(188.12,107.73) v3(188.12,48.3) v3(188.12,47.53) v3(188.25,89.44) v3(188.25,27.21) v3(188.38,16.17) v3(188.76,90.59) v3(188.76,28.74) v3(189.01,48.3) v3(189.01,47.53) v3(189.66,110.24) v3(189.65,91.6) v3(189.9,48.3) v3(189.9,47.53) v3(189.9,29.88) v3(190.28,102.91) v3(191.18,19.31) v3(191.42,103.8) v3(191.8,105.19) v3(193.2,86.52) v3(193.84,29.5) v3(194.09,87.41) v3(194.22,104.88) v3(194.34,26.07) v3(194.6,88.68) v3(194.6,27.98) v3(196.26,19.31) v3(197.43,102.09) v3(197.77,60.49) v3(197.77,57.82) v3(198.79,60.49) v3(198.79,57.82) v3(199.68,60.49) v3(199.68,57.82) v3(201.34,19.31) v3(201.92,99.08) v3(206.42,20.11) v3(206.67,96.79) v3(208.35,45.98) v3(208.4,45.32) v3(209.18,37.86) v3(209.81,37.86) v3(211.08,37.86) v3(211.5,20.11) v3(211.69,95.19) v3(211.72,37.86) v3(216.58,20.11) v3(217.28,94.25) v3(221.78,19.31) v3(225.33,94.37) v3(225.41,15.51) v3(230.36,95.36) v3(230.49,15.51) v3(233.08,20.1) v3(234.94,17.71) v3(235.18,97.1) v3(236.51,56.42) v3(237.27,56.42) v3(238.03,56.42) v3(238.79,56.42) v3(239.69,99.52) v3(243.78,102.24) v3(244.51,53.38) v3(244.51,52.74) v3(244.51,52.11) v3(244.51,51.47) v3(245.14,53.38) v3(245.14,52.74) v3(245.14,52.11) v3(245.14,51.47) v3(245.4,50.71) v3(245.4,50.07) v3(245.78,53.38) v3(245.78,52.74) v3(245.78,52.11) v3(245.78,51.47) v3(246.03,50.71) v3(246.03,50.07) v3(246.19,59.9) v3(246.19,59.09) v3(246.54,66.33) v3(246.54,65.7) v3(246.97,59.9) v3(246.97,59.09) v3(247.3,53.15) v3(247.3,52.02) v3(247.3,51.38) v3(247.3,50.75) v3(247.3,50.11) v3(247.56,67.47) v3(247.66,52.58) v3(247.94,51.97) v3(247.94,51.33) v3(247.94,50.7) v3(247.94,50.06) v3(248.57,51.97) v3(248.57,51.33) v3(248.57,50.7) v3(248.57,50.06) v3(248.69,100.81) v3(249.21,50.07) v3(249.34,49.44) v3(250.28,110.07) v3(250.38,105.71) v3(251.19,17.71) v3(251.62,34.96) v3(251.62,34.33) v3(252.7,114.53) v3(253.27,19.98) v3(254.45,119.34) v3(254.67,56.55) v3(255.48,124.38) v3(255.43,56.55) v3(255.76,134.54) v3(255.76,129.46) v3(255.85,16.27) v3(256.19,56.55) v3(256.96,56.55) v3(257.46,162.11) v3(257.46,157.03) v3(257.46,151.95) v3(257.46,146.87) v3(257.46,141.79) v3(257.46,136.71) v3(257.84,19.98) v3(259.62,31.2) v3(260.03,31.74) v3(260.38,95.67) v3(260.38,17.18) v3(260.47,163.98) v3(260.64,33.82) v3(260.64,33.18) v3(260.89,97.95) v3(260.89,97.32) v3(260.96,168.52) v3(261.02,18.96) v3(261.4,33.82) v3(261.4,33.18) v3(262.04,35.09) v3(262.16,169.96) v3(262.16,166.91) v3(262.29,172.63) v3(262.67,100.24) v3(263.05,19.72) v3(263.05,14.77) v3(263.18,98.72) v3(263.31,80.43) v3(263.81,79.92) v3(263.94,168.95) v3(264.83,173.14) v3(264.83,15.66) v3(264.96,97.83) v3(265.46,17.18) v3(265.72,169.96) v3(265.72,78.14) v3(265.85,172.25) v3(265.85,25.06) v3(265.87,21.75) v3(266.23,77.63) v3(266.48,101.89) v3(266.48,98.59) v3(266.86,91.86) v3(267.24,100.24) v3(267.96,168.43) v3(268,94.91) v3(268,30.39) v3(268,24.17) v3(269.15,91.98) v3(269.15,86.02) v3(269.53,173.14) v3(269.53,168.44) v3(269.66,116.11) v3(269.66,113.45) v3(269.91,133.13) v3(270.04,137.7) v3(270.29,29.5) v3(270.29,25.18) v3(270.54,90.97) v3(270.67,87.29) v3(271.18,27.21) v3(271.31,101.64) v3(271.31,96.56) v3(271.31,89.06) v3(271.43,84.11) v3(271.94,169.56) v3(272.29,140.07) v3(272.29,135) v3(272.29,129.92) v3(272.29,118.45) v3(272.29,113.37) v3(272.29,108.29) v3(272.32,160.82) v3(272.32,153.33) v3(272.96,25.06) v3(273.08,30.26) v3(273.21,34.71) v3(273.59,91.1) v3(273.59,86.14) v3(273.59,81.44) v3(275.04,165.25) v3(275.04,160.17) v3(275.04,155.09) v3(275.04,150.01) v3(275.04,144.93) v3(275.04,125.76) v3(275.04,120.68) v3(275.04,104.29) v3(275.04,99.21) v3(275.04,94.13) v3(275.04,89.05) v3(275.04,83.97) v3(275.04,78.89) v3(275.04,73.81) v3(275.04,68.73) v3(275.04,63.65) v3(275.04,58.57) v3(275.04,53.49) v3(275.04,48.41) v3(275.04,43.33) v3(275.04,38.25) v3(275.04,33.17) v3(275.04,28.09) v3(275.01,23.07) v4(20.33,145.07) v4(21.79,154.09) v4(24.56,139.19) v4(46.38,67.05) v4(46.36,50.79) v4(47.06,61.9) v4(47.86,38.34) v4(48.31,138.45) v4(55.91,156.27) v4(56.84,113.37) v4(58.47,96.21) v4(63.78,73.71) v4(64.35,163.03) v4(68.94,158.2) v4(121.85,111.42) v4(122.42,152.42) v4(126.04,139.51) v4(130.64,137.87) v4(165.81,52.14) v4(260.14,97.88)
