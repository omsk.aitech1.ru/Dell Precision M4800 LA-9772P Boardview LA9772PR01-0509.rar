# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3RP3: length 104.1
  TOP w0.102: v1(41.13,102.86) 41.32,102.67 UH1.AY31
  IN3 w0.089: 42.12,103.2 42.11,103.2 42.08,103.24 41.03,103.24 40.95,103.16 40.95,103.04 v1(41.13,102.86)
  IN3 w0.127: 42.12,103.2 43.34,103.2 43.86,102.68 49.34,102.68 51.34,104.69 64.45,104.69 65.81,106.05 65.81,112.46 64.77,113.51 64.77,125.62 64.94,125.79 64.94,127.08 69.35,131.5 69.35,139.53 71.23,141.41 83.86,141.41 88.41,136.86 88.41,128.57 92.89,124.09 94.79,124.09 95.09,124.39 95.09,124.68 v1(95.28,124.88)
  BOTTOM w0.102: v1(95.28,124.88) 95.06,125.1 95.06,125.26 95.2,125.4 JDOCK1.86
USB3RP5: length 43.8
  TOP w0.102: v1(39.83,101.85) 40.13,101.55 UH1.AV29 ; JIO1.47 8.68,97.2 8.89,97.41 11.12,97.41 v1(11.34,97.19)
  IN3 w0.089: 41.28,101.22 41.26,101.22 41.23,101.26 40.17,101.26 39.98,101.44 39.98,101.7 v1(39.83,101.85)
  IN3 w0.127: 41.28,101.22 41.95,101.22 42.39,100.79 42.39,100.45 41.31,99.38 36.91,99.38 36.69,99.6 33.68,99.6 32.65,98.56 30.49,98.56 29.9,97.98 26.78,97.98 26.64,98.12 24.91,98.12 24.64,98.38 24.19,98.38 23.7,98.87 23.7,99.1 23.31,99.5 17.46,99.5 17.28,99.68 13.06,99.68 12.05,98.66 10.88,98.66 10.58,98.36 10.58,97.67 10.87,97.37 11.15,97.37 v1(11.34,97.19)
USB3RP6: length 41.6
  TOP w0.102: v1(9.31,93.61) 9.12,93.79 8.92,93.79 8.73,93.6 JIO1.59 ; v1(37.98,101.84) 38.34,101.48 UH1.AP29
  IN3 w0.089: 37.65,101.36 37.66,101.36 37.7,101.32 37.92,101.32 37.98,101.38 v1(37.98,101.84)
  IN3 w0.127: 37.65,101.36 32.32,101.36 31.81,100.85 31.81,100.67 31.33,100.19 30.54,100.19 29.75,99.4 26.73,99.4 26.38,99.75 25.51,99.75 24.64,100.62 24.64,100.86 23.99,101.5 21.72,101.5 21.67,101.45 18.61,101.45 18.53,101.53 12.05,101.53 10.58,100.06 10.58,99.45 9.82,98.69 9.82,97.34 10.32,96.84 10.32,95.77 10.04,95.48 9.05,95.48 8.5,94.93 8.5,93.96 8.75,93.71 9.2,93.71 v1(9.31,93.61)
USB3TN1: length 218.1
  TOP w0.076: UH1.BE24 43.49,99.5 43.67,99.68 44.01,99.68 v1(44.4,99.3)
  IN4 w0.117: v1(44.4,99.3) 44.2,99.49 44.2,99.71 44.33,99.83 48.07,99.83 49.69,101.46 49.69,101.79 52.3,104.4 53.84,104.4 54.25,104 65.51,104 66.93,105.42 75.52,105.42 75.88,105.78 77.7,105.78 77.98,105.5 85.4,105.5 86.19,104.71 114.36,104.71 115.12,103.95 138.74,103.95 140.18,102.5 142.61,102.5 143.26,103.16 146.65,103.16 147.22,103.74 162.32,103.74 164.07,101.99 175.49,101.99 186.93,90.56 186.93,88.53 190,85.46 196.43,85.46 203.11,78.78 203.11,77.5 207.42,73.19 207.42,72.96 210.55,69.83 218.9,69.83 220.65,71.58 222.99,71.58 227.68,76.27 227.68,77.15 230.03,79.51 230.03,80.3 229.62,80.71 228.89,80.71 v1(228.79,80.81)
  BOTTOM w0.102: C452.2 228.9,82.02 229.12,81.8 229.12,81.39 229.4,81.11 229.4,80.8 229.09,80.49 228.91,80.49 228.79,80.61 v1(228.79,80.81)
USB3TN1_C: length 2.2
  BOTTOM w0.102: C452.1 229.02,83.25 229.02,83.78 229.13,83.89 229.13,84.31 229.05,84.4 U638.27
USB3TN1_RP: length 43.8
  TOP w0.102: L42.2 254.65,112.7 254.31,112.36 254.19,112.36 v1(254.01,112.55)
  IN3 w0.127: v1(254.01,112.55) 253.83,112.37 253.16,112.37 252.03,111.24 252.03,100.01 247.54,95.51 235.33,95.51 232.93,93.12 228.63,93.12 228.25,92.74 228.25,92.16 v1(228.11,92.01)
  BOTTOM w0.102: v1(228.11,92.01) 228.33,91.79 228.33,91.33 C488.1
USB3TN1_RP_C: length 2.7
  BOTTOM w0.102: C488.2 228.35,89.73 228.35,89.49 228.65,89.19 228.65,89.18 229.05,88.78 229.06,88.78 229.14,88.7 229.14,88.5 229.05,88.4 U638.1
USB3TN2: length 221.8
  TOP w0.076: UH1.BD25 42.84,99.85 42.95,99.85 43.08,99.97 43.35,99.97 43.42,100.05 43.65,100.05 43.68,100.07 43.7,100.07
  TOP w0.102: 43.7,100.07 45.74,100.07 45.96,99.86 45.96,99.45 46.11,99.3 v1(46.25,99.3)
  IN4 w0.117: v1(231.76,80.81) 231.76,80.63 231.58,80.45 231.33,80.45 230.99,80.11 230.99,79.76 228.18,76.95 228.18,74.53 224.9,71.26 223.76,71.26 222.26,69.76 219.79,69.76 219.35,69.31 209.81,69.31 202.52,76.59 202.52,78.25 195.81,84.96 189.41,84.96 186.22,88.15 186.22,90.5 175.52,101.21 162.87,101.21 160.84,103.24 149.18,103.24 147.63,101.69 139.91,101.69 138.34,103.26 124.7,103.26 124.15,102.71 118.68,102.71 117.95,103.45 111.46,103.45 110.7,104.21 85.85,104.21 85.07,105 77.75,105 77.48,105.28 76.17,105.28 75.78,104.89 67.12,104.89 65.73,103.5 52.11,103.5 50.27,101.66 50.27,100.87 49.75,100.36 49.67,100.36 49.61,100.36 49.33,100.08 49.33,100.02 49.33,99.94 49.09,99.69 49,99.69 49,99.69 48.94,99.69 48.66,99.42 48.66,99.35 48.66,99.27 48.19,98.79 46.14,98.79 46.02,98.91 46.02,99.06 v1(46.25,99.3)
  BOTTOM w0.102: v1(231.76,80.81) 231.76,80.59 231.91,80.44 232.08,80.44 232.22,80.58 232.22,81.24 231.96,81.49 231.96,81.82 231.7,82.08 C456.2
USB3TN2_C: length 2.2
  BOTTOM w0.102: U638.21 231.45,84.4 231.54,84.3 231.54,83.75 231.87,83.42 231.87,83.31 C456.1
USB3TN2_RP: length 60.4
  TOP w0.102: v1(261.55,123.59) 261.46,123.68 261.17,123.68 260.88,123.39 v3(260.33,123.39) 260.09,123.39 259.9,123.58 259.9,124.09 259.73,124.26 L44.2
  IN3 w0.127: v1(231.41,91.87) 231.48,91.79 231.48,91.27 231.86,90.9 232.47,90.9 232.7,91.13 233.21,91.13 234.16,92.08 234.16,92.78 235.79,94.4 248,94.4 253.06,99.46 253.06,109.59 254.81,111.35 254.81,116.83 257.23,119.25 257.23,123.05 257.84,123.66 261.49,123.66 v1(261.55,123.59)
  BOTTOM w0.102: C492.1 231.63,91.33 231.63,91.65 v1(231.41,91.87)
USB3TN2_RP_C: length 2.4
  BOTTOM w0.102: C492.2 231.68,89.7 231.68,88.97 231.54,88.83 231.54,88.54 231.45,88.45 U638.7
USB3TN3: length 102.1
  TOP w0.102: UH1.BE32 43.34,102.66 43.45,102.66 43.74,102.95 46.06,102.95 46.14,103.03 46.14,103.16 46.01,103.29 46.01,103.54 45.8,103.74 45.8,103.9 45.93,104.02 46.35,104.02 46.48,103.9 v1(46.48,103.45)
  IN3 w0.127: v1(46.48,103.45) 46.69,103.66 46.69,104.18 47.06,104.55 49.15,104.55 50.3,105.69 64.02,105.69 64.81,106.49 64.81,111.77 63.76,112.82 63.76,126.04 63.93,126.21 63.93,127.5 68.34,131.91 68.34,135.71 67.57,136.48 67.57,139.45 70.62,142.5 84.24,142.5 90.19,136.55 90.19,132.97 95.46,127.7 96.51,127.7 96.63,127.82 96.63,128.08 v1(96.45,128.26)
  BOTTOM w0.102: JDOCK1.90 96.2,127.19 96.34,127.33 96.34,127.61 96.62,127.89 96.62,128.09 v1(96.45,128.26)
USB3TN5: length 60.3
  TOP w0.102: v1(46.99,101.34) 46.99,101.04 46.9,100.95 46.24,100.95 45.7,100.41 43.35,100.41 UH1.BE26 ; JIO1.51 8.72,96 8.91,95.81 9.04,95.81 9.13,95.9 9.13,96.18 9.37,96.42 9.62,96.42 v1(9.81,96.61)
  IN3 w0.127: v1(46.99,101.34) 47.18,101.15 47.33,101.15 48.95,99.53 48.95,99.05 48.53,98.62 44.28,98.62 42.34,96.67 36.52,96.67 34.81,94.96 30.08,94.96 29.88,94.76 25.82,94.76 23.83,92.77 22.92,92.77 22.84,92.85 15.13,92.85 14.89,92.62 12.76,92.62 11.09,90.95 10.01,90.95 7.74,93.23 7.74,95.26 8.9,96.42 9.63,96.42 v1(9.81,96.61)
USB3TN6: length 48.1
  TOP w0.076: UH1.BD27 42.87,100.8 44.6,100.8 45.03,101.24 v1(45.03,101.34)
  TOP w0.102: JIO1.63 8.73,92.4 8.92,92.21 9.89,92.21 9.93,92.17 10.33,92.17 v1(10.58,92.42)
  IN3 w0.127: v1(10.58,92.42) 10.58,92.24 10.47,92.14 10.27,92.14 9.89,92.51 9.89,93.13 10.15,93.39 10.28,93.39 10.8,93.91 10.8,94.77 14.2,98.16 16.37,98.16 16.69,98.49 21.67,98.49 22.81,97.35 23.83,97.35 24.37,96.82 26.35,96.82 26.5,96.66 32.72,96.66 33.18,97.11 33.18,97.27 33.66,97.75 37.38,97.75 37.41,97.71 41.65,97.71 44.73,100.8 44.73,101.17 44.9,101.34 v1(45.03,101.34)
USB3TP1: length 218.3
  TOP w0.076: UH1.BD23 42.76,99.1 42.68,99.01 42.68,98.87 42.77,98.78 42.91,98.78 43.09,98.96 43.09,99.08 43.21,99.21 43.73,99.21 v1(43.81,99.3)
  IN4 w0.117: v1(228.79,80.1) 228.79,80.22 229.03,80.47 229.53,80.47 229.79,80.2 229.79,79.61 227.44,77.25 227.44,76.36 222.89,71.82 220.56,71.82 218.8,70.06 210.64,70.06 207.65,73.05 207.65,73.29 203.34,77.6 203.34,78.87 196.52,85.69 190.1,85.69 187.16,88.63 187.16,90.66 175.59,102.23 164.17,102.23 162.42,103.97 147.13,103.97 146.55,103.4 143.17,103.4 142.51,102.74 140.28,102.74 138.84,104.18 115.22,104.18 114.45,104.95 86.28,104.95 85.5,105.73 78.08,105.73 77.8,106.01 75.78,106.01 75.42,105.66 66.84,105.66 65.41,104.23 54.34,104.23 53.94,104.64 52.21,104.64 49.45,101.89 49.45,101.56 47.97,100.07 44.23,100.07 43.97,99.8 43.97,99.45 v1(43.81,99.3)
  BOTTOM w0.102: v1(228.79,80.1) 228.96,80.27 229.18,80.27 229.61,80.71 229.61,81.2 229.33,81.48 229.33,81.76 229.59,82.01 C454.2
USB3TP1_C: length 2.2
  BOTTOM w0.102: U638.26 229.45,84.39 229.35,84.29 229.35,83.81 229.23,83.69 229.23,83.29 C454.1
USB3TP1_RP: length 43.4
  TOP w0.102: L42.3 254.7,111.85 254.41,112.15 254.19,112.15 v1(254.01,111.96)
  IN3 w0.127: v5(228.74,92.01) 228.68,92.01 228.5,92.19 228.5,92.64 228.73,92.87 233.04,92.87 235.43,95.26 247.64,95.26 252.28,99.91 252.28,111.14 253.26,112.12 253.85,112.12 v1(254.01,111.96)
  BOTTOM w0.102: v5(228.74,92.01) 228.55,91.81 228.55,91.34 C489.1
USB3TP1_RP_C: length 2.7
  BOTTOM w0.102: U638.2 229.45,88.38 229.36,88.47 229.36,88.79 v3(229.02,89.13) 228.57,89.58 228.57,89.77 C489.2
USB3TP2: length 221.9
  TOP w0.076: UH1.BC24 42.4,99.55 42.89,99.55 43.14,99.81 43.42,99.81 43.49,99.88 43.65,99.88 43.68,99.86 43.7,99.86
  TOP w0.102: 43.7,99.86 45.65,99.86 45.74,99.77 45.74,99.45 v1(45.59,99.3)
  IN4 w0.117: v1(231.76,80.05) 231.59,80.22 231.42,80.22 231.22,80.02 231.22,79.66 228.41,76.85 228.41,74.44 225,71.02 223.86,71.02 222.36,69.52 219.89,69.52 219.44,69.07 209.71,69.07 202.29,76.49 202.29,78.15 195.72,84.72 189.31,84.72 185.99,88.05 185.99,90.41 175.42,100.98 162.77,100.98 160.74,103 149.27,103 147.73,101.46 139.81,101.46 138.24,103.03 124.8,103.03 124.24,102.47 118.58,102.47 117.85,103.21 111.36,103.21 110.6,103.98 85.76,103.98 84.97,104.76 77.66,104.76 77.38,105.04 76.26,105.04 75.88,104.66 67.22,104.66 65.82,103.26 52.21,103.26 50.5,101.56 50.5,100.77 48.29,98.56 46.04,98.56 45.78,98.82 45.78,99.11 v1(45.59,99.3)
  BOTTOM w0.102: v1(231.76,80.05) 231.94,80.22 232.17,80.22 232.43,80.49 232.43,81.33 232.18,81.58 232.18,81.82 C457.2
USB3TP2_C: length 2.2
  BOTTOM w0.102: C457.1 232.09,83.35 232.09,83.51 231.75,83.84 231.75,84.29 231.85,84.38 U638.20
USB3TP2_RP: length 60.3
  TOP w0.102: v1(261.55,124.22) 261.55,124.19 261.26,123.9 261.08,123.9 260.79,123.61 260.7,123.61 260.69,123.62 260.17,123.62 260.12,123.67 260.12,124.1 260.23,124.22 260.43,124.22 260.58,124.36 L44.3
  IN3 w0.127: v1(232.05,91.87) 232.02,91.87 231.73,91.58 231.73,91.37 231.96,91.15 232.37,91.15 232.6,91.37 233.1,91.37 233.91,92.18 233.91,92.88 235.68,94.65 247.89,94.65 252.81,99.57 252.81,109.7 254.56,111.45 254.56,116.93 256.99,119.36 256.99,123.15 257.74,123.91 258.7,123.91 258.81,124.01 259.24,124.01 259.35,123.91 259.73,123.91 259.83,124.01 260.26,124.01 260.37,123.91 261.27,123.91 261.55,124.19 v1(261.55,124.22)
  BOTTOM w0.102: v1(232.05,91.87) 231.85,91.67 231.85,91.34 C493.1
USB3TP2_RP_C: length 2.4
  BOTTOM w0.102: C493.2 231.9,89.79 231.9,88.88 231.75,88.74 231.75,88.56 231.85,88.47 U638.8
USB3TP3: length 102.2
  TOP w0.102: UH1.BC32 42.45,102.65 42.92,102.65 43.13,102.45 43.54,102.45 43.83,102.74 46.43,102.74 v1(47.14,103.45)
  IN3 w0.127: v1(97.04,128.26) 96.88,128.1 96.88,127.72 96.61,127.45 95.36,127.45 89.94,132.87 89.94,136.45 84.14,142.25 70.72,142.25 67.81,139.34 67.81,136.59 68.59,135.81 68.59,131.81 64.18,127.4 64.18,126.1 64.01,125.94 64.01,112.92 65.06,111.87 65.06,106.39 64.12,105.45 50.4,105.45 49.26,104.3 47.16,104.3 46.93,104.07 46.93,103.66 v1(47.14,103.45)
  BOTTOM w0.102: v1(97.04,128.26) 96.83,128.05 96.83,127.8 96.56,127.52 96.56,127.34 96.7,127.19 JDOCK1.92
USB3TP5: length 60.3
  TOP w0.102: UH1.BC26 42.82,100.32 43.13,100.62 45.61,100.62 v1(46.33,101.34) ; JIO1.53 8.68,95.4 8.87,95.59 9.13,95.59 9.34,95.81 9.34,96.09 9.46,96.2 9.61,96.2 v1(9.81,96)
  IN3 w0.127: v1(9.81,96) 9.64,96.18 9,96.18 7.98,95.16 7.98,93.33 10.12,91.2 10.98,91.2 12.66,92.87 14.79,92.87 15.03,93.1 22.94,93.1 23.02,93.02 23.73,93.02 25.71,95.01 29.78,95.01 29.98,95.21 34.71,95.21 36.42,96.92 42.23,96.92 44.18,98.87 48.42,98.87 48.71,99.15 48.71,99.42 48.51,99.62 48.36,99.62 48.06,99.91 48.06,100.07 47.79,100.34 47.64,100.34 47.34,100.63 47.34,100.78 47.23,100.9 46.19,100.9 46.06,101.03 46.06,101.21 46.19,101.34 v1(46.33,101.34)
USB3TP6: length 48.1
  TOP w0.076: v1(44.35,101.34) 44.45,101.45 44.52,101.45 44.64,101.33 44.64,101.07 44.53,100.97 43.63,100.97 43.57,101.03 43.57,101.26 43.52,101.31 43.32,101.31 43.26,101.25 UH1.BE28
  TOP w0.102: JIO1.65 8.73,91.8 8.92,91.99 9.8,91.99 9.84,91.96 10.35,91.96 v1(10.58,91.73)
  IN3 w0.127: v1(44.35,101.34) 44.48,101.2 44.48,100.9 41.54,97.96 37.52,97.96 37.48,98 33.56,98 32.93,97.37 32.93,97.22 32.62,96.91 26.61,96.91 26.45,97.06 24.47,97.06 23.94,97.6 22.92,97.6 21.78,98.74 16.59,98.74 16.26,98.41 14.1,98.41 10.55,94.87 10.55,94.02 10.17,93.64 10.05,93.64 9.64,93.23 9.64,92.41 10.16,91.89 10.42,91.89 v1(10.58,91.73)
USB_MCARD1_DET#: length 201.2
  TOP w0.102: UH1.A10 24.44,93.81 24.29,93.66 23.62,93.66 v1(23.4,93.44)
  IN2 w0.127: v1(23.4,93.44) 23.39,93.44 23.04,93.09 20.74,93.09 19.59,94.24 19.59,95.02 19.26,95.35 19.26,96.61 18.83,97.04 18.83,100.88 17.33,102.37 17.33,106.58 17.47,106.72 17.47,108.93 20.18,111.64 20.18,113.98 20.77,114.57 20.77,114.86 22.67,116.76 23.06,116.76 25.57,119.28 25.57,123.38 26.6,124.41 26.6,128.08 29.32,130.8 35.94,130.8 41.64,136.5 41.64,138.11 42.58,139.05 43.34,139.05 44.82,140.52 46.62,140.52 48.24,142.14 48.24,145.23 50.54,147.53 50.54,150.66 51.37,151.48 53.27,151.48 58.1,156.31 65.71,156.31 69.14,159.73 70.44,159.73 74.25,163.55 74.25,164.92 74.7,165.36 78.16,165.36 78.88,164.64 81.43,164.64 82.15,163.92 86.83,163.92 87.94,162.8 93.72,162.8 96.37,165.45 98.56,165.45 99.54,166.43 100.41,166.43 100.8,166.81 100.8,167.3 101.41,167.9 102.76,167.9 103.39,168.54 105.9,168.54 106.28,168.92 106.76,168.92 106.92,168.77 107.68,168.77 108.03,169.12 113.02,169.12 116,166.14 117.5,166.14 117.93,166.57 121.41,166.57 128.04,159.94 131.01,159.94 133.87,157.08 145.2,157.08 v1(146.74,155.53)
  BOTTOM w0.102: v1(23.4,93.44) 23.87,93.44 v2(23.99,93.33) ; JMINI4.40 145.55,157.34 147.35,155.53 R824.1 147.05,155.23 v1(146.74,155.53)
USB_OC0#: length 375.1
  TOP w0.102: UH1.P3 30.36,90.61 30.36,90.14 30.59,89.91 30.59,89.65 30.41,89.47 30.41,89.06 v1(30.77,88.71) ; v1(258.42,101.84) 257.63,101.05 v1(254.49,101.05)
  IN2 w0.127: v1(30.13,80.81) 30.15,80.82 30.15,81.38 30.59,81.82 33.9,81.82 35.35,80.38 46.41,80.38 47.6,81.57 52.18,81.57 53.79,83.18 67.1,83.18 69.06,85.14 79.5,85.14 84.63,90.27 84.63,92.24 86.13,93.74 87.63,93.74 89.8,95.91 113.46,95.91 114.09,95.27 114.89,95.27 115.49,95.87 117.27,95.87 118.49,94.65 130.89,94.65 132.99,96.75 132.99,98.8 135.42,101.23 136.89,101.23 140.04,98.08 154.42,98.08 155.1,97.39 161.08,97.39 164.51,93.97 179.34,93.97 179.97,93.33 194.39,93.33 198.74,88.99 198.74,82.96 202.98,78.71 202.98,74.63 207.86,69.75 216.17,69.75 218.04,71.61 218.4,71.61 218.83,72.04 218.83,72.12 219.47,72.76 221.11,72.76 221.21,72.65 223.91,72.65 226.48,75.22 235.26,75.22 239.96,79.92 245.55,79.92 247,81.37 247,86.37 248.57,87.95 248.57,90.03 256.57,98.03 256.57,98.37 255.98,98.97 255.32,98.97 254.96,99.32 254.96,100.58 v1(254.49,101.05)
  IN3 w0.127: v1(30.77,88.71) 30.77,88.1 29.37,86.7 26.39,86.7 25.52,85.84 21.97,85.84 20.95,86.85 19.2,86.85 18.59,87.46 13.69,87.46 11.94,89.22 9.4,89.22 6.46,92.16 6.46,95.81 8.21,97.56 8.21,110.59 9.2,111.57 9.2,112.88 9.79,113.47 10.87,113.47 12.32,114.92 13.6,114.92 14.34,115.66 15.28,115.66 16.34,116.72 16.34,117.31 18.04,119.01 18.83,119.01 19.77,119.95 24.37,119.95 26.15,121.73 28.53,121.73 29.78,120.48 v1(29.8,120.48)
  BOTTOM w0.102: v1(254.49,101.05) 255.28,101.84 U45.6 ; v1(29.8,120.48) 30.21,120.89 v2(30.21,121.64) 30.21,122.34 RH3.1 ; v1(30.77,88.71) 30.77,88.01 29.98,87.23 29.98,85.3 RH246.2 30.26,84.57 30.26,80.94 v1(30.13,80.81) ; v1(258.42,101.84) U45.10
USB_OC1#: length 120.6
  TOP w0.102: v1(4.48,88.73) 4.86,88.73 5.99,89.86 5.99,89.99 6.6,90.6 JIO1.69 ; UH1.V1 31.91,88.29 30.36,86.74 29.71,86.74 28.48,85.51 RH247.2 28.02,84.62 28.02,81.68 27.36,81.02 v1(27.36,80.81)
  IN3 w0.127: v1(27.36,80.81) 26.94,80.38 23.48,80.38 22.96,80.91 22.96,81.33 22.46,81.82 15.97,81.82 15.16,81.01 13.12,81.01 8.44,85.68 5.93,85.68 5.01,86.6 5.01,88.2 v1(4.48,88.73)
  IN4 w0.109: v1(18.68,126.32) 17.9,125.55 17.9,122.54 13.33,117.97 13.33,116.59 9.69,112.95 9.69,111.06 8.26,109.63 8.26,90.75 9.79,89.22 11.92,89.22 14.23,86.9 14.86,86.9 17.41,84.35 17.97,84.35 19.67,82.65 23.99,82.65 24.21,82.43 25.87,82.43 26.58,81.72 27.14,81.72 27.36,81.49 v1(27.36,80.81)
  BOTTOM w0.102: v1(18.68,126.32) 19.08,126.73 v2(19.22,126.73) 26.73,126.73 27.62,125.84 28.94,125.84 29.75,125.03 RH4.1
USB_OC2#: length 70.7
  TOP w0.102: RPH7.1 27.33,85.52 27.82,86.02 v1(27.87,86.02) 27.9,86.02 29.38,87.49 30.46,87.49 31.4,88.43 31.4,90.16 UH1.U2
  IN4 w0.109: v1(27.87,86.02) 27.44,85.58 26.14,85.58 25.72,86 25.11,86 24.85,86.26 21.95,86.26 19.85,88.37 19.85,89.39 19.34,89.9 19.34,91.66 16.58,94.42 16.58,96.06 16.4,96.24 15.38,96.24 15.22,96.09 15.22,95.26 14.93,94.97 14.5,94.97 13.32,96.14 13.32,100.77 12.59,101.49 12.59,107.74 13.15,108.29 13.15,110.68 14.11,111.64 14.11,113.9 14.93,114.72 14.93,115.11 16.82,117 16.82,118.4 v1(17.43,119.01)
  BOTTOM w0.102: RH6.1 28.86,121.19 v2(27.82,120.15) 27.59,119.92 26.12,119.92 24.72,118.53 22.51,118.53 21.85,117.87 18.35,117.87 17.43,118.78 v1(17.43,119.01)
USB_OC3#: length 74.7
  TOP w0.102: v1(30.18,88.71) 30.18,89.68 UH1.P1
  IN3 w0.127: v1(30.18,88.71) 30.13,88.71 28.38,86.95 26.28,86.95 25.42,86.09 22.07,86.09 21.06,87.11 19.3,87.11 18.69,87.72 13.8,87.72 12.04,89.47 9.51,89.47 6.71,92.26 6.71,95.7 8.47,97.45 8.47,110.48 9.81,111.82 10.75,111.82 11.24,112.3 11.24,113.48 12.42,114.67 13.71,114.67 14.16,115.12 15.44,115.12 20.02,119.7 24.47,119.7 25.46,120.69 v1(26.28,120.69)
  BOTTOM w0.102: RH7.1 27.97,122.79 RH248.2 26.58,123.18 v2(26.58,121.79) 26.73,121.64 26.73,121.09 26.32,120.69 v1(26.28,120.69)
USB_OC4#: length 256.9
  TOP w0.102: v1(69.6,165.98) U48.6 ; v1(24.9,80.81) 25.13,81.03 v1(25.13,81.37) 25.13,81.37 25.13,84.62 RH249.2 24.81,85.08 26.84,87.11 27.71,87.11 29.04,88.44 29.04,89.39 29.17,89.52 29.17,89.92 29.47,90.23 UH1.M3 ; v1(6.59,90) JIO1.71 ; U48.10 v1(66.47,165.98)
  IN1 w0.109: v1(66.47,165.98) v1(69.6,165.98)
  IN2 w0.127: v1(66.47,165.98) 65.46,165.98 62.7,163.22 62.7,161.47 62.15,160.92 60.41,160.92 59.54,160.06 54.51,160.06 51.69,157.24 48.4,157.24 46.47,155.3 43.49,155.3 40.6,152.41 40.6,148.85 38.5,146.75 24.63,146.75 20.38,150.99 15.71,150.99 13.12,153.58 10.02,153.58 7.55,151.12 7.55,145.02 8.32,144.25 8.68,144.25 12.1,140.83 12.1,135.67 9.1,132.67 9.1,125.69 12.89,121.91 12.89,117.31 10.32,114.74 8.83,114.74 7.28,113.2 7.28,91.86 6.59,91.17 v1(6.59,90)
  IN4 w0.109: v1(24.9,80.81) 24.75,80.66 21.25,80.66 20.2,81.7 19.28,81.7 17.88,83.11 13.48,83.11 6.59,90 v1(6.59,90) ; v1(25.13,81.37) 25.13,81.37 24.54,81.95 24.01,81.95 23.79,82.17 19.48,82.17 18.07,83.58 13.71,83.58 7.78,89.51 7.78,109.82 9.22,111.26 9.22,113.15 12.86,116.78 12.86,118.17 15.91,121.22 15.91,124.75 17.91,126.75 19.42,126.75 v1(19.85,126.32)
  BOTTOM w0.102: v1(19.85,126.32) 19.9,126.38 24.7,126.38 26.07,125 RH8.1 ; v1(69.6,165.98) v2(69.6,166.6)
USB_OC5#: length 61.9
  TOP w0.102: UH1.T1 31.12,89.76 31.12,89.52 31.17,89.47 31.17,88.53 30.37,87.72 29.28,87.72 27.99,86.43 27.69,86.43 27.28,86.02 v1(27.24,86.02) 26.83,85.6 RPH7.2
  IN4 w0.109: v1(18.22,118.58) 17.62,117.98 17.62,117.13 15.41,114.91 15.41,114.53 14.58,113.7 14.58,111.45 13.62,110.49 13.62,108.09 13.07,107.54 13.07,101.69 13.8,100.96 13.8,98.82 15.53,97.09 16.39,97.09 17.05,96.43 17.05,95.21 18.2,94.07 18.75,94.07 19.81,93.01 19.81,90.1 20.34,89.57 20.34,88.54 20.84,88.05 23.73,88.05 24.04,87.73 24.04,86.95 24.26,86.73 25.04,86.73 25.31,86.47 26.78,86.47 v1(27.24,86.02)
  BOTTOM w0.102: RH9.1 25.18,120.58 v2(24.11,119.51) 23.35,118.76 22.41,118.76 21.75,118.1 18.7,118.1 v1(18.22,118.58)
USB_OC6#: length 58.5
  TOP w0.102: UH1.N2 29.78,90.16 29.78,89.57 29.5,89.29 29.5,88.26 27.9,86.66 27.29,86.66 v1(26.65,86.02) 26.65,85.96 26.33,85.64 RPH7.3
  IN4 w0.109: v1(18.83,119.79) 18.83,119.77 17.28,118.22 17.28,117.12 15.17,115.01 15.17,114.63 14.34,113.8 14.34,111.55 13.38,110.58 13.38,108.19 12.83,107.64 12.83,101.59 13.56,100.86 13.56,98.72 15.43,96.85 16.29,96.85 16.82,96.33 16.82,94.51 19.57,91.75 19.57,90 20.08,89.49 20.08,88.46 22.05,86.5 24.95,86.5 25.21,86.24 25.82,86.24 26.04,86.02 v1(26.65,86.02)
  BOTTOM w0.102: RH17.1 24.29,122.41 22.42,120.55 v2(21.18,120.55) 19.58,120.55 v1(18.83,119.79)
USB_PWR_SHR_EN#: length 77.6
  TOP w0.102: v1(216.92,78) 216.91,78 216.37,77.46 216.37,76.34 216.01,75.98 216.01,74.56 218.79,71.78 220.26,71.78 v1(220.91,71.13)
  IN2 w0.127: v1(260.59,102.98) 260.59,100.45 259.47,99.34 258.24,99.34 248.83,89.92 248.83,87.84 247.28,86.29 247.28,80.99 245.96,79.67 240.14,79.67 234.88,74.41 227.52,74.41 224.9,71.79 221.57,71.79 v1(220.91,71.13)
  BOTTOM w0.102: R1626.1 257.74,104.44 259.13,104.44 v1(260.59,102.98) 260.59,101.78 v4(260.4,101.59) ; U46.B10 217.42,77.5 v1(216.92,78) ; v1(220.91,71.13) 220.89,71.11 220.89,70.37 221.63,69.63 RP2.7
USB_PWR_SHR_VBUS_EN: length 70.2
  IN1 w0.109: v1(220.96,84.62) 221.37,85.02 221.37,85.1 221.62,85.35 222.48,85.35 223.29,84.54 224.42,84.54 224.67,84.29 225.33,84.29 v1(225.76,84.72)
  IN2 w0.127: v1(252.76,96.68) 246.62,90.54 246.62,82.31 246.24,81.93 229.7,81.93 225.4,86.22 222.49,86.22 221.4,85.13 221.4,85 221.01,84.62 v1(220.96,84.62)
  BOTTOM w0.102: RP1.7 225.4,83.73 225.66,83.98 225.66,84.62 v1(225.76,84.72) ; U46.B50 221.42,85.07 v1(220.96,84.62) ; Q55.2 255.07,94.38 v1(252.76,96.68) 252.05,97.39 v2(252.05,98.16) 252.05,100.01 253.09,101.05 253.09,104.77 254.76,106.44 254.76,107.38 255.16,107.78 U2.1
USB_SIDE_EN#: length 295
  TOP w0.102: v1(256.07,98.14) v2(256.64,98.14) ; v1(9.25,90.33) 9.25,89.98 8.68,89.4 JIO1.73
  IN2 w0.127: v1(196.58,92.54) 195.54,93.58 180.08,93.58 179.44,94.22 164.61,94.22 161.13,97.7 155.16,97.7 154.52,98.33 140.27,98.33 137.12,101.48 135.26,101.48 132.57,98.79 132.57,96.69 130.79,94.91 118.6,94.91 117.34,96.16 114.04,96.16 113.79,96.42 89.59,96.42 87.48,94.31 83.54,94.31 81.44,92.21 76.44,92.21 72.68,88.45 71.52,88.45 66.76,83.69 53.58,83.69 51.96,82.08 47.39,82.08 46.2,80.88 35.56,80.88 34.11,82.33 29.63,82.33 28.99,81.7 28.99,80.63 28.73,80.38 25.23,80.38 24.6,79.74 16.98,79.74 16.34,79.11 13.77,79.11 8.26,84.61 8.26,89.34 v1(9.25,90.33) ; v1(214.17,87.47) 214.84,86.8 218.24,86.8 220.35,88.91 224.47,88.91 229.22,84.16 229.22,83.96 230.69,82.48 245.45,82.48 246.36,83.4 246.36,91.07 253.44,98.14 v1(256.07,98.14)
  BOTTOM w0.102: U46.A33 v1(214.17,87.47) 213.39,88.25 R768.2 210.5,88.86 207.05,92.31 196.81,92.31 v1(196.58,92.54) ; v1(256.07,98.14) 256.33,98.41 U45.4
USBP0+: length 296.3
  TOP w0.089: v1(26.35,103.74) 26.35,103.96 26.08,104.23 26.08,104.39 26.25,104.56 26.25,104.7 26.16,104.79 UH1.D37
  IN4 w0.089: 43.96,100.93 43.95,100.93 43.93,100.91 43.54,100.91 43.02,101.44 37.82,101.44 37.56,101.18 30.02,101.18 29.73,101.47 26.55,101.47 26.32,101.7 26.32,101.98 26.45,102.11 26.45,102.65 25.92,103.19 25.92,103.55 26.11,103.74 v1(26.35,103.74)
  IN4 w0.117: v1(254.51,103.99) 254.26,103.74 253.97,103.74 253.58,103.35 253.58,102.62 255.12,101.08 255.12,99.77 259.67,95.23 259.67,83.4 254.36,78.09 246.53,78.09 246.09,77.64 236.22,77.64 232.04,81.82 228.7,81.82 228.01,81.14 228.01,79.07 223.3,74.36 222.31,74.36 221.03,73.07 219.46,73.07 217.19,70.8 210.95,70.8 208.5,73.25 208.5,73.76 204.32,77.93 204.32,81.36 192.59,93.1 187.13,93.1 181.78,98.44 181.25,98.44 176.6,103.09 164.66,103.09 162.83,104.92 115.75,104.92 114.98,105.69 86.61,105.69 85.81,106.48 80.85,106.48 80.37,106.96 70.36,106.96 70.06,107.27 67.25,107.27 64.99,105.01 54.64,105.01 54.15,105.5 52.02,105.5 48.15,101.64 48.15,101.3 47.78,100.93 43.96,100.93
  BOTTOM w0.102: U2.6 256.16,105.6 255.68,105.12 254.84,105.12 254.81,105.09 v3(254.25,104.53) 254.05,104.32 254.05,103.78 254.14,103.69 254.21,103.69 v1(254.51,103.99)
USBP0-: length 296.7
  TOP w0.089: v1(25.8,103.97) 25.88,104.05 25.88,104.46 25.53,104.81 UH1.B37
  IN4 w0.089: v1(25.8,103.97) 25.8,103.73 25.71,103.64 25.71,103.1 26.24,102.57 26.24,102.19 26.11,102.07 26.11,101.61 26.47,101.26 29.64,101.26 29.93,100.97 37.65,100.97 37.91,101.23 42.93,101.23 43.46,100.7 43.83,100.7 43.85,100.72 43.92,100.72 43.95,100.69 43.96,100.69
  IN4 w0.117: 43.96,100.69 47.88,100.69 48.39,101.2 48.39,101.54 52.12,105.27 54.05,105.27 54.54,104.77 65.09,104.77 67.35,107.03 69.96,107.03 70.27,106.73 80.27,106.73 80.75,106.25 85.72,106.25 86.51,105.45 114.88,105.45 115.65,104.68 162.73,104.68 164.56,102.86 176.5,102.86 181.15,98.21 181.68,98.21 187.03,92.86 192.49,92.86 204.08,81.27 204.08,77.84 208.26,73.66 208.26,73.15 210.85,70.56 217.29,70.56 219.56,72.84 221.12,72.84 222.41,74.12 223.4,74.12 228.25,78.97 228.25,81.04 228.8,81.59 231.94,81.59 236.12,77.4 246.19,77.4 246.63,77.85 254.45,77.85 259.9,83.3 259.9,95.33 255.36,99.87 255.36,101.18 253.82,102.72 253.82,103.25 254.07,103.5 254.42,103.5 v1(254.51,103.41)
  BOTTOM w0.102: v1(254.51,103.41) 254.44,103.48 254.05,103.48 253.83,103.69 253.83,104.43 254.29,104.89 254.31,104.89 254.75,105.33 255.59,105.33 255.66,105.41 U2.7
USBP0_D+: length 3.4
  BOTTOM w0.102: U2.3 256.16,108.6 255.93,108.84 255.93,109.43 256.34,109.84 256.59,109.84 256.69,109.74 256.69,109.41 256.77,109.33 L39.2
USBP0_D-: length 3.3
  BOTTOM w0.102: L39.3 256.83,110.18 256.71,110.06 256.23,110.06 v3(256,109.83) 255.71,109.54 255.71,108.67 255.66,108.62 U2.2
USBP0_R_D+: length 24.2
  BOTTOM w0.102: JUSB1.3 264.4,113.32 264.59,113.13 265.54,113.13 265.91,113.5 265.91,117.38 265.11,118.18 264.5,118.18 264.49,118.17 263.95,118.17 263.94,118.18 262.23,118.18 261.95,117.9 261.95,113.42 261.02,112.49 260.54,112.49 260.41,112.37 D15.3 260.13,111.66 259.99,111.8 259.99,112.44 259.9,112.53 259.72,112.53 259.43,112.24 259.43,111.29 260.28,110.44 v3(260.28,110.06) 260.28,109.85 260.07,109.64 259.63,109.64 259.32,109.33 L39.1
USBP0_R_D-: length 24.1
  BOTTOM w0.102: JUSB1.2 265.06,112.91 265.63,112.91 266.13,113.41 266.13,117.47 265.2,118.4 v3(264.22,118.4) 262.14,118.4 261.73,117.99 261.73,113.51 260.93,112.71 260.6,112.71 260.41,112.9 D15.2 260.14,113.59 259.93,113.37 259.93,112.88 259.8,112.75 259.63,112.75 259.22,112.33 259.22,111.2 260.05,110.36 260.05,109.93 259.98,109.85 259.69,109.85 259.36,110.18 L39.4
USBP1+: length 349
  TOP w0.102: L41.3 261.38,121.82 261.22,121.66 261.22,121.5 v1(260.82,121.09) ; UH1.C38 25.43,105.29 24.97,105.29 24.77,105.5 24.71,105.5 24.35,105.85 23.63,105.85 23.16,106.32 v1(23.16,106.86)
  IN4 w0.117: v1(23.16,106.86) 23.01,106.86 22.9,106.96 22.9,107.13 22.95,107.18 22.95,107.53 23.05,107.63 23.05,108.03 22.95,108.13 22.95,108.48 23.05,108.58 23.05,108.98 22.95,109.08 22.95,109.43 22.36,110.02 21.96,110.02 21.58,110.4 21.58,112.47 22.16,113.04 22.16,114.29 22.79,114.92 22.79,115.81 26.97,119.98 26.97,121.5 28.79,123.33 28.79,125.44 29.82,126.46 29.82,131.87 33.73,135.78 33.73,137.91 38.16,142.34 39.87,142.34 41.9,144.38 42.67,144.38 45.48,147.18 47.54,147.18 50.88,150.53 50.88,151.74 52.35,153.2 55.3,153.2 58.05,155.94 68.69,155.94 70.78,158.03 72.43,158.03 76.16,161.76 77.81,161.76 78.75,162.7 94.4,162.7 96.6,164.91 98.74,164.91 99.5,165.67 108.56,165.67 108.88,165.36 111.99,165.36 112.25,165.61 114.59,165.61 114.85,165.36 127.25,165.36 130.29,162.32 134.15,162.32 135.9,160.56 135.9,159.39 142.27,153.02 144.61,153.02 145.4,153.81 150.74,153.81 151.29,153.26 151.29,150.91 152.88,149.32 152.88,146.19 153.14,145.94 153.14,143.02 154.36,141.79 163.96,141.79 165.09,140.67 166.59,140.67 169.81,137.45 171,137.45 175.36,133.09 175.36,121.25 180.66,115.95 180.66,108.05 187.87,100.85 195.64,100.85 202.63,93.86 209.62,93.86 210.83,92.64 215.14,92.64 215.78,92.01 226.65,92.01 227.39,92.75 233.67,92.75 234.8,93.88 237.19,93.88 241.31,98 248.59,98 252.7,102.1 252.7,103.75 256.84,107.9 256.84,109.38 258.69,111.23 258.69,119.4 259.83,120.53 259.83,120.97 260.13,121.27 260.64,121.27 v1(260.82,121.09)
USBP1-: length 349.2
  TOP w0.102: UH1.A38 24.63,105.27 24.26,105.64 23.54,105.64 22.94,106.23 22.94,106.49 22.84,106.59 22.49,106.59 22.41,106.67 22.41,106.77 v1(22.5,106.86) ; L41.2 261.48,122.67 261.21,122.4 261.21,121.96 260.95,121.7 v1(260.82,121.7)
  IN4 w0.117: v1(22.5,106.86) 22.67,107.02 22.67,107.23 22.71,107.27 22.71,109.33 22.26,109.78 21.86,109.78 21.34,110.3 21.34,112.57 21.92,113.14 21.92,114.38 22.56,115.02 22.56,115.91 26.73,120.08 26.73,121.6 28.56,123.43 28.56,125.54 29.58,126.56 29.58,131.97 33.49,135.88 33.49,138.01 38.06,142.58 39.77,142.58 41.8,144.61 42.57,144.61 45.38,147.42 47.44,147.42 50.65,150.63 50.65,151.84 52.25,153.43 55.21,153.43 57.95,156.18 68.59,156.18 70.68,158.27 72.34,158.27 76.06,161.99 77.71,161.99 78.65,162.93 94.3,162.93 96.51,165.14 98.64,165.14 99.4,165.91 108.66,165.91 108.97,165.59 111.9,165.59 112.15,165.85 114.69,165.85 114.94,165.59 127.35,165.59 130.39,162.55 134.24,162.55 136.13,160.66 136.13,159.49 142.37,153.26 144.51,153.26 145.3,154.04 150.84,154.04 151.53,153.36 151.53,151.01 153.12,149.42 153.12,146.29 153.37,146.04 153.37,143.12 154.46,142.03 164.06,142.03 165.18,140.9 166.69,140.9 169.91,137.69 171.1,137.69 175.6,133.19 175.6,121.35 180.9,116.05 180.9,108.15 187.97,101.08 195.74,101.08 202.73,94.09 209.72,94.09 210.93,92.88 215.24,92.88 215.88,92.25 226.55,92.25 227.29,92.98 233.57,92.98 234.7,94.12 237.09,94.12 241.21,98.23 248.5,98.23 252.46,102.19 252.46,103.85 256.61,107.99 256.61,109.48 258.45,111.33 258.45,119.5 259.59,120.63 259.59,121.06 260.03,121.51 260.62,121.51 v1(260.82,121.7)
USBP1_D+: length 21.4
  TOP w0.102: JUSB2.3 264.4,135.75 264.68,135.46 265.18,135.46 269.3,131.34 269.3,126.05 269.31,126.03 269.31,125.41 v3(268.5,124.6) 267.93,124.03 267.48,124.03 D17.2 266.63,123.89 266.51,124.01 266.17,124.01 265.08,122.92 265.08,122.72 264.51,122.15 264.13,122.15 263.81,121.82 L41.4
USBP1_D-: length 21.4
  TOP w0.102: L41.1 263.83,122.67 264.14,122.36 264.42,122.36 264.87,122.81 264.87,123.01 266.08,124.22 266.53,124.22 266.63,124.32 D17.3 267.5,124.24 267.84,124.24 268.09,124.49 268.09,124.51 268.53,124.95 268.54,124.95 269.08,125.49 v3(269.08,125.77) 269.08,131.25 265.09,135.25 264.61,135.25 264.4,135.04 JUSB2.2
USBP2+: length 15.9
  TOP w0.102: UH1.C36 25.41,104.5 24.95,104.5 24.76,104.68 24.61,104.68 23.99,105.31 23.36,105.31 23.14,105.53 20.04,105.53 19.65,105.92 19.12,105.92 18.46,105.26 18.11,104.9 18.09,104.9 17.7,104.51 17.7,104.49 16.84,103.63 v3(16.58,103.63) 16.33,103.63 15.07,104.89 15.07,106.06 14.82,106.31 14.18,106.31 14.07,106.2 JIO1.18
USBP2-: length 15.9
  TOP w0.102: UH1.A36 24.54,104.47 24.52,104.47 23.9,105.09 23.27,105.09 23.05,105.32 19.95,105.32 19.56,105.7 19.21,105.7 18.61,105.1 v3(18.06,104.54) 16.91,103.4 16.25,103.4 14.85,104.8 14.85,105.97 14.73,106.09 14.27,106.09 14.17,105.99 14.17,105.83 14.37,105.63 14.37,105.48 14.26,105.37 14.11,105.37 13.89,105.6 JIO1.20
USBP3+: length 103.2
  TOP w0.102: UH1.C34 25.07,103.57 24.77,103.87 24.36,103.87 23.91,104.32 22.5,104.32 22.35,104.16 21.69,104.16 v1(21.19,104.66)
  IN4 w0.117: v1(21.19,104.66) 21.09,104.66 21,104.75 21,105.05 21.19,105.24 21.52,105.24 21.62,105.14 22.02,105.14 22.12,105.24 22.47,105.24 22.58,105.14 22.98,105.14 23.08,105.24 23.51,105.24 23.92,105.65 23.92,108.45 27.57,112.1 36.39,112.1 37.38,113.1 37.38,113.98 36.47,114.89 36.47,115.51 39.18,118.23 39.18,118.9 38.62,119.46 38.62,121.24 38.47,121.39 38.47,126.91 38.79,127.23 38.79,128.25 40.77,130.23 43.13,130.23 44.06,131.16 61.27,131.16 62.15,130.29 78.33,130.29 78.68,130.64 89.6,130.64 91.09,129.14 91.7,129.14 91.8,129.05 v1(91.8,128.97)
  BOTTOM w0.102: JDOCK1.72 91.7,127.21 91.78,127.29 91.91,127.29 91.98,127.37 91.98,128.08 92.25,128.34 92.25,129.03 92.13,129.14 91.86,129.14 91.8,129.09 v1(91.8,128.97)
USBP3-: length 103.3
  TOP w0.102: v1(20.58,104.66) 20.58,104.35 20.68,104.25 21.29,104.25 21.6,103.95 22.44,103.95 22.59,104.1 23.82,104.1 24.27,103.66 24.53,103.66 24.62,103.57 UH1.A34
  IN4 w0.117: v1(20.58,104.66) 20.76,104.83 20.76,105.15 21.09,105.48 23.41,105.48 23.68,105.75 23.68,108.54 27.47,112.34 36.29,112.34 37.14,113.19 37.14,113.88 36.23,114.79 36.23,115.61 38.95,118.33 38.95,118.81 38.39,119.37 38.39,121.14 38.24,121.3 38.24,127.01 38.55,127.32 38.55,128.35 40.67,130.47 43.03,130.47 43.97,131.4 61.37,131.4 62.24,130.52 78.24,130.52 78.58,130.87 89.7,130.87 91.19,129.38 91.63,129.38 v1(91.8,129.55)
  BOTTOM w0.102: JDOCK1.74 92.2,127.99 92.46,128.26 92.46,129.12 92.22,129.36 91.99,129.36 v1(91.8,129.55)
USBP4+: length 188.8
  TOP w0.102: UH1.D33 25.51,103.16 25.22,102.87 24.95,102.87 24.76,103.06 24.27,103.06 23.69,103.63 23.14,103.63 22.73,103.22 20.97,103.22 20.64,102.9 v1(20.64,102.79)
  IN4 w0.117: v1(20.64,102.79) 20.46,102.98 20.46,103.32 20.05,103.73 20.05,106.03 20.23,106.22 20.23,107 20.48,107.25 20.48,109.41 20.1,109.79 20.1,113.88 20.68,114.46 20.68,114.89 21.32,115.53 21.32,116.42 25.13,120.23 25.13,121.75 26.55,123.18 26.55,126.64 29.08,129.17 29.08,132.18 31.94,135.04 31.94,137.26 37.84,143.17 39.61,143.17 42.07,145.63 42.86,145.63 44.94,147.71 44.94,151.01 47.74,153.81 49.36,153.81 50.18,154.62 50.18,154.96 51.27,156.04 55.56,156.04 56.93,157.41 61.78,157.41 64.7,160.34 69.58,160.34 73,163.76 77.57,163.76 78.06,164.25 94.76,164.25 98.81,168.3 105.49,168.3 106.85,169.66 116.29,169.66 116.79,169.16 121.23,169.16 122.37,170.3 133.07,170.3 137.85,165.51 137.85,162.94 140.06,160.73 140.06,156.92 142.51,154.47 143.3,154.47 143.73,154.9 143.73,155.86 143.33,156.26 142.77,156.26 v1(142.58,156.45)
  BOTTOM w0.102: v1(142.58,156.45) 142.78,156.25 143.02,156.25 143.3,156.54 JMINI4.38
USBP4-: length 188.8
  TOP w0.102: v1(19.98,102.79) 19.9,102.88 19.9,103.11 20,103.21 20.65,103.21 20.88,103.44 22.64,103.44 23.05,103.85 23.78,103.85 24.37,103.26 24.86,103.26 24.94,103.18 UH1.B33
  IN4 w0.117: v1(142.58,155.84) 142.58,155.97 142.64,156.03 143.23,156.03 143.49,155.76 143.49,155 143.2,154.71 142.6,154.71 141.77,155.54 141.77,155.7 141.5,155.97 141.34,155.97 141.1,156.22 141.1,156.37 140.82,156.64 140.67,156.64 140.3,157.01 140.3,160.83 138.09,163.04 138.09,165.61 133.17,170.53 122.27,170.53 121.13,169.4 116.88,169.4 116.39,169.89 106.76,169.89 105.4,168.53 98.72,168.53 94.67,164.48 77.96,164.48 77.47,163.99 72.9,163.99 69.48,160.57 64.6,160.57 61.68,157.65 56.83,157.65 55.46,156.28 51.17,156.28 49.95,155.06 49.95,154.72 49.27,154.04 47.64,154.04 44.71,151.11 44.71,147.81 42.76,145.87 41.97,145.87 39.51,143.4 37.74,143.4 31.7,137.36 31.7,135.14 28.85,132.28 28.85,129.27 26.32,126.74 26.32,123.27 24.89,121.85 24.89,120.33 21.08,116.52 21.08,115.63 20.45,114.99 20.45,114.56 19.86,113.98 19.86,109.69 20.24,109.31 20.24,107.35 20,107.1 20,106.31 19.81,106.13 19.81,103.63 20.22,103.22 20.22,102.88 20.14,102.79 v1(19.98,102.79)
  BOTTOM w0.102: JMINI4.36 143.3,155.74 143.01,156.04 142.77,156.04 v1(142.58,155.84)
USBP5+: length 270.2
  TOP w0.102: UH1.G31 27.16,102.58 v1(27.48,102.9)
  IN3 w0.127: v1(249.85,81.06) 250.01,80.89 250.65,80.89 255.02,76.52 255.02,71.24 254.64,70.86 254.2,70.86 v1(254.03,70.7)
  IN4 w0.089: 30.49,101.8 30.22,101.8 29.49,102.53 27.85,102.53 v1(27.48,102.9)
  IN4 w0.117: v1(249.85,81.06) 249.67,80.88 248.27,80.88 246.38,78.99 242.95,78.99 242.58,79.36 240.24,79.36 239.87,78.99 236.67,78.99 232.94,82.72 227.14,82.72 225.31,80.88 225.31,77.66 222.89,75.25 222.16,75.25 220.89,73.98 218.74,73.98 216.3,71.54 212.55,71.54 211.44,72.65 211.44,73.17 210.76,73.85 209.49,73.85 205.52,77.81 205.52,81.52 193.15,93.89 187.42,93.89 181.95,99.36 181.38,99.36 176.91,103.83 165.13,103.83 163.28,105.68 116.92,105.68 115.28,107.33 83.25,107.33 82.87,107.71 70.85,107.71 70.55,108.01 66.49,108.01 64.26,105.78 54.92,105.78 53.32,107.38 52.36,107.38 50.4,105.42 50.4,104.99 47.54,102.13 43.24,102.13 43.16,102.2 41.68,102.2 41.42,102.47 37.26,102.47 36.59,101.8 30.49,101.8
  BOTTOM w0.102: v1(254.03,70.7) 253.84,70.89 253.61,70.89 253.33,70.6 JMINI2.38
USBP5-: length 270.1
  TOP w0.102: v1(26.83,102.9) 26.56,102.64 UH1.F31
  IN3 w0.127: v1(254.03,71.28) 254.2,71.11 254.54,71.11 254.78,71.35 254.78,76.41 250.55,80.64 250.01,80.64 v1(249.85,80.47)
  IN4 w0.089: 30.49,101.56 30.47,101.56 30.44,101.58 30.16,101.58 29.41,102.33 27.77,102.33 27.58,102.53 27.2,102.53 v1(26.83,102.9)
  IN4 w0.117: 30.49,101.56 36.69,101.56 37.36,102.23 41.32,102.23 41.59,101.97 43.06,101.97 43.14,101.89 47.64,101.89 50.64,104.89 50.64,105.33 52.46,107.15 53.22,107.15 54.83,105.54 64.36,105.54 66.59,107.77 70.46,107.77 70.76,107.47 82.77,107.47 83.15,107.09 115.18,107.09 116.82,105.45 163.18,105.45 165.03,103.59 176.81,103.59 181.28,99.13 181.85,99.13 187.32,93.65 193.05,93.65 205.28,81.42 205.28,77.72 209.39,73.61 210.66,73.61 211.2,73.07 211.2,72.56 212.45,71.31 216.4,71.31 218.84,73.75 220.99,73.75 222.26,75.01 222.99,75.01 225.54,77.56 225.54,80.79 227.24,82.48 232.85,82.48 236.58,78.76 239.97,78.76 240.34,79.12 242.48,79.12 242.85,78.76 246.47,78.76 248.37,80.65 249.67,80.65 v1(249.85,80.47)
  BOTTOM w0.102: v1(254.03,71.28) 253.86,71.11 253.63,71.11 253.33,71.4 JMINI2.36
USBP6+: length 79
  TOP w0.102: v1(28.68,102.9) 28.95,102.62 UH1.L31
  IN4 w0.089: 29.52,103.28 29.5,103.28 29.48,103.31 28.36,103.31 28.32,103.27 28.32,103.19 28.45,103.07 28.45,102.97 28.56,102.86 28.63,102.86 v1(28.68,102.9)
  IN4 w0.117: 29.52,103.28 29.9,103.28 30.24,103.62 30.24,104.04 30.34,104.14 30.34,104.54 30.24,104.63 30.24,104.98 30.34,105.08 30.34,105.48 30.24,105.57 30.24,105.83 31.99,107.58 40.47,107.58 42.96,110.07 45.21,110.07 46.05,110.91 46.47,110.91 47.99,112.42 49.75,112.42 51.34,114.01 52.39,114.01 65.19,126.8 65.19,127.42 67.3,129.53 87.79,129.53 88.89,128.43 90.23,128.43 90.41,128.25 90.41,128 90.28,127.87 v1(90.07,127.87)
  BOTTOM w0.102: v1(90.07,127.87) 90.33,127.61 90.33,127.34 90.2,127.21 JDOCK1.66
USBP6-: length 79.1
  TOP w0.102: v1(28.08,102.9) 28.36,102.62 UH1.K31
  IN4 w0.089: v1(28.08,102.9) 28.13,102.96 28.13,103.35 28.29,103.5 29.48,103.5 29.5,103.52 29.52,103.52
  IN4 w0.117: 29.52,103.52 29.81,103.52 30.01,103.72 30.01,105.93 31.9,107.82 40.37,107.82 42.86,110.31 45.11,110.31 45.95,111.15 46.38,111.15 47.89,112.66 49.65,112.66 51.24,114.25 52.29,114.25 64.95,126.9 64.95,127.52 67.2,129.77 87.88,129.77 88.99,128.66 90.33,128.66 90.64,128.35 90.64,128.03 v1(90.8,127.87)
  BOTTOM w0.102: v1(90.8,127.87) 90.55,127.62 90.55,127.36 90.7,127.2 JDOCK1.68
USBP7+: length 121.6
  TOP w0.102: JUSH1.3 50.05,7.49 49.91,7.64 49.91,12.89 48.73,14.08 48.73,16.98 v1(48.93,17.18) ; UH1.H29 27.76,101.49 v1(27.4,101.85)
  IN1 w0.089: 26.12,101.22 26.15,101.22 26.17,101.24 26.97,101.24 27.17,101.44 27.17,101.62 v1(27.4,101.85)
  IN1 w0.117: v1(48.93,17.18) 48.73,17.38 48.73,21.08 45.71,24.1 45.71,25.99 45.09,26.61 45.09,28.26 46.07,29.23 46.07,32.69 39.16,39.6 39.16,47.74 41.93,50.51 41.93,54.57 39.61,56.89 39.61,66.22 37.55,68.27 37.55,76.87 38.14,77.46 38.14,80.58 38.32,80.76 38.32,82.51 37.46,83.37 37.46,83.78 37.01,84.22 36.1,84.22 35.31,85.01 26.5,85.01 25.74,85.76 23.07,85.76 22.02,86.82 22.02,87.83 22.36,88.17 22.61,88.17 23.43,88.99 23.43,90.13 24.39,91.1 24.39,98.21 25.47,99.29 25.47,100.94 25.75,101.22 26.12,101.22
USBP7-: length 121.7
  TOP w0.102: UH1.G29 27.16,101.44 v1(26.75,101.85) ; v1(48.29,17.18) 48.51,16.97 48.51,13.99 49.69,12.8 49.69,7.65 49.55,7.51 JUSH1.2
  IN1 w0.089: 26.07,101.46 26.08,101.46 26.09,101.45 26.15,101.45 26.17,101.43 26.89,101.43 26.98,101.52 26.98,101.62 v1(26.75,101.85)
  IN1 w0.117: v1(48.29,17.18) 48.5,17.38 48.5,20.98 45.47,24 45.47,25.89 44.86,26.51 44.86,28.35 45.84,29.33 45.84,32.59 38.92,39.5 38.92,47.84 41.69,50.61 41.69,54.47 39.37,56.79 39.37,66.12 37.32,68.17 37.32,76.97 37.91,77.56 37.91,80.68 38.08,80.86 38.08,82.41 37.22,83.27 37.22,83.68 36.91,83.98 36,83.98 35.21,84.77 26.4,84.77 25.64,85.52 22.97,85.52 21.78,86.72 21.78,87.93 22.26,88.41 22.52,88.41 23.19,89.08 23.19,90.23 24.16,91.19 24.16,98.31 25.24,99.38 25.24,101.04 25.66,101.46 26.07,101.46
USBP8+: length 101.2
  TOP w0.102: UH1.C32 25.44,102.66 24.97,102.66 24.77,102.45 23.92,102.45 23.87,102.4 23.48,102.4 v1(23.08,102.79) ; v1(29.16,164.37) 28.86,164.37 28.79,164.45 28.79,164.88 29.08,165.17 29.31,165.17 29.42,165.06 29.42,164.96 29.65,164.73 L51.1
  IN4 w0.117: v1(23.08,102.79) 23.11,102.79 23.3,102.61 23.3,102.45 23.11,102.26 22.76,102.26 22.65,102.37 22.25,102.37 22.13,102.26 21.78,102.26 21.67,102.37 21.27,102.37 21.15,102.26 19.71,102.26 18.96,103.01 18.96,105.98 19.5,106.52 19.5,107.31 19.69,107.5 19.69,109.15 19.36,109.48 19.36,114.18 19.95,114.77 19.95,115.2 20.56,115.82 20.56,116.71 24.39,120.53 24.39,122.11 25.69,123.4 25.69,126.82 28.35,129.48 28.35,132.49 28.78,132.92 28.78,133.84 29.73,134.78 29.73,136.29 30.4,136.96 30.56,136.96 37.5,143.9 39.25,143.9 43.82,148.47 43.82,151.01 45.2,152.39 45.2,154.73 44.16,155.76 44.16,157.57 44.89,158.3 44.89,161.23 41.41,164.7 34.68,164.7 33.38,163.41 29.12,163.41 28.74,163.79 28.74,164.45 28.81,164.53 29,164.53 v1(29.16,164.37)
USBP8-: length 101.1
  TOP w0.102: L51.4 29.56,165.58 29.37,165.39 28.99,165.39 28.57,164.97 28.57,164.64 v1(28.3,164.37) ; v1(23.67,102.79) 23.67,102.79 23.22,103.24 23.22,103.34 23.33,103.44 23.61,103.44 24.14,102.91 24.14,102.73 24.2,102.66 24.54,102.66 UH1.A32
  IN4 w0.117: v1(28.3,164.37) 28.5,164.18 28.5,163.69 29.02,163.17 33.48,163.17 34.78,164.47 41.32,164.47 44.65,161.13 44.65,158.4 43.93,157.67 43.93,155.66 44.96,154.63 44.96,152.48 43.59,151.11 43.59,148.57 39.15,144.14 37.41,144.14 30.46,137.2 30.3,137.2 29.49,136.39 29.49,134.88 28.54,133.93 28.54,133.02 28.11,132.58 28.11,129.57 25.45,126.92 25.45,123.5 24.16,122.21 24.16,120.63 20.33,116.8 20.33,115.91 19.71,115.3 19.71,114.87 19.13,114.28 19.13,109.39 19.46,109.06 19.46,107.6 19.26,107.41 19.26,106.62 18.72,106.08 18.72,102.91 19.61,102.02 23.2,102.02 23.53,102.35 23.53,102.66 v1(23.67,102.79)
USBP8_D+: length 17.7
  TOP w0.102: L51.2 31.99,164.73 32.29,165.03 32.81,165.03 D73.3 33.66,164.93 33.77,165.03 34.39,165.03 37.54,168.17 37.54,170.76 38.07,171.29 42.07,171.29 42.37,170.99 42.37,170.62 42.27,170.52 JESA1.3
USBP8_D-: length 17.7
  TOP w0.102: JESA1.2 42.69,170.52 42.59,170.62 42.59,171.08 42.16,171.51 37.98,171.51 37.32,170.85 37.32,168.26 34.3,165.24 33.77,165.24 33.66,165.35 D73.2 32.81,165.24 32.29,165.24 31.95,165.58 L51.3
USBP9+: length 14.8
  TOP w0.102: v1(14.56,103.81) 14.37,104 14.16,104 13.96,103.8 JIO1.26 ; v1(21.89,102.79) 22.51,102.17 24.39,102.17 24.46,102.25 24.77,102.25 24.97,102.04 25.43,102.04 UH1.C30
  IN3 w0.127: v1(21.89,102.79) 21.73,102.64 21.73,102.31 21.4,101.97 18.83,101.97 18.53,102.27 16.14,102.27 15.03,103.39 15.03,103.84 14.89,103.98 14.73,103.98 v1(14.56,103.81)
USBP9-: length 14.7
  TOP w0.102: JIO1.24 13.98,104.4 14.17,104.21 14.37,104.21 v1(14.56,104.4) ; v1(21.23,102.79) 21.14,102.71 21.14,102.5 21.27,102.37 22,102.37 22.42,101.96 24.62,101.96 UH1.A30
  IN3 w0.127: v1(21.23,102.79) 21.36,102.79 21.49,102.66 21.49,102.41 21.29,102.22 20.95,102.22 20.85,102.32 20.42,102.32 20.32,102.22 19.94,102.22 19.83,102.32 19.4,102.32 19.3,102.22 18.93,102.22 18.63,102.52 16.24,102.52 15.27,103.49 15.27,103.95 14.99,104.23 14.61,104.23 14.56,104.28 v1(14.56,104.4)
USBP10+: length 13.6
  TOP w0.102: UH1.D29 25.49,101.53 25.21,101.25 24.96,101.25 24.77,101.43 v3(21.46,101.43) 20.4,101.43 19.76,102.08 19.48,102.08 19.26,102.3 18.37,102.3 18.36,102.28 17.76,102.28 17.75,102.3 15.76,102.3 15.46,102 JIO1.32
USBP10-: length 13.5
  TOP w0.102: JIO1.30 13.85,102.6 13.95,102.7 13.95,102.78 14.03,102.85 14.19,102.85 14.28,102.75 14.28,102.3 14.36,102.22 15.37,102.22 15.67,102.51 v3(18.08,102.51) 19.35,102.51 19.57,102.3 19.85,102.3 20.49,101.65 21.18,101.65 21.19,101.66 21.72,101.66 21.74,101.65 22.7,101.65 22.79,101.74 23.15,101.74 23.23,101.65 23.54,101.65 23.63,101.74 23.98,101.74 24.07,101.65 24.39,101.65 24.4,101.64 24.77,101.64 24.88,101.74 25,101.74 25.08,101.66 UH1.B29
USBP12+: length 102.3
  TOP w0.102: L10.4 60.83,148.03 60.91,148.11 60.91,148.49 60.99,148.58 61.95,148.58 62.9,149.53 72.5,149.53 75.21,146.82 75.21,135.46 70.34,130.59 67.91,130.59 66.28,128.95 64.46,128.95 v1(64.27,129.14) ; v1(26.73,100.87) 26.56,100.7 UH1.F26
  IN4 w0.089: 28.66,106.99 28.66,106.98 28.64,106.97 28.64,106.76 28.84,106.56 28.84,104.63 28.44,104.22 26.45,104.22 26.23,104.44 25.61,104.44 25.24,104.06 25.24,100.9 25.72,100.42 26.89,100.42 27.11,100.64 27.11,101.03 27.06,101.08 26.82,101.08 26.73,100.99 v1(26.73,100.87)
  IN4 w0.117: 28.66,106.99 28.66,107.33 29.34,108.01 31.07,108.01 31.71,108.65 36.13,108.65 38.31,110.83 44.92,110.83 45.78,111.69 46.2,111.69 49.26,114.75 52.09,114.75 64.37,127.03 64.37,127.67 64.94,128.23 64.94,128.69 64.69,128.94 64.47,128.94 v1(64.27,129.14)
USBP12-: length 102.3
  TOP w0.102: UH1.G26 27.16,100.53 v1(27.5,100.87) ; L10.1 60.8,148.88 60.89,148.79 61.86,148.79 62.81,149.74 72.59,149.74 75.42,146.91 75.42,135.37 70.43,130.38 68,130.38 66.37,128.74 64.45,128.74 v1(64.27,128.56)
  IN4 w0.089: 28.42,106.99 28.42,106.97 28.43,106.97 28.43,106.68 28.63,106.47 28.63,104.71 28.35,104.43 26.54,104.43 26.32,104.65 25.52,104.65 25.03,104.15 25.03,100.81 25.63,100.21 26.98,100.21 27.32,100.55 27.32,100.79 27.4,100.87 v1(27.5,100.87)
  IN4 w0.117: v1(64.27,128.56) 64.42,128.7 64.57,128.7 64.7,128.57 64.7,128.33 64.14,127.77 64.14,127.13 51.99,114.98 49.16,114.98 46.1,111.92 45.68,111.92 44.82,111.07 38.21,111.07 36.03,108.88 31.61,108.88 30.97,108.25 29.25,108.25 28.42,107.42 28.42,106.99
USBP12_D+: length 11.1
  TOP w0.102: L10.3 58.1,148.03 57.78,148.35 57.74,148.35 57.41,148.35 57.18,148.57 57.18,148.9 56.6,149.49 55.44,149.49 54.54,148.58 54.06,148.58 53.96,148.48 D21.3 53.26,147.72 53.08,147.9 53.08,148.36 52.92,148.52 52.61,148.52 52.17,148.08 51.57,148.08 51.56,148.09 51.24,148.09 51.1,147.95 JEDP1.16
USBP12_D-: length 11.1
  TOP w0.102: L10.2 58.07,148.88 57.76,148.56 57.5,148.56 57.4,148.66 57.4,148.99 56.69,149.71 55.36,149.71 54.45,148.8 54.06,148.8 53.96,148.9 D21.2 53.35,149.65 53.09,149.4 53.09,148.92 52.92,148.74 52.52,148.74 52.09,148.31 v3(51.84,148.31) 51.24,148.31 51.1,148.45 JEDP1.15
USBP13+: length 1.1
  TOP w0.102: UH1.G24 27.16,99.5 v1(27.47,99.81)
  BOTTOM w0.089: T167.1 27.67,100.01 v1(27.47,99.81)
USBP13-: length 1.3
  TOP w0.102: v1(26.88,99.81) 26.56,99.49 UH1.F24
  BOTTOM w0.089: v1(26.88,99.81) 26.63,99.55 T166.1
USBRBIAS: length 2
  TOP w0.305: UH1.K24 28.7,99.75 28.7,99.77 v1(28.66,99.81) 28.7,99.85 28.7,100.02 28.36,100.37 UH1.K26
  BOTTOM w0.381: RH187.1 28.66,99.12 v1(28.66,99.81)
USH_DET#: length 144.1
  TOP w0.102: JUSH1.20 v1(58.55,5.67) ; v1(26.78,94.34) 26.78,94.34 26.56,94.55 UH1.F13
  IN1 w0.109: v1(14.28,97.41) 13.47,96.59 13.47,91.95 13.12,91.6 13.12,88.09 15.11,86.09 15.97,86.09 21.41,80.66 24.14,80.66 24.63,80.16 28.97,80.16 29.47,79.67 32.77,79.67 34.44,77.99 34.44,67.16 36.6,65 36.6,55.65 38.95,53.3 38.95,51.75 35.43,48.23 35.43,34.2 38.95,30.68 38.95,27.68 42.12,24.52 42.12,18.49 43.67,16.94 43.67,10.29 49.57,4.39 57.26,4.39 v1(58.55,5.67)
  BOTTOM w0.102: v1(26.78,94.34) 26.68,94.34 26.42,94.6 25.08,94.6 24.7,94.22 20.37,94.22 19.38,95.21 v2(18.91,95.21) 17.86,95.21 16.87,96.2 15.88,96.2 14.68,97.41 v1(14.28,97.41) 14.21,97.33 RPH9.8
USH_PWR_ON: length 346.5
  TOP w0.102: v1(52.93,17.27) 53.27,17.27 T140.1
  IN1 w0.109: v1(208.92,73.42) 209.66,73.42 210.26,74.01 215.92,74.01 216.49,73.44 221.4,73.44 222.91,71.94 225.63,71.94 226.62,72.94 226.9,72.94 227.75,73.79 230.92,73.79 231.57,73.14 233.37,73.14 234.02,73.79 244.74,73.79 245.67,74.72 251.23,74.72 255.19,78.67 260.6,78.67 269.9,69.37 269.9,47.23 264.67,42 254.01,42 250.38,38.36 236.67,38.36 221.84,23.53 201.53,23.53 200.92,24.14 196.13,24.14 194.71,22.73 132.85,22.73 132.25,23.32 107.85,23.32 104.78,26.4 89.55,26.4 89.21,26.74 84.35,26.74 75.61,18 75.61,14.83 72.84,12.06 60.45,12.06 55.24,17.27 v1(52.93,17.27)
  BOTTOM w0.102: U46.A18 212.08,78.02 211.91,77.86 208.77,77.86 207.86,78.78 206.36,78.78 205.65,78.06 205.65,75.45 206.64,74.46 206.64,73.75 206.97,73.42 v1(208.92,73.42)
USH_PWR_STATE#: length 337.3
  TOP w0.102: JUSH1.16 v1(56.55,7.71)
  IN1 w0.109: v1(214.13,88.1) 214.66,88.63 219.62,88.63 220.63,87.62 220.63,87.39 221.75,86.27 225.21,86.27 227.54,83.93 227.54,83.39 233.08,77.85 238.07,77.85 239.83,79.61 242.68,79.61 243.2,79.09 250.72,79.09 252.99,81.37 261.6,81.37 272.73,70.24 272.73,46.35 262.8,36.43 258.67,36.43 258.54,36.55 257.59,36.55 257.38,36.34 252.03,36.34 250.83,35.14 237.17,35.14 222.94,20.91 200.64,20.91 199.86,20.13 131.68,20.13 131.1,20.71 106.74,20.71 103.4,24.06 84.44,24.06 84.07,23.69 84.07,23.28 79.83,19.04 79.83,17.13 77.83,15.13 77.83,14.68 74.35,11.21 74.35,9.39 72.67,7.71 v1(56.55,7.71)
  BOTTOM w0.102: v1(56.55,7.71) 56.83,7.71 v2(57.15,7.39) ; v1(214.13,88.1) 214.13,88.07 214.28,88.22 R102.2 214.59,88.56 214.59,87.18 214.67,87.1 U46.A34
USH_SMBCLK: length 277.9
  TOP w0.102: v1(51.01,5.62) 51.19,5.8 51.19,5.93 51.05,6.07 JUSH1.5
  IN1 w0.109: v1(51.01,5.62) 51.19,5.8 51.19,6.16 50.79,6.55 49.3,6.55 44.98,10.86 44.98,17.57 43.33,19.22 43.33,25.02 40.19,28.16 40.19,31.17 36.78,34.58 36.78,47.86 40.17,51.25 40.17,53.81 37.85,56.13 37.85,65.5 35.76,67.58 35.76,78.44 35.19,79.01 35.19,80.1 33.03,82.26 26.57,82.26 26.2,82.63 24.96,82.63 24.78,82.81 22.59,82.81 21.82,83.58 21.82,83.63 21.37,84.08 20.76,84.08 19.38,85.46 19.38,85.84 17.77,87.46 16.53,87.46 15.67,88.31 15.67,89.06 16.19,89.57 16.19,90.38 14.56,92.01 14.56,92.74 14.69,92.88 14.69,94.18 15.3,94.78 15.3,96.1 16.56,97.36 16.56,97.88 16.29,98.16 16.29,99.05 15.22,100.11 15.22,104.51 15.91,105.19 15.91,105.62 16.41,106.12 16.41,108.94 19.41,111.95 19.41,119.87 19.04,120.25 18.83,120.25 18.19,120.89 18.19,121.9 19.37,123.08 25.23,123.08 27.13,124.98 27.13,128.15 29.69,130.71 29.69,133.71 29.17,134.23 29.17,142.56 28.03,143.69 28.03,145.51 27.46,146.08 27.46,153.25 28.2,153.98 28.2,158.38 27.56,159.02 27.56,160.05 28.03,160.52 29.81,160.52 30.43,161.15 34.4,161.15 37.15,163.9 42.18,163.9 46.26,159.82 46.76,159.82 47.64,158.94 51.14,158.94 51.68,158.4 52.5,158.4 53.24,159.14 56.05,159.14 56.7,158.48 63.18,158.48 64.96,160.27 78.22,160.27 78.84,160.89 84.64,160.89 85.33,161.59 99.31,161.59 100.12,162.41 100.12,162.76 v1(100.66,163.29)
  BOTTOM w0.102: U51.A50 100.5,162.3 100.26,162.53 100.26,162.9 v1(100.66,163.29) ; v1(51.01,5.62) 51.19,5.45 51.19,4.91 R589.2
