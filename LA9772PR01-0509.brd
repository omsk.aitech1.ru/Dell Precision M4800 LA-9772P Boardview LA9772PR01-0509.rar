# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PWRBTN#_XDP: length 5.5
  TOP w0.102: JXDP2.41 22.3,124.49 v1(23.3,125.49)
  BOTTOM w0.102: RH28.2 22.01,124.19 v2(22.61,124.79) v1(23.3,125.49)
PCH_PWRGD#: length 81.1
  TOP w0.102: R410.1 162.87,134.15 162.14,133.41 159.62,133.41 157.87,135.16 157.87,135.5 156.68,136.7 152.01,136.7 151.8,136.48 v2(150.45,136.48) 149.64,136.48 v1(149.39,136.23) ; Q52.1 R893.2 95.59,149.97 v1(94.75,149.97)
  IN3 w0.127: v1(149.39,136.23) 144.99,136.23 135.96,145.26 133.56,145.26 131.73,143.43 121.43,143.43 119.92,144.94 113.96,144.94 113.69,144.68 108.87,144.68 108.59,144.96 103.84,144.96 103.45,144.56 102.13,144.56 101.25,145.44 100.35,145.44 98.37,147.42 97.86,147.42 96.47,148.82 95.91,148.82 v1(94.75,149.97)
PCH_RI#: length 7
  TOP w0.102: v1(30.18,88.12) 29.78,88.53 29.78,89.29 29.98,89.49 29.98,89.92 30.17,90.11 30.17,90.36 29.88,90.65 UH1.N4
  BOTTOM w0.102: v1(30.18,88.12) 30.18,87.97 v2(29.14,86.93) 28.86,86.65 RH84.2
PCH_RSMRST#: length 70.3
  TOP w0.102: v1(100.87,158.35) 100.47,157.95 100.08,157.95 99.75,158.28 99.53,158.28 98.54,159.27 v2(98.23,159.27) 96.78,159.27 95.97,160.08 R892.2 ; U7.1 143.69,140.68 143.54,140.84 143.13,140.84 142.92,140.64 v1(142.92,140.31)
  IN1 w0.109: v1(100.87,158.35) 100.87,158.33 101.1,158.1 101.93,158.1 103.17,159.34 103.17,161.92 103.07,162.02 103.07,163.52 103.45,163.9 105.64,163.9 106.2,163.34 111.01,163.34 112.07,162.28 114.96,162.28 116.5,160.74 116.5,156.96 120.28,153.18 126.78,153.18 128.12,151.84 128.12,150.52 130.63,148 136.03,148 142.92,141.11 v1(142.92,140.31)
  BOTTOM w0.102: v1(100.87,158.35) 100.87,158.28 100.54,157.95 99.96,157.95 99.38,158.52 U51.B47
PCH_RSMRST#_Q: length 285.3
  TOP w0.102: v1(140.49,134.87) 140.49,135.11 142.87,137.49 146.93,137.49 147.8,138.35 147.8,141.81 147.62,141.98 146.63,141.98 146.29,142.33 U7.4 ; UH1.J2 28.15,90.16 28.15,89.65 28.12,89.62 28.12,89.11 v1(27.72,88.71)
  IN1 w0.109: v1(140.49,134.87) 140.49,133.21 145.71,127.99 145.71,115.99 145.3,115.58 145.3,108.53 153.75,100.08 v1(154.28,100.08)
  IN2 w0.127: v1(116.63,101.31) 115.6,102.33 109.78,102.33 108.89,101.45 91.77,101.45 91.62,101.6 81.9,101.6 79.8,99.5 77.05,99.5 76.48,98.93 74.96,98.93 72.04,96.02 72.04,94.53 70.8,93.28 70.08,93.28 66.5,89.7 64.58,89.7 63.79,88.91 v1(63.76,88.91)
  IN3 w0.127: v1(63.76,88.91) 63.13,88.91 62.29,89.75 59.27,89.75 56.41,86.89 56.29,86.89 51.61,82.21 47.16,82.21 45.26,80.3 38.63,80.3 38.27,79.94 35.39,79.94 34.95,80.39 32.78,80.39 31.71,79.32 28.69,79.32 27.88,80.13 23.34,80.13 22.54,80.94 v1(22.54,81.14) ; v1(116.63,101.31) 117.88,102.55 120.66,102.55 121.45,103.34 121.45,103.72 122.15,104.43 129.29,104.43 131.42,106.56 144.32,106.56 148.72,102.17 152.19,102.17 v1(154.28,100.08)
  IN4 w0.109: v1(20.68,125.46) 21.12,125.89 21.12,126.48 20.61,126.99 17.81,126.99 15.67,124.85 15.67,121.32 12.6,118.25 12.6,117.11 8.98,113.49 8.98,111.36 7.54,109.91 7.54,89.42 13.61,83.34 17.97,83.34 19.38,81.94 21.74,81.94 v1(22.54,81.14)
  BOTTOM w0.102: v1(22.54,81.14) 22.54,81.24 22.77,81.47 RH142.2 23.29,82.52 23.29,83.78 RH79.2 24.17,84.66 24.17,85.91 v4(25.51,87.26) 26.08,87.83 26.84,87.83 v1(27.72,88.71) ; RH26.1 20.28,124.39 20.28,125.05 v1(20.68,125.46)
PCH_RTCRST#: length 197.2
  TOP w0.102: UH1.D9 25.5,93.41 25.21,93.12 24.95,93.12 24.76,93.3 24.49,93.3 24.34,93.15 24.04,93.15 23.68,92.8 22.97,92.8 22.61,93.15 20.4,93.15 CH7.2 19.36,93.08 17.31,93.08 RH44.2 16.85,91.34 16.43,90.92 15.7,90.92 v1(15.17,90.39) ; JAPS1.9 86.48,27.37 86.81,27.04 86.81,25.21 85.12,23.52 v1(84.59,23.52)
  IN1 w0.109: v1(15.17,90.39) 14.98,90.39 13.85,89.27 13.85,88.38 15.27,86.95 17,86.95 18.89,85.07 18.89,84.2 19.97,83.12 21.59,83.12 22.39,82.32 24.58,82.32 24.77,82.13 26.01,82.13 26.37,81.77 28.4,81.77 29.77,80.4 33.06,80.4 35.16,78.29 35.16,67.47 37.36,65.27 37.36,55.92 39.68,53.6 39.68,51.45 36.15,47.93 36.15,34.5 39.68,30.98 39.68,27.98 42.84,24.82 42.84,18.82 44.42,17.24 44.42,10.56 49.87,5.12 51.85,5.12 53.37,6.64 72.3,6.64 74.93,9.27 74.93,10.44 76.37,11.89 v1(76.72,11.89) 76.72,12.23 78.32,13.83 78.32,14.23 84.59,20.51 v1(84.59,23.52)
  BOTTOM w0.102: v1(76.72,11.89) 76.68,11.92 76.68,18.4 77.29,19.01 77.29,21.03 76.25,22.07 72.93,22.07 72.02,22.98 68.66,22.98 68.41,23.24 CMOS1.2 ; v1(84.59,23.52) v4(84.59,24.31)
PCH_RTCX1: length 7.1
  TOP w0.102: v1(25.64,91.43) 25.32,91.74 UH1.B5
  BOTTOM w0.102: v1(25.64,91.43) 24.96,91.43 v2(24.85,91.31) 23.76,90.22 RH39.1 CH4.2 22.86,91.08 22.4,90.63 21.74,90.63 21.51,90.85 21.51,91.63 YH1.1
PCH_RTCX2: length 8
  TOP w0.102: UH1.B4 25.33,91.1 v1(25.64,90.79)
  BOTTOM w0.102: YH1.2 21.5,89.88 21.74,90.12 22.46,90.12 RH39.2 23.07,89.1 CH5.2 23.33,88.68 23.45,88.68 v2(24.61,89.84) 25.56,90.79 v1(25.64,90.79)
PCH_SATA_MOD_EN#: length 141.1
  TOP w0.102: QH2.3 46.92,81.65 47.68,80.88 47.68,78.9 49.11,77.48 53.63,77.48 55.04,78.9 59.2,78.9 59.22,78.88 62.77,78.88 68.41,84.52 68.41,87.67 74.62,93.87 83.03,93.87 83.96,92.95 83.96,89.05 86.97,86.04 v1(89.62,86.04)
  IN1 w0.109: v1(89.62,86.04) 89.62,91.63 91.12,93.13 91.12,95.84 92.79,97.52 92.79,106.59 93.84,107.63 93.84,109.95 93.49,110.3 93.49,110.76 95.02,112.3 95.02,117.9 94.78,118.15 94.78,123.53 93.98,124.32 93.98,125.23 95.16,126.41 95.16,128.43 95.61,128.88 95.61,137.64 96.18,138.21 96.18,144.2 94.67,145.71 94.67,146.49 98.19,150.01 98.19,152.78 99.7,154.29 100.24,154.29 v1(100.67,153.86)
  BOTTOM w0.102: v1(89.62,86.04) v4(88.95,86.04) ; U51.B36 99.93,153.02 100.67,153.76 v1(100.67,153.86)
PCH_SATA_MOD_G_EN#: length 120.8
  TOP w0.102: RH229.1 44.5,86.18 v2(44.32,86.18) 42.62,86.18 39.54,89.26 39.54,90.16 UH1.AU2 ; RH229.1 45.51,85.32 47.43,85.32 47.89,84.86 QH2.1 ; RH229.1 45.44,85.18 46.12,84.49 46.12,83.87 46.22,83.77 46.22,83.39 v1(45.75,82.92) ; RH13.1 37.45,119.29 v1(37.91,119.75)
  IN3 w0.127: v1(45.75,82.92) 45.09,82.26 36.51,82.26 36.17,81.91 35.58,81.91 34.65,82.84 13.7,82.84 8.25,88.3 8.25,88.94 5.44,91.74 5.44,96.23 7.2,97.98 7.2,113.39 8.3,114.49 10.45,114.49 18.06,122.1 25.08,122.1 25.72,122.74 31.03,122.74 33.54,120.23 37.42,120.23 v1(37.91,119.75)
PCH_SMB_ALERT#: length 9.8
  TOP w0.102: v1(29.16,91.98) 29.39,91.98 UH1.N7
  BOTTOM w0.102: RH166.2 25.56,86.15 26.29,86.89 27.06,86.89 28.53,88.36 28.53,89.93 v2(28.83,90.23) 29.45,90.84 29.45,91.35 29.16,91.63 v1(29.16,91.98)
PCH_SPI_CLK: length 25.4
  TOP w0.102: JSPI1.8 v2(52.04,85.97) 51.73,85.97 RH181.2 50.78,85.33 v1(50.45,85.66) ; v1(36.79,93.8) 36.5,93.8 UH1.AJ11
  IN1 w0.109: v1(50.45,85.66) 50.45,85.68 50.58,85.81 50.82,85.81 50.95,85.94 50.95,86.55 50.82,86.68 50.01,86.68 49.43,87.25 48.24,87.25 45.43,90.05 44.74,90.05 43.74,91.06 43.74,91.69 41.51,93.91 38.52,93.91 38.13,94.3 38.13,94.57 37.8,94.91 37.47,94.91 37.22,94.65 37.22,94.23 v1(36.79,93.8)
PCH_SPI_CS0#: length 36.1
  TOP w0.102: v1(49.87,85.66) 49.97,85.76 49.97,86.64 v2(49.22,87.39) 48.87,87.74 48.87,87.91 48.99,88.04 49.38,88.04 49.79,88.45 50.02,88.45 50.08,88.4 50.08,88.18 49.72,87.82 49.72,87.67 49.84,87.54 50,87.54 50.12,87.41 50.12,86.93 50.25,86.8 50.45,86.8 50.58,86.93 50.58,87.41 50.71,87.54 50.96,87.54 51.09,87.41 RH182.2 51.26,86.94 51.52,86.94 51.65,87.06 51.65,87.26 51.77,87.39 51.98,87.39 52.1,87.26 52.1,87.06 52.23,86.94 52.46,86.94 52.59,87.06 52.59,87.26 52.71,87.39 52.94,87.39 53.07,87.26 53.07,87.06 53.18,86.95 53.47,86.95 53.63,87.11 53.88,87.11 54.01,86.97 JSPI1.10 ; UH1.AJ7 36.28,92.31 v1(36.69,91.9)
  IN1 w0.109: v1(49.87,85.66) 49.82,85.66 49.54,85.38 49.23,85.38 49.13,85.48 49.13,85.61 49.59,86.07 49.59,86.22 49.18,86.63 48.43,86.63 48.32,86.52 48.09,86.52 45.18,89.44 44.48,89.44 42.93,90.98 42.93,91.73 42.5,92.16 41.89,92.16 41.46,92.59 40.47,92.59 40.17,92.29 40.17,91.86 39.81,91.5 38.79,91.5 38.74,91.55 38.49,91.55 38.18,91.86 38.18,93.74 37.83,94.09 37.52,94.09 37.19,93.76 37.19,92.41 v1(36.69,91.9)
PCH_SPI_CS1#: length 27.4
  TOP w0.102: UH1.AL7 37.48,92.31 v1(37.67,92.5) ; v1(53.02,81.06) 53.17,80.91 RH177.2 52.99,80.43 52.61,80.81 52.61,81.56 54.02,82.97 JSPI1.2
  IN1 w0.109: v1(53.02,81.06) 53.02,82.4 50.4,85.02 48.88,85.02 47.2,86.7 47.2,86.7 46.51,87.39 46.51,87.59 45.03,89.07 43.31,89.07 42.02,90.36 38.79,90.36 37.65,91.5 37.5,91.5 37.25,91.76 37.25,92.08 v1(37.67,92.5)
PCH_SPI_DIN: length 27.8
  TOP w0.102: 35.98,90.69 35.98,90.68 35.89,90.59 35.89,90.13 35.67,89.91 35.67,89.63 35.77,89.52 35.77,89.11 v1(36.04,88.85) ; v1(49.72,83.37) 50.45,83.37 50.57,83.49 RH179.2 51.92,83.49 53.13,84.69 v2(53.26,84.69) 53.62,84.69 53.9,84.97 JSPI1.6
  IN1 w0.109: v1(36.04,88.85) 37.25,88.85 38.04,88.06 40.38,88.06 41.9,86.54 45.05,86.54 48.42,83.16 49.11,83.16 50.6,81.67 50.78,81.67 51.01,81.9 51.01,82.08 v1(49.72,83.37)
PCH_SPI_DO: length 24.5
  TOP w0.102: v1(36.13,88.26) 36.43,88.57 36.43,89.07 36.05,89.45 36.05,89.71 35.98,89.78 ; JSPI1.4 53.65,83.97 v2(52.85,83.17) 51.94,82.26 51.61,82.26 RH178.2 50.49,81.14 v1(50.45,81.14)
  IN1 w0.109: v1(50.45,81.14) 49.84,81.75 49.32,81.75 44.9,86.17 41.75,86.17 40.23,87.69 37.89,87.69 37.32,88.26 v1(36.13,88.26)
PCH_SPI_DO2: length 23.8
  TOP w0.102: v1(37.09,87.79) 36.93,87.96 36.93,89.18 36.48,89.63 36.48,89.91 36.48,89.91 36.48,89.92 36.67,90.11 36.67,90.36 36.38,90.65 UH1.AJ4 ; v1(49.26,88.5) 49.56,88.81 50.33,88.81 50.4,88.89 RH183.2 51.47,88.5 51.47,88.43 51.78,88.12 53.81,88.12 53.96,87.97 JSPI1.12
  IN3 w0.127: v1(49.26,88.5) 49.26,88.3 48.66,87.7 46.89,87.7 45.25,86.07 42.86,86.07 41.03,87.89 37.19,87.89 v1(37.09,87.79)
PCH_SPI_DO3: length 24.9
  TOP w0.102: v1(50.38,89.34) 50.38,89.95 RH184.2 v2(52.1,89.65) 52.78,88.97 JSPI1.14 ; v1(36.51,87.77) 36.74,88 36.74,89.04 36.28,89.49 36.28,90.16 UH1.AJ2
  IN3 w0.127: v1(36.51,87.77) 36.51,87.81 37.11,88.4 41.07,88.4 43.02,86.45 45.09,86.45 47.58,88.94 49.49,88.94 49.51,88.91 50,88.91 50.38,89.29 v1(50.38,89.34)
PCH_TD_IREF: length 9.8
  TOP w0.102: UH1.AY43 40.85,107.91 41.21,108.27 41.21,108.54 41.44,108.77 41.49,108.77 42.23,109.51 RH176.1 47.41,110.09 48.51,110.09 v2(48.99,110.58)
PCH_THRMTRIP#_R: length 9.8
  TOP w0.102: 40.04,89.78 40.13,89.78 40.45,89.47 40.45,88.68 42.61,86.51 45.54,86.51 v2(45.86,86.19) 46.9,86.19 CH17.1 RH206.2
PCH_TPM_EN: length 159.8
  TOP w0.102: UH1.BB4 41.74,91.37 v1(41.74,91.67)
  IN2 w0.127: v1(41.74,91.67) 41.74,91.69 45.16,95.11 49.87,95.11 52.94,98.18 53.22,98.18 54.39,99.35 54.39,101.36 55.17,102.14 60.36,102.14 61.68,100.82 64.72,100.82 71.49,107.59 80.06,107.59 81.15,108.68 81.92,108.68 82.22,108.38 116.29,108.38 117.25,109.33 119.04,109.33 119.76,108.61 126.4,108.61 126.92,109.13 129.34,109.13 130.04,108.43 156.9,108.43 157.88,109.41 162.7,109.41 164.09,110.81 v1(164.09,111.22)
  IN3 w0.127: v1(164.09,111.22) 163.99,111.22 161.76,113.46 161.76,117.57 159.7,119.63 v1(159.41,119.63)
  BOTTOM w0.102: v1(159.41,119.63) 159.52,119.75 R2189.1 ; v1(41.74,91.67) 40.5,91.67 39.92,91.09 39.92,89.74 39.68,89.49 39.68,89.11 39.88,88.91 41.26,88.91 42.07,88.1 45.37,88.1 RH209.1 45.84,86.82 v2(45.75,86.73) RH208.1
PCI_5048: length 5.1
  TOP w0.102: v1(26.3,107.43) 25.95,107.78 UH1.D44
  BOTTOM w0.102: v1(26.3,107.43) 25.89,107.02 25.5,107.02 25.43,107.08 25.4,107.08 25.15,107.33 v2(24.9,107.33) 24.37,107.33 22.72,108.98 RH158.1
PCI_DOCK: length 4.3
  TOP w0.102: UH1.B42 25.29,107.02 v1(25.74,106.56)
  BOTTOM w0.102: v1(25.74,106.56) 25.66,106.56 25.33,106.89 23.94,106.89 v2(23.61,107.22) RH162.1
PCI_LOOPBACKOUT: length 26.3
  TOP w0.102: RH164.1 20.07,108.94 19.95,108.81 19.95,107.38 19.21,106.64 19.21,106.54 19.31,106.44 19.82,106.44 19.97,106.28 20.13,106.28 20.25,106.41 20.25,106.97 20.51,107.22 20.51,108.01 20.63,108.14 20.74,108.14 20.86,108.27 20.86,109.31 20.74,109.43 18.96,109.43 18.83,109.56 18.83,109.79 18.96,109.92 21.22,109.92 21.34,109.79 v2(21.34,108.43) 21.34,107.88 21.47,107.76 22.08,107.76 22.21,107.88 22.21,109.56 22.34,109.69 22.56,109.69 22.69,109.56 22.69,109.38 22.82,109.26 23.61,109.26 23.73,109.13 23.73,108.9 23.61,108.77 22.82,108.77 22.69,108.65 22.69,108.42 22.82,108.29 23.61,108.29 23.73,108.16 23.73,107.94 23.61,107.81 22.82,107.81 22.69,107.68 22.69,107.45 22.82,107.33 23.68,107.33 23.81,107.2 23.81,106.36 24.01,106.16 24.5,106.16 UH1.A40
PCI_MEC: length 8.2
  TOP w0.102: v2(20.65,111.97) RH160.1 21.62,111.85 22.18,111.29 22.95,111.29 25.49,108.75 26.48,108.75 26.67,108.55 26.67,107.94 UH1.E44
PCI_PIRQA#: length 17.1
  TOP w0.102: UH1.H20 27.76,97.68 v1(27.4,97.32)
  BOTTOM w0.102: RPH1.3 14.98,100.62 15.84,101.48 18.52,101.48 18.88,101.12 18.88,100.68 20.29,99.27 21.57,99.27 22.67,98.17 24.49,98.17 24.65,98.02 24.71,98.02 v2(24.96,97.76) 25.62,97.76 26.01,98.16 26.57,98.16 v1(27.4,97.32)
PCI_PIRQB#: length 18
  TOP w0.102: v1(28.7,97.32) 28.95,97.57 UH1.L20
  BOTTOM w0.102: RPH1.2 14.65,101.12 14.76,101.23 v2(15.11,101.23) 15.16,101.23 15.64,101.71 18.61,101.71 19.11,101.22 19.11,100.78 20.38,99.5 21.67,99.5 22.77,98.4 24.56,98.4 24.61,98.35 26.65,98.35 27.27,97.72 28.3,97.72 v1(28.7,97.32)
PCI_PIRQC#: length 18.1
  TOP w0.102: UH1.K17 28.05,96.53 v1(28.05,96.24)
  BOTTOM w0.102: v1(28.05,96.24) 28.05,96.38 v2(27.73,96.7) 27.58,96.85 25.41,96.85 24.32,97.94 22.58,97.94 21.48,99.05 20.19,99.05 18.65,100.59 18.65,101.03 18.42,101.26 15.93,101.26 14.8,100.12 RPH1.4
PCI_PIRQD#: length 18.6
  TOP w0.102: v1(29.24,98.38) 29.55,98.08 UH1.M20
  BOTTOM w0.102: RPH1.1 15.18,101.62 15.49,101.94 18.71,101.94 19.34,101.31 19.34,100.87 20.23,99.99 v2(21.01,99.99) 21.51,99.99 22.27,99.22 23.35,99.22 23.95,98.63 24.8,98.63 24.89,98.54 26.73,98.54 27.29,97.98 28.36,97.98 28.76,98.38 v1(29.24,98.38)
PCI_TPM_TCM: length 8.6
  TOP w0.102: UH1.C40 25.1,106 24.75,106.36 24.49,106.36 24.29,106.56 24.29,107.68 24.21,107.76 24.21,109.34 23.36,110.2 21.9,110.2 21.7,110.4 v2(21.37,110.4) RH155.2
PCIE_PRX_EXPTX_N7: length 45.6
  TOP w0.102: v1(9.18,100.8) 9,100.62 8.87,100.62 8.69,100.8 JIO1.35 ; UH1.AT40 39.65,105.96 v1(39.65,105.96)
  IN3 w0.089: 39.46,107.13 39.46,107.12 39.43,107.08 39.43,106.89 39.2,106.67 39.2,105.85 39.27,105.78 39.47,105.78 v1(39.65,105.96)
  IN3 w0.127: 39.46,107.13 39.46,108.05 39.02,108.49 39.02,109.99 37.99,111.03 35.74,111.03 34.91,110.19 32.5,110.19 31.38,111.31 23.48,111.31 21.95,109.78 17.84,109.78 15.3,107.24 14.97,107.24 14.66,106.94 11.41,106.94 11.01,106.54 11.01,101.68 9.96,100.64 9.34,100.64 v1(9.18,100.8)
PCIE_PRX_EXPTX_P7: length 45.7
  TOP w0.102: UH1.AT39 39.14,105.82 v1(39.65,105.31) ; v1(9.18,100.21) 8.99,100.4 8.89,100.4 8.68,100.2 JIO1.37
  IN3 w0.089: v1(39.65,105.31) 39.65,105.43 39.48,105.6 39.2,105.6 39.02,105.78 39.02,106.74 39.25,106.97 39.25,107.07 39.22,107.11 39.22,107.13
  IN3 w0.127: v1(9.18,100.21) 9.36,100.39 10.07,100.39 11.26,101.58 11.26,106.44 11.51,106.69 14.77,106.69 15.07,107 15.4,107 17.94,109.54 22.05,109.54 23.58,111.06 31.27,111.06 32.4,109.94 35.01,109.94 35.85,110.78 37.89,110.78 38.77,109.89 38.77,108.39 39.22,107.95 39.22,107.13
PCIE_PRX_GLANTX_N2: length 111.8
  TOP w0.102: v1(39.19,102.86) 39.53,102.52 39.53,102.33
  IN4 w0.117: v1(39.19,102.86) 39.16,102.9 39.16,103.7 39.74,104.28 41.82,104.28 42.14,104.6 45.76,104.6 46.62,105.46 46.62,105.9 48.5,107.78 48.76,107.78 52.22,111.24 52.79,111.24 59.32,117.77 66.53,117.77 67.16,117.14 71.03,117.14 72.85,118.96 83.45,118.96 85.27,117.14 86.53,117.14 87.22,117.83 89.28,117.83 92.92,121.47 92.92,126.49 97.43,131 100.55,131 100.61,130.94 103.04,130.94 103.53,131.43 106.41,131.43 109.14,134.16 113.59,134.16 115.22,135.79 115.22,142.19 116.48,143.45 116.48,148.41 116.02,148.87 v1(115.33,148.87)
  BOTTOM w0.102: v1(115.33,148.87) 115.53,148.67 115.97,148.67 116.29,148.99 C459.2
PCIE_PRX_GLANTX_N2_C: length 2.9
  BOTTOM w0.102: C459.1 117.53,148.68 117.71,148.68 117.8,148.77 117.8,149.07 v3(118.12,149.39) 118.3,149.57 118.78,149.57 118.85,149.64 U31.39
PCIE_PRX_GLANTX_P2: length 111.7
  TOP w0.102: UH1.AR31 38.93,102.52 v1(38.59,102.86)
  IN4 w0.117: v1(38.59,102.86) 38.6,102.86 38.64,102.86 38.92,103.14 38.92,103.79 39.64,104.51 41.72,104.51 42.04,104.84 45.66,104.84 46.38,105.56 46.38,106 48.4,108.02 48.67,108.02 52.12,111.47 52.69,111.47 59.22,118 66.63,118 67.26,117.37 70.93,117.37 72.75,119.2 83.55,119.2 85.37,117.37 86.43,117.37 87.13,118.07 89.18,118.07 92.69,121.57 92.69,126.59 97.33,131.23 100.65,131.23 100.71,131.18 102.94,131.18 103.43,131.67 106.32,131.67 109.05,134.4 113.49,134.4 114.98,135.89 114.98,142.29 116.24,143.55 116.24,148.31 115.92,148.64 115.68,148.64 115.33,148.29 v1(115.33,148.29)
  BOTTOM w0.102: v1(115.33,148.29) 115.49,148.45 115.95,148.45 C458.2
PCIE_PRX_GLANTX_P2_C: length 2.9
  BOTTOM w0.102: C458.1 117.55,148.46 117.8,148.46 118.02,148.68 118.02,148.96 118.41,149.35 118.77,149.35 118.88,149.24 U31.38
PCIE_PRX_MMITX_N8: length 36
  TOP w0.102: v1(38.64,105.7) 38.58,105.7 UH1.AN38 ; v1(11.77,105.62) 11.59,105.8 8.87,105.8 8.67,105.6 JIO1.19
  IN3 w0.089: v1(38.64,105.7) 38.64,105.83 38.54,105.93 38.29,105.93 38.08,106.13 38.08,106.56 38.05,106.59 38.05,106.61
  IN3 w0.127: 38.05,106.61 38.05,106.9 36.31,108.65 32.57,108.65 30.92,110.3 24.12,110.3 22.59,108.77 18.68,108.77 16.14,106.23 15.38,106.23 14.93,105.78 11.93,105.78 v1(11.77,105.62)
PCIE_PRX_MMITX_P8: length 36
  TOP w0.102: JIO1.17 8.68,106.2 8.86,106.02 11.58,106.02 v1(11.77,106.21) ; UH1.AN39 38.24,105.88 v1(38.65,106.29)
  IN3 w0.089: v1(38.65,106.29) 38.47,106.11 38.36,106.11 38.26,106.21 38.26,106.57 38.3,106.6 38.3,106.61
  IN3 w0.127: v1(11.77,106.21) 11.95,106.03 14.82,106.03 15.28,106.48 16.03,106.48 18.57,109.02 22.49,109.02 24.02,110.55 31.02,110.55 32.68,108.9 36.41,108.9 38.3,107.01 38.3,106.61
PCIE_PRX_WLANTX_N3: length 136.9
  TOP w0.102: v1(40.82,103.81) 40.73,103.81 40.87,103.67 40.87,103.45 UH1.AW33
  IN4 w0.089: 42.42,103.21 42.41,103.21 42.38,103.24 41.22,103.24 41.02,103.44 41.02,103.62 40.82,103.81 v1(40.82,103.81)
  IN4 w0.117: v1(134.65,150.63) 134.48,150.8 134.26,150.8 134.13,150.67 134.13,149.15 137.35,145.93 137.35,140.44 137.93,139.86 137.93,135.72 132.44,130.24 128.79,130.24 124.82,126.27 124.82,123.33 116.37,114.87 90.36,114.87 89.16,113.67 84.32,113.67 84.01,113.98 82.86,113.98 82.27,113.38 78.24,113.38 77.45,114.18 73.97,114.18 72.92,113.13 71.32,113.13 69.65,114.79 66.33,114.79 65.57,115.56 60.23,115.56 56.17,111.49 56.17,109.76 54.49,108.09 52.24,108.09 49.77,105.61 49.77,105.09 47.3,102.63 43.65,102.63 43.07,103.21 42.42,103.21
  BOTTOM w0.102: JMINI4.23 135.29,150.54 135.01,150.82 134.84,150.82 v1(134.65,150.63)
PCIE_PRX_WLANTX_P3: length 136.7
  TOP w0.102: v1(41.49,103.81) 41.49,103.83 41.32,103.66 UH1.AY33
  IN4 w0.089: 42.42,103.44 42.41,103.44 42.38,103.41 41.3,103.41 41.19,103.52 41.19,103.76 41.28,103.85 41.46,103.85 v1(41.49,103.81)
  IN4 w0.117: 42.42,103.44 43.16,103.44 43.74,102.86 47.21,102.86 49.53,105.19 49.53,105.71 52.15,108.32 54.39,108.32 55.93,109.86 55.93,111.59 60.13,115.79 65.66,115.79 66.43,115.03 69.75,115.03 71.42,113.36 72.83,113.36 73.87,114.41 77.55,114.41 78.34,113.62 82.17,113.62 82.77,114.22 84.1,114.22 84.42,113.9 89.06,113.9 90.26,115.11 116.27,115.11 124.59,123.43 124.59,126.37 128.69,130.47 132.35,130.47 137.69,135.82 137.69,139.77 137.12,140.34 137.12,145.83 133.89,149.05 133.89,150.77 134.16,151.04 134.55,151.04 134.65,151.14 v1(134.65,151.24)
  BOTTOM w0.102: JMINI4.25 135.31,151.34 135.01,151.04 134.86,151.04 v1(134.65,151.24)
PCIE_PRX_WPANTX_N6: length 84
  TOP w0.102: v1(40.99,105.78) 41.32,105.45 UH1.AY38
  IN4 w0.117: v1(40.99,105.78) 40.79,105.57 40.79,105.38 40.9,105.27 41.41,105.27 41.72,105.57 45.34,105.57 45.64,105.87 45.64,106.3 47.83,108.48 47.83,109.51 49.18,110.86 50.35,110.86 51.73,112.24 52.41,112.24 66.49,126.31 66.49,126.97 67.32,127.81 72.14,127.81 72.95,126.99 82.31,126.99 83.03,127.72 83.03,127.92 83.34,128.23 85.81,128.23 87.43,126.61 91.46,126.61 93.63,128.79 93.63,129.2 94.59,130.16 95.21,130.16 97.13,132.07 100.95,132.07 101.08,131.95 102.56,131.95 104.53,133.92 105.09,133.92 105.47,133.54 105.47,133.18 v1(105.65,133.01)
  BOTTOM w0.102: JMINI3.23 105.75,134.65 105.75,133.67 105.48,133.4 105.48,133.17 v1(105.65,133.01)
PCIE_PRX_WPANTX_P6: length 84.1
  TOP w0.102: v1(40.34,105.78) 40.72,105.4 UH1.AW38
  IN4 w0.117: v1(40.34,105.78) 40.55,105.57 40.55,105.29 40.8,105.03 41.51,105.03 41.81,105.34 45.44,105.34 45.88,105.78 45.88,106.2 48.07,108.39 48.07,109.41 49.28,110.62 50.45,110.62 51.83,112 52.51,112 66.72,126.21 66.72,126.87 67.42,127.57 72.04,127.57 72.86,126.76 82.41,126.76 83.27,127.62 83.27,127.82 83.44,127.99 85.72,127.99 87.33,126.38 91.55,126.38 93.87,128.69 93.87,129.1 94.69,129.92 95.31,129.92 97.23,131.84 100.86,131.84 100.98,131.71 102.66,131.71 104.62,133.68 104.99,133.68 105.23,133.44 105.23,133.18 v1(105.06,133.01)
  BOTTOM w0.102: v1(105.06,133.01) 105.27,133.21 105.27,133.41 104.95,133.73 104.95,134.52 104.95,134.52 JMINI3.25
PCIE_PTX_EXPRX_N7: length 50.8
  TOP w0.102: JIO1.29 8.73,102.6 8.92,102.41 9.04,102.41 v1(9.31,102.68) ; UH1.BE40 43.26,105.91 43.34,105.83 43.54,105.83 43.62,105.9 43.62,106.26 43.93,106.56 44.37,106.56 44.72,106.91 44.91,106.91 45.09,107.09 v1(45.09,107.28)
  IN3 w0.127: v1(45.09,107.28) 44.89,107.48 44.89,109.92 43.14,111.67 39.81,111.67 39.61,111.87 35.44,111.87 34.53,110.95 32.83,110.95 31.71,112.08 22.8,112.08 22.01,111.29 18.99,111.29 18.27,110.57 16.92,110.57 15.01,108.67 14.18,108.67 13.21,107.7 11.08,107.7 10.25,106.87 10.25,103.01 9.76,102.52 9.46,102.52 v1(9.31,102.68)
PCIE_PTX_EXPRX_P7: length 50.7
  TOP w0.102: v1(44.44,107.31) 44.44,106.94 44.28,106.78 43.84,106.78 43.42,106.36 43.1,106.36 42.74,106 UH1.BC40 ; v1(9.31,101.94) 9.05,102.19 8.92,102.19 8.73,102 JIO1.31
  IN3 w0.127: v1(44.44,107.31) 44.64,107.51 44.64,107.74 44.53,107.85 44.53,108.28 44.64,108.39 44.64,108.77 44.53,108.88 44.53,109.31 44.64,109.42 44.64,109.81 43.04,111.42 39.71,111.42 39.51,111.62 35.54,111.62 34.63,110.7 32.73,110.7 31.6,111.83 22.9,111.83 22.11,111.04 19.09,111.04 18.37,110.32 17.02,110.32 15.12,108.42 14.28,108.42 13.31,107.45 11.18,107.45 10.5,106.77 10.5,102.91 9.86,102.27 9.43,102.27 9.31,102.14 v1(9.31,101.94)
PCIE_PTX_GLANRX_N2: length 111.7
  TOP w0.076: UH1.BD33 42.86,103.08 42.93,103.08 43.09,103.24 43.41,103.24 43.5,103.34 43.5,103.37 43.52,103.39
  TOP w0.102: v1(45.01,103.37) 45.01,103.48 44.69,103.8 43.93,103.8 43.52,103.39
  IN4 w0.117: v1(45.01,103.37) 44.9,103.48 44.9,103.69 45.06,103.85 46.14,103.85 47.35,105.07 47.35,105.6 48.8,107.05 49.07,107.05 52.47,110.45 53.05,110.45 59.63,117.03 66.18,117.03 66.82,116.38 71.33,116.38 73.15,118.2 83.14,118.2 85.61,115.73 87.31,115.73 88.63,117.05 89.7,117.05 93.79,121.15 93.79,123.46 94.15,123.81 94.15,126.67 97.73,130.25 99.88,130.25 99.99,130.14 103.34,130.14 103.89,130.69 106.72,130.69 109.44,133.41 113.88,133.41 116.42,135.96 116.42,138.82 117.97,140.36 117.97,143.8 117.97,143.81 117.97,149.16 116.35,150.79 v1(115.65,150.79)
  BOTTOM w0.102: v1(115.65,150.79) 115.84,150.6 115.98,150.6 C461.1
PCIE_PTX_GLANRX_N2_C: length 2.4
  BOTTOM w0.102: U31.42 118.83,150.84 118.74,150.75 v3(118.17,150.75) 117.84,150.75 117.66,150.57 117.55,150.57 C461.2
PCIE_PTX_GLANRX_P2: length 111.6
  TOP w0.076: UH1.BB33 42.37,103.16 42.68,102.84 42.93,102.84 43.16,103.08 43.48,103.08 43.62,103.22 43.66,103.22 43.67,103.23
  TOP w0.102: 43.67,103.23 43.81,103.37 v1(44.35,103.37)
  IN4 w0.117: v1(44.35,103.37) 44.43,103.37 44.67,103.61 44.67,103.79 44.96,104.08 46.04,104.08 47.12,105.16 47.12,105.7 48.7,107.28 48.97,107.28 52.37,110.69 52.95,110.69 59.53,117.26 66.27,117.26 66.92,116.62 71.23,116.62 73.05,118.43 83.24,118.43 85.7,115.97 87.21,115.97 88.53,117.29 89.6,117.29 93.56,121.25 93.56,123.56 93.91,123.91 93.91,126.77 97.63,130.49 99.98,130.49 100.08,130.38 103.24,130.38 103.8,130.93 106.62,130.93 109.34,133.65 113.78,133.65 116.19,136.05 116.19,138.91 117.73,140.46 117.73,143.9 117.74,143.91 117.74,149.07 116.26,150.55 116,150.55 115.65,150.2 v1(115.65,150.2)
  BOTTOM w0.102: v1(115.65,150.2) 115.84,150.39 115.93,150.39 C460.1
PCIE_PTX_GLANRX_P2_C: length 2.4
  BOTTOM w0.102: U31.41 118.85,150.44 118.75,150.53 118.49,150.53 118.47,150.52 117.92,150.52 117.75,150.35 117.53,150.35 C460.2
PCIE_PTX_MMIRX_N8: length 50
  TOP w0.102: UH1.BD42 42.57,107.09 v1(42.27,107.39) ; JIO1.13 8.67,107.4 8.85,107.58 9.1,107.58 9.2,107.48 9.51,107.48 v1(9.81,107.17)
  IN3 w0.127: v1(9.81,107.17) 9.81,107.45 9.91,107.55 10.17,107.55 10.24,107.63 10.24,108.07 10.35,108.17 10.81,108.17 10.85,108.21 12.98,108.21 14.39,109.62 14.92,109.62 17.1,111.8 21.38,111.8 22.16,112.59 31.93,112.59 32.14,112.38 41.69,112.38 41.87,112.21 43.36,112.21 46.19,109.38 46.19,106.92 46.03,106.76 45.72,106.76 45.61,106.87 45.18,106.87 45.07,106.76 44.2,106.76 44.09,106.87 43.72,106.87 43.62,106.76 43.28,106.76 42.84,107.2 42.46,107.2 v1(42.27,107.39)
PCIE_PTX_MMIRX_P8: length 50
  TOP w0.102: v1(9.81,107.99) 9.52,107.69 9.29,107.69 9.19,107.8 8.86,107.8 8.66,108 JIO1.11 ; v1(42.26,106.74) 42.41,106.74 UH1.BD41
  IN3 w0.127: v1(42.26,106.74) 42.47,106.95 42.74,106.95 43.18,106.51 46.14,106.51 46.44,106.82 46.44,109.48 43.47,112.46 41.97,112.46 41.8,112.63 32.25,112.63 32.04,112.84 22.06,112.84 21.27,112.05 17,112.05 14.82,109.87 14.28,109.87 12.88,108.46 10.75,108.46 10.71,108.42 10.24,108.42 v1(9.81,107.99)
PCIE_PTX_WLANRX_N3: length 134.5
  TOP w0.102: v1(48.54,105.05) 48.7,104.89 48.7,104.76 48.57,104.63 48.02,104.63 47.9,104.52 44.16,104.52 43.26,103.62 UH1.BE34
  IN4 w0.117: v1(131.63,153.85) 131.62,153.85 131.27,154.19 131.16,154.19 131.05,154.08 131.05,152.91 131.66,152.3 131.66,150.51 136.32,145.84 136.32,135.67 131.63,130.97 128.46,130.97 122.18,124.7 122.18,121.73 116.06,115.61 89.01,115.61 87.89,114.48 84.98,114.48 82.5,116.95 81.91,116.95 81.3,116.34 72.34,116.34 71.63,115.64 66.53,115.64 65.87,116.29 59.93,116.29 53.31,109.68 52.74,109.68 49.37,106.31 49.1,106.31 48.2,105.41 48.2,105.31 48.46,105.05 v1(48.54,105.05)
  BOTTOM w0.102: C596.1 132.63,153.71 132.3,154.03 131.82,154.03 v1(131.63,153.85)
PCIE_PTX_WLANRX_N3_C: length 2.7
  BOTTOM w0.102: JMINI4.31 135.25,153.74 134.96,154.04 133.92,154.04 C596.2
PCIE_PTX_WLANRX_P3: length 134.6
  TOP w0.102: v1(47.88,105.05) 47.88,104.8 47.81,104.73 44.07,104.73 43.21,103.87 43.13,103.87 43.1,103.84 43.09,103.85 42.81,103.57 UH1.BC34
  IN4 w0.117: v1(47.88,105.05) 47.96,105.14 47.96,105.5 49.01,106.55 49.28,106.55 52.64,109.91 53.22,109.91 59.83,116.53 65.97,116.53 66.62,115.87 71.53,115.87 72.24,116.58 81.2,116.58 81.81,117.19 82.6,117.19 85.07,114.72 87.79,114.72 88.91,115.84 115.96,115.84 121.95,121.83 121.95,124.8 128.36,131.21 131.53,131.21 136.09,135.76 136.09,145.74 131.42,150.41 131.42,152.2 130.81,152.81 130.81,154.18 131.06,154.43 v1(131.63,154.43)
  BOTTOM w0.102: v1(131.63,154.43) 131.82,154.25 132.31,154.25 132.66,154.6 C598.1
PCIE_PTX_WLANRX_P3_C: length 2.7
  BOTTOM w0.102: C598.2 133.93,154.25 134.95,154.25 135.23,154.54 JMINI4.33
PCIE_PTX_WPANRX_N6: length 78.5
  TOP w0.102: v1(44,106.08) 44.19,105.89 44.19,105.69 44.01,105.51 43.14,105.51 42.82,105.19 UH1.BC38 ; C636.1 102.28,133.83 102.28,133.43 v1(102.47,133.25)
  IN4 w0.117: v1(44,106.08) 44.15,106.23 44.15,106.65 43.76,107.04 43.76,107.77 46.38,110.39 47.32,110.39 48.58,111.65 49.69,111.65 51.55,113.51 52.6,113.51 65.7,126.61 65.7,127.22 67.44,128.97 86.14,128.97 87.74,127.37 91.17,127.37 92.89,129.09 92.89,129.74 95.07,131.91 95.85,131.91 96.75,132.81 100.41,132.81 100.9,133.3 100.9,133.94 101.19,134.23 102.05,134.23 102.47,133.81 v1(102.47,133.25)
PCIE_PTX_WPANRX_N6_C: length 2.7
  TOP w0.102: v1(102.45,136.03) 102.29,135.87 102.29,135.49 C636.2
  BOTTOM w0.102: JMINI3.31 102.55,134.65 102.55,135.44 102.27,135.72 102.27,135.85 v1(102.45,136.03)
PCIE_PTX_WPANRX_P6: length 78.4
  TOP w0.102: C626.1 102.07,133.91 102.07,133.54 v1(101.78,133.25) ; UH1.BE38 43.24,105.19 43.11,105.07 43.11,104.87 43.24,104.75 43.44,104.75 43.57,104.87 43.57,105.17 43.7,105.29 44.1,105.29 44.41,105.6 44.41,105.85 v1(44.64,106.08)
  IN4 w0.117: v1(101.78,133.25) 102.01,133.25 102.05,133.3 102.05,133.47 102.23,133.65 102.23,133.71 101.95,134 101.29,134 101.14,133.84 101.14,133.2 100.51,132.57 96.85,132.57 95.95,131.68 95.16,131.68 93.13,129.64 93.13,128.99 91.27,127.13 87.64,127.13 86.04,128.73 67.54,128.73 65.93,127.12 65.93,126.51 52.7,113.27 51.64,113.27 49.78,111.42 48.68,111.42 47.42,110.16 46.48,110.16 44,107.68 44,107.14 44.39,106.75 44.39,106.23 44.53,106.08 v1(44.64,106.08)
PCIE_PTX_WPANRX_P6_C: length 2.7
  TOP w0.102: v1(101.86,136.03) 102.08,135.81 102.08,135.44 C626.2
  BOTTOM w0.102: v1(101.86,136.03) 102.05,135.84 102.05,135.74 101.75,135.43 101.75,134.65 JMINI3.33
PCIE_SATA_PRX_WANTX_N4: length 193.9
  TOP w0.076: UH1.BD13 42.8,94.88 42.86,94.83 43.04,94.83 43.16,94.96 43.5,94.96 43.53,94.93 43.54,94.93
  TOP w0.102: 43.54,94.93 46.95,94.93 47.04,94.84 v3(48.05,94.84) 48.74,94.84 49.23,95.34 49.23,95.64 49.41,95.82 v1(49.46,95.82)
  IN4 w0.117: v1(49.46,95.82) 49.26,95.62 49.26,95.44 49.38,95.32 49.87,95.32 50.01,95.46 50.01,96.09 52.18,98.26 54.42,98.26 55.91,99.76 56.73,99.76 57.11,99.38 58.63,99.38 58.76,99.5 59.98,99.5 60.75,100.27 68.31,100.27 68.97,100.93 72.86,100.93 73.28,101.35 82.41,101.35 82.68,101.08 107.19,101.08 108.79,99.48 119.41,99.48 119.72,99.17 122.36,99.17 122.6,98.93 132.71,98.93 133.59,98.05 138.95,98.05 139.35,97.66 175.49,97.66 181.16,91.99 181.16,88.18 186.73,82.61 193.89,82.61 199.1,77.4 199.1,76.63 208.77,66.97 212.07,66.97 212.33,66.71 212.33,65.97 212.12,65.76 211.81,65.76 v1(211.62,65.57)
  BOTTOM w0.102: C534.1 212.09,65.78 211.83,65.78 v1(211.62,65.57)
PCIE_SATA_PRX_WANTX_N4_C: length 2.2
  BOTTOM w0.102: C534.2 213.64,65.74 214.19,65.74 214.26,65.68 214.61,65.68 214.73,65.56 U637.4
PCIE_SATA_PRX_WANTX_P4: length 194
  TOP w0.076: UH1.BB13 42.4,95.03 42.68,95.31 42.93,95.31 43.13,95.12 43.5,95.12 43.53,95.15 43.54,95.15
  TOP w0.102: 43.54,95.15 47.04,95.15 47.13,95.06 47.75,95.06 47.76,95.07 48.38,95.07 48.4,95.06 48.65,95.06 49.02,95.43 49.02,95.65 v1(48.85,95.82)
  IN4 w0.117: v1(211.62,66.2) 211.82,66 212.02,66 212.09,66.07 212.09,66.61 211.98,66.73 208.67,66.73 198.87,76.53 198.87,77.3 193.79,82.38 186.63,82.38 180.93,88.08 180.93,91.89 175.4,97.42 139.25,97.42 138.86,97.82 133.49,97.82 132.61,98.69 122.5,98.69 122.26,98.94 119.62,98.94 119.31,99.25 108.7,99.25 107.1,100.85 82.58,100.85 82.32,101.11 73.38,101.11 72.96,100.7 69.07,100.7 68.41,100.04 60.85,100.04 60.08,99.27 58.86,99.27 58.73,99.14 57.01,99.14 56.63,99.52 56.01,99.52 54.51,98.02 52.28,98.02 50.25,95.99 50.25,95.36 49.97,95.08 49.28,95.08 49.02,95.34 49.02,95.65 v1(48.85,95.82)
  BOTTOM w0.102: v1(211.62,66.2) 211.83,65.99 212.09,65.99 C533.1
PCIE_SATA_PRX_WANTX_P4_C: length 2.2
  BOTTOM w0.102: U637.5 214.81,66.06 214.69,65.94 214.37,65.94 214.3,66.01 213.66,66.01 C533.2
PCIE_SATA_PTX_WANRX_N4: length 194.4
  TOP w0.102: v1(40.46,95.29) 40.13,95.62 UH1.AV15
  IN4 w0.089: 41.83,95.48 41.82,95.49 41.77,95.49 41.4,95.87 40.86,95.87 40.64,95.65 40.64,95.48 v1(40.46,95.29)
  IN4 w0.117: 41.83,95.48 42.22,95.09 48.39,95.09 49.03,94.45 50.25,94.45 50.88,95.08 50.88,95.74 51.76,96.61 53.04,96.61 53.65,96 55.32,96 56.81,97.5 64.01,97.5 64.68,98.16 67.58,98.16 69.18,99.76 73.41,99.76 74.14,100.49 82.01,100.49 82.65,99.84 107.22,99.84 108.44,98.62 117.15,98.62 118.93,96.84 132.23,96.84 132.28,96.79 174.17,96.79 180.13,90.83 180.13,87.96 186.34,81.75 193.51,81.75 198.09,77.17 198.09,76.43 210.27,64.25 211.44,64.25 v1(211.62,64.43)
  BOTTOM w0.102: v1(211.62,64.43) 211.83,64.22 212.09,64.22 C513.1
PCIE_SATA_PTX_WANRX_N4_C: length 2.3
  BOTTOM w0.102: U637.2 214.73,64.56 214.62,64.44 214.26,64.44 214.06,64.24 213.65,64.24 C513.2
PCIE_SATA_PTX_WANRX_P4: length 194.4
  TOP w0.102: v1(41.06,95.29) 41.05,95.29 40.72,95.62 UH1.AW15
  IN4 w0.089: 41.66,95.31 41.65,95.33 41.65,95.37 41.32,95.69 40.94,95.69 40.82,95.58 40.82,95.39 40.92,95.29 v1(41.06,95.29)
  IN4 w0.117: v1(211.62,63.79) 211.62,63.91 211.51,64.01 210.17,64.01 197.85,76.33 197.85,77.07 193.41,81.51 186.24,81.51 179.89,87.87 179.89,90.74 174.07,96.56 132.19,96.56 132.14,96.61 118.83,96.61 117.05,98.38 108.34,98.38 107.12,99.6 82.55,99.6 81.91,100.25 74.24,100.25 73.51,99.53 69.27,99.53 67.67,97.93 64.78,97.93 64.11,97.26 56.9,97.26 55.41,95.77 53.55,95.77 52.94,96.38 51.85,96.38 51.11,95.64 51.11,94.98 50.35,94.21 48.93,94.21 48.29,94.85 42.12,94.85 41.66,95.31
  BOTTOM w0.102: C514.1 212.09,64 211.83,64 v1(211.62,63.79)
PCIE_SATA_PTX_WANRX_P4_C: length 2.3
  BOTTOM w0.102: C514.2 213.65,63.97 214.17,63.97 214.37,64.18 214.64,64.18 214.76,64.06 U637.1
PCIE_WAKE#: length 403
  TOP w0.102: v1(99.86,153.86) 99.45,153.45 R759.2 99.25,153.22 98.15,152.13 98.15,150.58 95.16,147.58 v2(95.16,146.48) 95.16,145.96 v1(95.11,145.91) ; JIO1.83 v1(6.52,86.4)
  IN1 w0.102: 123.96,128.57 v1(119.15,133.39)
  IN1 w0.109: v1(134.65,135.34) 131.8,135.34 130.88,134.43 120.19,134.43 v1(119.15,133.39) ; 123.96,128.57 124.57,127.96 124.57,123.1 123.45,121.98 123.45,112.25 125.54,110.16 125.54,102.09 v1(125.76,101.86) 127.85,99.78 128.38,99.78 130.51,97.65 161.15,97.65 164.44,94.36 166.03,94.36 177.18,83.21 179.45,83.21 179.68,83.45 181.14,83.45 184.16,80.43 195.61,80.43 205.06,70.98 212.2,70.98 213.31,72.09 213.31,73.01 213.76,73.45 214.47,73.45 214.96,72.97 221.21,72.97 222.82,71.36 231.81,71.36 231.94,71.49 242.43,71.49 243.04,72.1 247.06,72.1 248.39,73.43 251.64,73.43 253.16,74.95 253.82,74.95 256.27,77.4 v1(258.25,77.4)
  IN2 w0.127: v1(123.07,93.69) 122.87,93.89 117.94,93.89 117.58,94.26 113.52,94.26 113.48,94.3 92.64,94.3 91.73,93.38 89.45,93.38 88.13,92.06 88.13,91.17 80.72,83.75 69.56,83.75 67.32,81.52 58.12,81.52 56.72,80.12 52.17,80.12 51.62,79.58 47.1,79.58 46.88,79.36 39.38,79.36 38.77,78.75 34.63,78.75 33.79,79.59 29.38,79.59 29.15,79.36 25.65,79.36 25.02,78.73 17.4,78.73 16.77,78.09 13.32,78.09 7.02,84.39 7.02,85.91 6.53,86.4 v1(6.52,86.4)
  IN3 w0.127: v1(119.15,133.39) 118.26,134.28 109.76,134.28 105.32,138.72 102.17,138.72 95.11,145.78 v1(95.11,145.91)
  BOTTOM w0.102: v1(134.65,135.34) 134.65,138.28 134.92,138.54 JMINI4.1 ; JMINI3.1 117.75,133.58 117.98,133.35 119.11,133.35 v1(119.15,133.39) ; v1(125.76,101.86) R1972.2 126.22,100.62 126.22,99.83 125.18,98.79 124.88,98.79 123.07,96.99 v1(123.07,93.69) ; v1(99.86,153.86) 99.69,154.02 U51.B38 ; v1(258.25,77.4) 258.25,78.52 261.78,82.05 261.78,88.22 261.41,88.6 JMINI2.1
PCLK_80H: length 153.6
  IN4 w0.109: v1(128.46,153.76) 126.97,153.76 126.65,154.08 120.32,154.08 119.15,155.24 113.67,155.24 113.29,154.87 112.67,154.87 110.36,152.56 110.36,149.27 109.91,148.83 109.91,143.47 110.14,143.24 110.14,140.51 109.76,140.13 109.22,140.13 108.94,140.41 108.94,140.94 108.69,141.19 107.24,141.19 106.77,140.73 97.81,140.73 94.23,137.15 90.77,137.15 89.55,138.37 84.57,138.37 82.25,136.05 74.1,136.05 73.68,135.63 68.87,135.63 67.86,136.64 62.62,136.64 61.45,137.81 48.38,137.81 46.97,136.39 42.42,136.39 40.24,134.21 39.26,134.21 34.31,129.26 34.31,122.18 31.96,119.83 31.96,118.61 29.61,116.26 29.61,114.7 28.89,113.98 28.89,113.42 28.36,112.89 24.37,112.89 v1(22.08,110.6)
  BOTTOM w0.102: v1(22.08,110.6) 21.8,110.32 RH159.1 ; v1(128.46,153.76) 129.65,152.57 129.65,151.81 132.52,148.94 JMINI4.19
PECI_EC: length 106.9
  TOP w0.102: JCPU1.AR27 v1(80.12,74.75)
  IN1 w0.109: v1(80.12,74.75) 80.12,74.76 80.63,75.27 80.63,79 81.86,80.24 81.86,98.42 82.08,98.64 82.08,103.92 81.5,104.5 81.5,109.1 80.78,109.82 80.78,116.52 80.38,116.92 80.38,119.16 80.49,119.27 80.49,123.07 80.87,123.45 80.87,124.48 79.96,125.39 78.79,125.39 77.11,127.07 77.11,135.82 75.63,137.3 75.63,139.08 71.69,143.03 v1(71.69,146.67)
  BOTTOM w0.102: R952.2 92.19,158.41 91.09,157.31 91.09,154.16 v2(89.4,152.47) 88.86,151.93 86.94,151.93 86.67,151.66 86.67,151.09 82.25,146.67 v1(71.69,146.67)
PECI_EC_R: length 5.6
  BOTTOM w0.102: U51.A48 98.22,160.27 97.9,160.59 97.21,160.59 v2(96,159.37) 94.67,159.37 R952.1
PEG_B_CLKRQ#: length 10.5
  TOP w0.102: RH130.2 27.8,83.25 27.8,85.18 29.78,87.16 v2(30.06,87.16) 30.45,87.16 31.63,88.34 31.63,89.61 31.6,89.64 31.6,89.91 31.61,89.92 31.61,89.93 31.79,90.11 31.79,90.36 31.5,90.65 UH1.U4
PEG_COMP: length 4.4
  TOP w0.305: v1(84.12,43.75) 84.59,44.22 JCPU1.E23
  BOTTOM w0.305: v1(84.12,43.75) v2(84.12,44.83) 83.63,45.32 83.63,47.2 RC2.2
PEG_CRX_GTX_C_N0: length 3.1
  TOP w0.109: CC16.1 87.24,107.36 87.24,106.9 v3(87.42,106.72) 87.61,106.53 87.61,105.91 87.75,105.77 JMXM1.177
PEG_CRX_GTX_C_N1: length 2.9
  TOP w0.109: JMXM1.171 89.25,105.76 89.11,105.91 89.11,106.92 89.04,106.98 89.04,107.38 CC15.1
PEG_CRX_GTX_C_N2: length 3
  TOP w0.109: JMXM1.165 90.75,105.74 90.61,105.88 90.61,106.48 90.84,106.72 90.84,107.4 CC14.1
PEG_CRX_GTX_C_N3: length 3.9
  TOP w0.109: CC13.1 92.67,107.39 92.67,107.03 92.8,106.89 93.54,106.89 v3(93.73,106.7) 94.11,106.33 94.11,105.91 94.25,105.77 JMXM1.157
PEG_CRX_GTX_C_N4: length 3.7
  TOP w0.109: CC12.1 94.42,107.36 94.42,107.24 94.8,106.86 95.24,106.86 95.61,106.5 95.61,105.94 95.75,105.79 JMXM1.151
PEG_CRX_GTX_C_N5: length 3.3
  TOP w0.109: JMXM1.145 97.25,105.77 97.11,105.91 97.11,106.29 v3(96.62,106.78) 96.2,107.2 96.2,107.36 CC11.1
PEG_CRX_GTX_C_N6: length 3.2
  TOP w0.109: JMXM1.139 98.75,105.76 98.61,105.91 98.61,106.47 v3(98.28,106.79) 98.01,107.07 98,107.07 98,107.39 CC10.1
PEG_CRX_GTX_C_N7: length 3
  TOP w0.109: JMXM1.133 100.25,105.78 100.11,105.93 100.11,106.51 99.79,106.82 99.79,107.4 CC9.1
PEG_CRX_GTX_C_N8: length 3
  TOP w0.109: CC8.1 101.54,107.37 101.54,107.31 101.61,107.25 101.61,107.05 101.61,107.04 v3(101.61,106.72) 101.61,106.3 101.61,106.3 101.61,105.88 101.75,105.74 JMXM1.127
PEG_CRX_GTX_C_N9: length 3
  TOP w0.109: CC7.1 103.32,107.37 103.32,106.83 103.11,106.62 103.11,105.93 103.25,105.79 JMXM1.121
PEG_CRX_GTX_C_N10: length 3.1
  TOP w0.109: JMXM1.115 104.75,105.76 104.61,105.9 104.61,106.36 105.11,106.87 105.11,107.39 CC6.1
PEG_CRX_GTX_C_N11: length 3.3
  TOP w0.109: CC5.1 106.89,107.39 106.89,107.02 106.63,106.75 106.63,106.72 106.2,106.3 106.17,106.3 106.11,106.23 106.11,105.93 106.25,105.78 JMXM1.109
PEG_CRX_GTX_C_N12: length 3.5
  TOP w0.109: JMXM1.103 107.75,105.76 107.61,105.9 107.61,106.3 108.07,106.77 108.34,106.77 108.67,107.1 108.67,107.39 CC4.1
PEG_CRX_GTX_C_N13: length 3.7
  TOP w0.109: JMXM1.97 109.25,105.78 109.11,105.92 109.11,106.18 109.58,106.65 109.95,106.65 110.46,107.16 110.46,107.4 CC3.1
PEG_CRX_GTX_C_N14: length 3.9
  TOP w0.109: JMXM1.91 110.75,105.75 110.61,105.9 110.61,106.12 110.79,106.31 110.82,106.31 111.24,106.72 111.24,106.75 111.42,106.94 111.96,106.94 112.21,107.18 112.21,107.37 CC2.1
PEG_CRX_GTX_C_N15: length 4.2
  TOP w0.109: CC1.1 113.97,107.36 113.97,107.07 113.76,106.86 113.76,106.82 113.34,106.4 113.31,106.4 113.03,106.12 112.21,106.12 112.11,106.02 112.11,105.89 112.25,105.75 JMXM1.85
PEG_CRX_GTX_C_P0: length 3.1
  TOP w0.109: JMXM1.179 87.25,105.77 87.39,105.91 87.39,106.41 87.03,106.78 87.03,107.4 CC32.1
PEG_CRX_GTX_C_P1: length 2.9
  TOP w0.109: CC31.1 88.83,107.38 88.83,106.89 88.89,106.83 88.89,105.89 88.75,105.74 JMXM1.173
PEG_CRX_GTX_C_P2: length 3
  TOP w0.109: CC30.1 90.63,107.36 90.63,106.8 90.39,106.57 90.39,105.88 90.25,105.73 JMXM1.167
PEG_CRX_GTX_C_P3: length 3.9
  TOP w0.109: CC29.1 92.46,107.37 92.46,106.94 92.74,106.65 93.45,106.65 93.89,106.21 93.89,105.89 93.75,105.74 JMXM1.159
PEG_CRX_GTX_C_P4: length 3.7
  TOP w0.109: CC28.1 94.21,107.4 94.21,107.16 94.71,106.65 95.16,106.65 95.39,106.41 95.39,105.91 95.25,105.77 JMXM1.153
PEG_CRX_GTX_C_P5: length 3.3
  TOP w0.109: JMXM1.147 96.75,105.77 96.89,105.91 96.89,106.15 96.66,106.39 96.66,106.39 96.18,106.86 96.18,106.87 95.99,107.06 95.99,107.4 CC27.1
PEG_CRX_GTX_C_P6: length 3.2
  TOP w0.109: CC26.1 97.79,107.37 97.79,106.98 97.91,106.86 97.91,106.83 98.33,106.41 98.36,106.41 98.39,106.37 98.39,105.92 98.25,105.77 JMXM1.141
PEG_CRX_GTX_C_P7: length 3.1
  TOP w0.109: CC25.1 99.58,107.36 99.58,106.74 99.89,106.42 99.89,105.92 99.75,105.77 JMXM1.135
PEG_CRX_GTX_C_P8: length 3
  TOP w0.109: CC24.1 101.33,107.39 101.33,107.23 101.39,107.16 101.39,107.04 101.37,107.01 101.37,106.43 101.39,106.4 101.39,105.89 101.25,105.75 JMXM1.129
PEG_CRX_GTX_C_P9: length 3
  TOP w0.109: CC23.1 103.11,107.39 103.11,106.92 102.89,106.71 102.89,105.92 102.75,105.77 JMXM1.123
PEG_CRX_GTX_C_P10: length 3.1
  TOP w0.109: CC22.1 104.9,107.37 104.9,107 v3(104.59,106.69) 104.39,106.49 104.39,105.9 104.25,105.75 JMXM1.117
PEG_CRX_GTX_C_P11: length 3.2
  TOP w0.109: CC21.1 106.68,107.37 106.68,107.11 v3(106.26,106.69) 105.89,106.32 105.89,105.92 105.75,105.78 JMXM1.111
PEG_CRX_GTX_C_P12: length 3.5
  TOP w0.109: CC20.1 108.46,107.37 108.46,107.18 108.25,106.98 107.95,106.98 v3(107.69,106.72) 107.39,106.42 107.39,105.9 107.25,105.75 JMXM1.105
PEG_CRX_GTX_C_P13: length 3.7
  TOP w0.109: CC19.1 110.24,107.36 110.24,107.24 109.87,106.86 109.46,106.86 v3(109.3,106.71) 108.89,106.3 108.89,105.92 108.75,105.78 JMXM1.99
PEG_CRX_GTX_C_P14: length 3.9
  TOP w0.109: CC18.1 112,107.39 112,107.27 111.88,107.15 111.33,107.15 v3(110.87,106.69) 110.39,106.21 110.39,105.9 110.25,105.76 JMXM1.93
PEG_CRX_GTX_C_P15: length 4.2
  TOP w0.109: JMXM1.87 111.75,105.73 111.9,105.88 111.9,106.11 112.12,106.34 112.94,106.34 v3(113.39,106.78) 113.76,107.15 113.76,107.4 CC17.1
PEG_CRX_GTX_N0: length 102.6
  TOP w0.102: v1(75.11,43.76) 75.59,44.25 JCPU1.E32
  TOP w0.109: v1(87.54,109.58) 87.39,109.58 87.26,109.46 87.26,108.97 CC16.2
  IN3 w0.089: 71.89,41.4 71.93,41.36 74.36,41.36 74.54,41.55 74.54,43.04 74.84,43.33 75.03,43.33 75.11,43.41 v1(75.11,43.76)
  IN3 w0.14: v1(87.54,109.58) 87.32,109.58 87.14,109.41 87.14,109.08 87.82,108.41 87.82,105.41 85.42,103.01 84.72,103.01 82.86,101.15 80.6,101.15 78.19,98.75 75.01,98.75 74.56,98.3 74.56,97.32 73.29,96.05 73,96.05 72.28,95.33 72.28,94.92 71.46,94.09 71.05,94.09 67.92,90.96 67.92,89.73 63.58,85.39 63.15,85.39 57.81,80.05 57.81,77.4 57.44,77.04 57.44,75.38 58,74.82 58,74.17 57.54,73.72 57.54,71.39 58.45,70.47 58.45,51.34 62.8,47 62.8,45.08 66.48,41.4 69.64,41.4 69.75,41.51 70.2,41.51 70.31,41.4 70.81,41.4 70.92,41.51 71.36,41.51 71.48,41.4 71.89,41.4
PEG_CRX_GTX_N1: length 100.3
  TOP w0.102: v1(74.11,44.76) 74.59,44.28 JCPU1.E33
  TOP w0.109: CC15.2 89.04,108.97 89.04,109.46 89.16,109.58 v1(89.32,109.58)
  IN3 w0.089: v1(74.11,44.76) 74.38,44.76 74.67,44.47 74.67,44.23 74.54,44.1 74.54,43.62 74.24,43.33 73.88,43.33 72.91,42.36 71.92,42.36 71.89,42.39 71.87,42.39
  IN3 w0.14: v1(89.32,109.58) 89.1,109.58 88.92,109.41 88.92,108.96 89.32,108.56 89.32,105.78 87.49,103.95 87.49,103.13 86.37,102.02 84.87,102.02 83.21,100.35 80.94,100.35 79.4,98.81 79.4,97.76 78.87,97.23 75.77,97.23 71.77,93.23 71.31,93.23 68.94,90.86 68.94,89.61 63.69,84.35 63.25,84.35 58.74,79.85 58.74,78.24 59.26,77.72 59.26,51.88 63.71,47.43 63.71,45.31 66.64,42.39 69.74,42.39 69.83,42.48 70.27,42.48 70.36,42.39 70.86,42.39 70.95,42.48 71.39,42.48 71.48,42.39 71.87,42.39
PEG_CRX_GTX_N2: length 97.7
  TOP w0.102: JCPU1.D34 73.59,43.28 v1(73.11,43.76)
  TOP w0.109: v1(91.09,110.35) 90.94,110.35 90.82,110.22 90.82,108.97 CC14.2
  IN3 w0.089: v1(73.11,43.76) 73.2,43.85 73.47,43.85 73.57,43.75 73.57,43.64 73.25,43.32 71.92,43.32 71.89,43.35 71.87,43.35
  IN3 w0.14: 71.87,43.35 71.45,43.35 71.36,43.44 70.91,43.44 70.82,43.35 70.32,43.35 70.23,43.44 69.79,43.44 69.7,43.35 66.8,43.35 64.52,45.63 64.52,47.76 60.07,52.22 60.07,78.18 59.55,78.69 59.55,79.51 60.58,80.54 61.19,80.54 69.99,89.33 69.99,90.3 76.09,96.41 79.75,96.41 82.5,99.16 83.19,99.16 85.21,101.18 86.75,101.18 88.4,102.83 88.87,102.83 90.7,104.66 90.7,110.17 90.88,110.35 v1(91.09,110.35)
PEG_CRX_GTX_N3: length 93.9
  TOP w0.102: JCPU1.E35 72.59,44.28 v1(72.11,44.76)
  TOP w0.109: v1(92.93,109.58) 92.78,109.58 92.66,109.46 92.66,108.97 CC13.2
  IN3 w0.089: v1(72.11,44.76) 72.5,44.76 72.65,44.62 72.65,44.35 72.53,44.23 71.28,44.23 71.25,44.26 71.23,44.26
  IN3 w0.14: v1(92.93,109.58) 92.72,109.58 92.54,109.41 92.54,104.95 88.68,101.09 88.29,101.09 86.38,99.19 84.35,99.19 83.52,98.35 82.84,98.35 79.96,95.48 76.3,95.48 70.98,90.15 70.98,89.19 60.87,79.08 60.87,52.72 65.59,47.99 65.59,45.71 67.04,44.26 68.09,44.26 68.19,44.36 68.63,44.36 68.73,44.26 69.23,44.26 69.33,44.36 69.78,44.36 69.88,44.26 71.23,44.26
PEG_CRX_GTX_N4: length 101.9
  TOP w0.102: v1(77.11,42.76) 77.59,43.25 JCPU1.D30
  TOP w0.109: v1(94.71,110.5) 94.56,110.5 94.44,110.37 94.44,108.97 CC12.2
  IN3 w0.089: v1(77.11,42.76) 76.89,42.97 76.89,43.24 76.97,43.32 77.12,43.32 77.52,42.92 77.52,42.58 77.29,42.35 75.96,42.35 75.71,42.6 75.71,44.96 75.31,45.36 72.02,45.36 71.99,45.39 71.97,45.39
  IN3 w0.14: 71.97,45.39 71.56,45.39 71.45,45.5 71,45.5 70.89,45.39 70.4,45.39 70.29,45.5 69.84,45.5 69.73,45.39 69.39,45.39 61.71,53.07 61.71,78.79 72.07,89.15 72.07,90.11 75.9,93.94 80.6,93.94 84.24,97.57 84.24,97.87 84.74,98.38 86.7,98.38 88.62,100.29 89.01,100.29 94.32,105.6 94.32,110.32 94.49,110.5 v1(94.71,110.5)
PEG_CRX_GTX_N5: length 96.9
  TOP w0.102: v1(76.11,43.76) 76.59,44.25 JCPU1.E31
  TOP w0.109: CC11.2 96.21,108.97 96.21,109.46 96.34,109.58 v1(96.49,109.58)
  IN3 w0.089: 71.92,46.38 71.94,46.38 71.97,46.35 75.36,46.35 75.68,46.03 75.68,45.6 75.92,45.36 76.36,45.36 76.68,45.03 76.68,44.17 76.47,43.97 76.31,43.97 v1(76.11,43.76)
  IN3 w0.14: 71.92,46.38 71.63,46.38 71.52,46.49 71.07,46.49 70.97,46.38 70.47,46.38 70.36,46.49 69.92,46.49 69.81,46.38 69.53,46.38 62.53,53.39 62.53,78.42 73.06,88.95 73.06,89.97 76.11,93.03 80.91,93.03 84.81,96.92 86.84,96.92 87.57,97.66 87.57,98.1 88.72,99.25 89.16,99.25 91.09,101.18 92.16,101.18 95.78,104.8 95.78,107.08 96.1,107.4 96.1,109.41 96.27,109.58 v1(96.49,109.58)
PEG_CRX_GTX_N6: length 101.3
  TOP w0.102: JCPU1.D28 79.59,43.25 v1(79.11,42.76)
  TOP w0.109: CC10.2 98.01,108.63 97.91,108.74 97.91,109.17 97.65,109.43 97.65,109.77 97.77,109.89 97.93,109.89 98.08,109.74 v1(98.08,109.69)
  IN3 w0.089: v1(79.11,42.76) 79.11,43.01 78.95,43.17 77.9,43.17 77.5,43.56 77.5,44.93 77.28,45.15 76.88,45.15 76.49,45.55 76.49,45.93 76.23,46.19 75.88,46.19 75.52,46.54 75.52,46.9 75.26,47.17 72,47.17 71.97,47.13
  IN3 w0.14: v1(98.08,109.69) 98.24,109.85 98.43,109.85 98.59,109.7 98.59,108.93 96.86,107.2 96.86,104.79 92.44,100.37 91.37,100.37 89.72,98.72 89.32,98.72 88.61,98 88.61,97.58 87.41,96.37 85.04,96.37 81.01,92.34 76.2,92.34 73.64,89.78 73.64,88.76 63.08,78.2 63.08,53.62 69.57,47.13 71.97,47.13
PEG_CRX_GTX_N7: length 99.5
  TOP w0.102: JCPU1.E29 78.59,44.25 v1(78.11,43.76)
  TOP w0.109: CC9.2 99.78,108.96 99.78,109.18 99.92,109.32 99.92,109.59 100.05,109.71 v1(100.2,109.71)
  IN3 w0.089: v1(78.11,43.76) 78.3,43.95 78.5,43.95 78.73,44.18 78.73,45.94 78.32,46.35 77.96,46.35 77.75,46.57 77.75,46.95 77.33,47.37 76.95,47.37 76.73,47.59 76.73,47.96 76.33,48.36 72.01,48.36 71.98,48.39 71.95,48.39
  IN3 w0.14: v1(100.2,109.71) 99.98,109.71 99.81,109.54 99.81,107.55 98.66,106.41 98.66,104.94 92.92,99.2 91.78,99.2 86.98,94.4 85.76,94.4 82.97,91.6 82.97,89.19 79.05,85.28 71.66,85.28 64.14,77.77 64.14,54.25 69.19,49.2 69.33,49.2 69.71,48.83 69.71,48.69 70,48.39 71.95,48.39
PEG_CRX_GTX_N8: length 89.9
  TOP w0.102: v1(73.11,49.76) 73.59,50.25 JCPU1.L34
  TOP w0.109: CC8.2 101.62,108.91 101.62,109.4 101.3,109.72 100.97,109.72 v1(100.8,109.89)
  IN3 w0.089: v1(73.11,49.76) 73.11,49.49 72.98,49.36 71.94,49.36 71.91,49.39 71.89,49.39
  IN3 w0.14: 71.89,49.39 70.3,49.39 64.95,54.74 64.95,77.36 72.02,84.44 79.35,84.44 83.93,89.02 83.93,91.41 86.11,93.6 87.33,93.6 92.04,98.31 93.26,98.31 100.21,105.26 100.21,106.46 101.63,107.88 101.63,109.39 101.31,109.71 100.97,109.71 v1(100.8,109.89)
PEG_CRX_GTX_N9: length 88
  TOP w0.102: JCPU1.M35 72.59,51.24 v1(72.11,50.77)
  TOP w0.109: CC7.2 103.39,108.91 103.39,109.4 103.07,109.72 102.74,109.72 v1(102.57,109.89)
  IN3 w0.14: v1(102.57,109.89) 102.75,109.71 103.09,109.71 103.41,109.39 103.41,107.91 101.58,106.08 101.58,105.5 94.29,98.21 94.29,97.72 93.46,96.89 92.05,96.89 87.96,92.79 86.46,92.79 85,91.33 85,88.95 79.67,83.63 73.04,83.63 67.09,77.68 66.43,77.68 65.75,77 65.75,56.44 68.46,53.73 68.46,52.37 70.43,50.39 71.74,50.39 v1(72.11,50.77)
PEG_CRX_GTX_N10: length 89.8
  TOP w0.102: JCPU1.L32 75.59,50.25 v1(75.11,49.76)
  TOP w0.109: v1(104.43,109.92) 104.6,109.75 104.88,109.75 105.17,109.45 105.17,108.91 CC6.2
  IN3 w0.089: v1(75.11,49.76) 75.11,49.49 74.98,49.36 73.94,49.36 73.7,49.6 73.7,49.98 73.33,50.35 72.95,50.35 72.71,50.6 72.71,50.97 72.35,51.33 71.86,51.33 71.69,51.16 71.39,51.16 71.36,51.2 71.34,51.2
  IN3 w0.14: 71.34,51.2 70.77,51.2 69.27,52.69 69.27,55.31 67.43,57.15 67.43,76.88 73.36,82.81 79.99,82.81 87.44,90.26 87.44,90.5 88.12,91.18 88.12,91.81 92.05,95.74 93.89,95.74 95.72,97.57 95.72,98.46 103.13,105.87 103.13,106.28 105.19,108.34 105.19,109.48 104.94,109.74 104.61,109.74 v1(104.43,109.92)
PEG_CRX_GTX_N11: length 87.5
  TOP w0.102: v1(74.11,50.76) 74.59,51.25 JCPU1.M33
  TOP w0.109: CC5.2 106.95,108.91 106.95,109.4 106.63,109.72 106.3,109.72 v1(106.13,109.89)
  IN3 w0.089: v1(74.11,50.76) 74.11,50.49 74.04,50.42 73.88,50.42 73.7,50.59 73.7,51.14 72.97,51.87 71.19,51.87 70.84,52.22 70.84,52.27 70.82,52.28
  IN3 w0.14: v1(106.13,109.89) 106.31,109.71 106.64,109.71 106.97,109.39 106.97,108.85 104.68,106.56 104.68,105.99 97.32,98.63 97.32,97.77 96.79,97.24 96.53,97.24 94.04,94.75 92.96,94.75 89.98,91.78 89.98,91.22 88.78,90.02 88.32,90.02 80.3,82 73.68,82 68.23,76.55 68.23,57.49 70.09,55.64 70.09,53.02 70.82,52.28
PEG_CRX_GTX_N12: length 92
  TOP w0.102: JCPU1.L30 77.59,50.25 v1(77.11,49.76)
  TOP w0.109: CC4.2 108.73,108.91 108.73,109.4 108.41,109.72 108.08,109.72 v1(107.91,109.89)
  IN3 w0.089: v1(77.11,49.76) 77.11,49.5 76.98,49.38 75.93,49.38 75.71,49.6 75.7,49.61 75.7,49.98 75.33,50.35 74.95,50.35 74.94,50.36 74.7,50.61 74.7,51.01 74.26,51.44 74.13,51.44 73.59,51.98 73.59,51.98 73.26,52.31 71.89,52.31 71.47,52.73 71.47,52.78 71.46,52.79
  IN3 w0.14: 71.46,52.79 70.9,53.35 70.9,55.97 69.03,57.84 69.03,76.21 72.23,79.41 73.11,79.41 74.89,81.19 80.63,81.19 88.55,89.11 90.22,89.11 91.91,90.8 91.91,92.56 93.28,93.94 94.37,93.94 96.86,96.43 97.47,96.43 98.92,97.87 98.92,98.38 104.81,104.28 105.85,104.28 107.73,106.15 107.73,107.37 108.75,108.39 108.75,109.39 108.42,109.71 108.09,109.71 v1(107.91,109.89)
PEG_CRX_GTX_N13: length 90.3
  TOP w0.102: v1(76.11,50.76) 76.59,51.25 JCPU1.M31
  TOP w0.109: v1(109.69,109.89) 109.81,109.76 110.14,109.76 110.51,109.4 110.51,108.91 CC3.2
  IN3 w0.089: v1(76.11,50.76) 76.11,50.4 76.06,50.35 75.96,50.35 75.7,50.61 75.7,51 74.77,51.93 74.39,51.93 73.72,52.6 73.72,53.03 73.4,53.35 71.97,53.35 71.68,53.64 71.68,53.88 71.71,53.91 71.71,53.93
  IN3 w0.14: v1(109.69,109.89) 109.81,109.76 110.22,109.76 110.52,109.46 110.52,107.91 109.08,106.46 109.08,105.5 106.92,103.34 105.57,103.34 100.36,98.13 100.36,97.82 98.16,95.62 97.19,95.62 94.7,93.13 94.32,93.13 94.09,92.9 94.09,92.77 93.81,92.49 93.81,91.42 90.61,88.22 88.8,88.22 80.34,79.77 74.61,79.77 73.44,78.6 72.55,78.6 69.83,75.88 69.83,58.18 71.71,56.3 71.71,53.93
