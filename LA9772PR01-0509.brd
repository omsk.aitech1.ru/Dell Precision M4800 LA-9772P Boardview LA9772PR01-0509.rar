# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LED_WWAN_OUT#: length 8.6
  BOTTOM w0.102: Q77.3 246.61,70.51 v2(246.82,70.29) 247.99,69.12 248.52,69.12 249.26,69.86 R719.1 250.45,69 JMINI2.42
LG_3V: length 4.1
  BOTTOM w0.203: 248.07,57.44 247.56,57.44 247.38,57.62 PU101.11 247.38,58.02
  BOTTOM w0.762: 248.07,57.44 248.45,57.06 248.45,54.7
  vias: v2(248.23,52.79)
LG_5V: length 6.3
  IN1 w0.762: 244.2,56.47 243.24,55.51 243.24,51.14 243.62,50.76
  vias: v3(244.2,50.2) v3(244.51,50.76) v3(244.8,56.97) v3(245.31,57.41)
LG_+1.05VSP: length 7
  TOP w0.102: v3(23.15,143.42) v2(23.15,142.7)
  IN1 w0.762: v3(23.15,144.22) v3(23.15,143.42) 23.15,143.23 24.42,141.96 24.42,138.97 24.77,138.62
  vias: v3(25.51,138.9) v3(25.51,138.26)
LGATE1: length 23.6
  IN4 w1.016: 47.91,52.23 47.91,48.02 51.52,44.41 51.52,31.86 52.1,31.28 52.1,31.02
  BOTTOM w0.102: v3(52.08,30.01) v2(52.08,30.63)
  vias: v3(47.91,53.38) v3(48.5,53.96) v3(52.54,29.55)
LGATE2: length 11.7
  TOP w0.762: PQ502.4 v2(49.97,35.5) 48.56,34.08 48.56,30.99 50.05,29.5
LGATE3: length 7.8
  IN1 w0.762: 42.22,70.39 42.71,70.39 44.2,68.9 v3(48.48,68.9)
  BOTTOM w0.102: v3(48.48,68.9) 48.48,68.89 v2(49.16,68.21)
  vias: v3(41.49,71.38) v3(41.49,70.75)
LID_CL#: length 337.3
  TOP w0.102: v1(6.57,88.75) 6.62,88.8 JIO1.75
  IN2 w0.127: v1(176.78,91.29) 174.87,93.2 162.05,93.2 158.62,96.63 154.77,96.63 154.09,97.32 139.45,97.32 138.39,98.38 134.95,98.38 133.98,97.42 133.98,96.49 131.36,93.86 124.34,93.86 123.73,93.25 122.18,93.25 121.8,93.64 117.79,93.64 117.42,94 113.42,94 113.38,94.04 92.77,94.04 91.86,93.13 91.14,93.13 89.84,91.82 89.84,90.98 82.33,83.48 69.64,83.48 67.43,81.27 58.22,81.27 56.82,79.87 52.27,79.87 51.73,79.32 47.21,79.32 46.99,79.11 39.48,79.11 38.87,78.5 34.52,78.5 33.69,79.33 29.49,79.33 29.26,79.11 25.76,79.11 25.12,78.47 19.56,78.47 18.92,77.84 13.22,77.84 6.69,84.36 6.41,84.36 6.1,84.67 6.1,85.61 5.24,86.47 5.24,87.9 6.09,88.75 v1(6.57,88.75) 6.16,89.16 6.16,91.1 7.03,91.97 7.03,113.3 8.72,115 10.22,115 12.63,117.41 12.63,121.8 8.85,125.58 8.85,132.78 11.85,135.77 11.85,140.73 9.46,143.11 8.54,143.11 7.3,144.36 7.3,151.22 9.94,153.86 13.24,153.86 15.38,151.72 16.01,151.72 v1(16.04,151.75)
  BOTTOM w0.102: U58.2 17.62,153.67 16.04,152.08 v1(16.04,151.75) 16.04,151.43 v2(16.3,151.17) ; v1(176.78,91.29) 176.95,91.45 176.95,92.9 181.62,97.57 192.06,97.57 193.12,96.51 204.93,96.51 207.9,93.53 225.61,93.53 226.13,93.01 226.13,92.19 225.09,91.15 R807.1
LID_CL_SIO#: length 17.5
  TOP w0.102: v1(223.04,92.7) 224.48,91.25 224.48,90.23 223.24,88.99 222.4,88.99 221.92,88.5 221.92,86.17 222.27,85.82 222.27,84.7 221.9,84.34 v1(221.83,84.34)
  BOTTOM w0.102: v4(220.89,90.16) 221.14,90.41 221.14,91.76 221.45,92.06 R805.2 222.67,92.06 ; 222.67,92.06 222.67,92.33 v1(223.04,92.7) ; 222.67,92.06 C716.1 R807.2 ; U46.B54 221.89,84.27 v1(221.83,84.34)
LOM_ACTLED_YEL#: length 15.5
  TOP w0.102: v1(123.94,147.15) 123.94,147.41 v2(125.03,148.5)
  IN1 w0.109: v1(123.94,147.15) 123.5,146.72 123.5,145.45 126.33,142.62 130.24,142.62 131.61,141.26 v1(131.61,141.18)
  BOTTOM w0.102: U31.26 124.14,147.35 v1(123.94,147.15) ; v1(131.61,141.18) 131.43,141.01 U32.15
LOM_SPD10LED_GRN#: length 14.1
  TOP w0.102: v1(124.54,147.14) v2(125.15,147.14) 126.36,147.14 126.78,146.72 126.78,146.34 126.4,145.96 U15.2
  IN4 w0.109: v1(122.49,140.27) 122.49,142.94 124.54,144.98 v1(124.54,147.14)
  BOTTOM w0.102: U32.42 123.41,139.34 v1(122.49,140.27) ; U31.25 v1(124.54,147.14)
LOM_SPD100LED_ORG#: length 16.8
  TOP w0.102: v2(123.96,145.68) v1(123.96,146.57) 125.15,146.57 125.19,146.61 U15.1
  IN1 w0.109: v1(132.19,141.18) 130.51,142.86 126.81,142.86 123.96,145.71 v1(123.96,146.57)
  BOTTOM w0.102: v1(132.19,141.18) 131.93,140.92 U32.16 ; v1(123.96,146.57) 123.91,146.57 123.53,146.95 123.53,147.33 123.74,147.54 U31.27
LPC_LAD0: length 306.4
  TOP w0.102: UH1.A20 24.5,97.75 22.89,97.75 v2(22.64,97.5) v1(21.99,96.85)
  IN1 w0.109: v1(163.15,116.23) 163.15,115.91 165.11,113.96 165.11,111.01 171.08,105.04 173.15,105.04 186.94,91.25 186.94,88.11 189.72,85.33 198.87,85.33 201.6,82.6 205.02,82.6 205.82,81.8 210.47,81.8 v1(211.01,82.33)
  IN2 w0.127: v1(21.99,96.85) 22.08,96.94 22.08,99.21 22.86,99.99 23.52,99.99 24.19,100.65 24.19,104.33 23.68,104.84 23.68,111.14 23.86,111.31 23.86,115.23 24.99,116.36 26.93,116.36 33.29,122.72 35.42,122.72 36.97,121.17 36.97,115.96 36.46,115.45 36.46,114.89 36.71,114.64 37.02,114.64 37.58,114.09 37.58,113.34 38.03,112.89 41.31,112.89 42.96,114.54 46.77,114.54 48.95,112.35 51.94,112.35 57.08,117.5 57.08,126.15 61.95,131.02 61.95,132.21 63.2,133.46 65.94,133.46 68.39,135.91 68.83,135.91 71.39,138.47 73.74,138.47 74.19,138.91 79.76,138.91 81.38,140.52 87.4,140.52 93.2,146.32 93.2,147.29 95.33,149.42 95.33,150.38 96.48,151.53 96.48,155.43 97.34,156.3 101.13,156.3 102.78,154.65 102.78,152.26 100.75,150.23 v1(100.72,150.23)
  IN3 w0.127: v1(163.15,116.23) 163.15,116.86 152.45,127.57 152.45,136.38 150.32,138.5 146.9,138.5 145.07,140.33 145.07,141.91 v1(142.9,144.08) 139.66,144.08 136.39,147.34 128.74,147.34 127.37,145.98 121.9,145.98 120.61,147.27 114.42,147.27 112.78,148.91 112.78,149.34 110.99,151.13 101.32,151.13 100.72,150.53 v1(100.72,150.23)
  BOTTOM w0.102: v1(142.9,144.08) 143.36,144.54 143.46,144.54 JMINI4.16 ; U51.A30 100.95,151.02 100.95,150.45 v1(100.72,150.23) ; U46.A27 212.12,82.52 211.96,82.69 211.36,82.69 v1(211.01,82.33) ; U39.26 162.65,117.25 163.15,116.75 v1(163.15,116.23)
LPC_LAD1: length 299.4
  TOP w0.102: v2(100.61,153.29) 100.41,153.1 v1(100.41,152.77) ; UH1.C20 25.44,97.78 24.98,97.78 24.76,97.56 23.28,97.56 v1(22.58,96.85)
  IN1 w0.109: v1(211.59,82.28) 210.87,81.56 205.72,81.56 204.92,82.36 201.45,82.36 198.76,85.06 189.66,85.06 186.7,88.01 186.7,91.16 173.06,104.8 170.98,104.8 164.87,110.92 164.87,113.86 163.8,114.93 163.51,114.93 v1(163.47,114.97)
  IN2 w0.127: v1(100.41,152.77) 100.16,153.02 99.29,153.02 97.6,151.33 96.64,151.33 95.59,150.28 95.59,149.32 93.46,147.18 93.46,146.22 87.51,140.27 81.48,140.27 79.35,138.13 79.35,136.9 79.01,136.56 76.26,136.56 71.12,131.42 67.06,131.42 66.67,131.04 62.32,131.04 57.34,126.05 57.34,117.34 52.1,112.1 48.85,112.1 46.74,114.21 44.99,114.21 43.29,112.51 38.05,112.51 37.32,113.24 37.32,113.98 36.92,114.39 36.61,114.39 36.2,114.79 36.2,115.56 36.71,116.07 36.71,121.06 35.31,122.46 33.4,122.46 26.75,115.82 26.75,115.28 25.87,114.39 25.87,112.35 23.94,110.42 23.94,105.01 24.44,104.51 24.44,100.55 23.63,99.73 22.97,99.73 22.34,99.1 22.34,98.33 22.58,98.09 v1(22.58,96.85)
  IN3 w0.127: v1(163.47,114.97) 164.08,115.58 164.08,117.14 153.21,128.01 153.21,136.7 149.78,140.13 147.88,140.13 146.41,141.59 146.41,142.38 143.31,145.49 v1(141.73,145.49) 139.32,145.49 136.66,148.16 120.8,148.16 119.45,149.51 118.33,149.51 115.95,151.89 101.16,151.89 100.41,152.63 v1(100.41,152.77)
  BOTTOM w0.102: v1(141.73,145.49) 141.88,145.64 144.98,145.64 145.75,144.87 145.75,144.02 145.48,143.74 JMINI4.14 ; U46.A26 211.85,82.02 v1(211.59,82.28) ; U39.23 163.14,115.3 v1(163.47,114.97) ; U51.B32 100.75,152.18 100.41,152.51 v1(100.41,152.77)
LPC_LAD2: length 300.6
  TOP w0.102: UH1.A18 23.96,97.06 v1(23.74,96.85) ; v2(99.91,150.23) 99.68,150 v1(99.32,150)
  IN1 w0.109: v1(163.15,113.35) 163.15,111.17 170.23,104.09 172.76,104.09 185.95,90.9 185.95,87.68 189.31,84.33 198.34,84.33 203.4,79.27 210.59,79.27 210.85,79 212.56,79 213.78,80.22 214.16,80.22 214.46,80.53 214.46,81.39 v1(214.64,81.57)
  IN2 w0.127: v1(23.74,96.85) 23.74,97.68 25.26,99.19 25.26,105.14 24.72,105.67 24.72,109.96 27.27,112.51 28,112.51 28.89,113.4 28.89,114.54 29.6,115.25 29.6,117.59 33.69,121.68 34.15,121.68 34.58,121.24 34.58,121.12 35.95,119.75 35.95,116.38 34.5,114.94 34.5,113.57 36.33,111.75 43.61,111.75 45.31,113.45 46.42,113.45 48.99,110.88 53,110.88 54.12,112.01 54.12,113.04 58.24,117.16 58.24,125.87 62.64,130.27 66.99,130.27 67.37,130.66 71.44,130.66 76.58,135.8 80.21,135.8 83.92,139.51 87.83,139.51 91.8,143.48 93.99,143.48 96.15,145.64 96.15,146.11 95.87,146.39 95.87,147.84 97.57,149.54 98.84,149.54 99.3,150 v1(99.32,150)
  IN3 w0.127: v1(99.32,150) 99.83,150 101.21,151.38 115.74,151.38 117.79,149.33 117.79,148.89 118.41,148.27 119.97,148.27 120.59,147.65 136.45,147.65 139.51,144.59 142.55,144.59 v1(142.63,144.66) 143.21,144.66 145.32,142.56 145.32,140.44 147,138.76 150.43,138.76 152.7,136.49 152.7,127.8 159,121.5 161.04,119.47 163.57,116.93 163.57,116.02 162.8,115.25 162.8,113.71 v1(163.15,113.35)
  BOTTOM w0.102: U46.B26 213.61,81.27 213.72,81.16 214.38,81.16 214.64,81.42 v1(214.64,81.57) ; v1(99.32,150) 99.42,149.9 99.75,149.9 100.5,150.64 U51.A31 ; JMINI4.12 143.27,142.94 143.08,142.94 142.4,143.62 142.4,144.44 v1(142.63,144.66) ; U39.20 v1(163.15,113.35)
LPC_LAD3: length 298.8
  TOP w0.102: v2(99.77,151.93) 99.84,152 v1(99.84,152.59) ; v1(23.16,96.85) 23.68,97.37 24.76,97.37 24.98,97.15 25.43,97.15 25.52,97.06 UH1.C18
  IN1 w0.109: v1(164.05,111.85) 164.19,111.85 164.61,111.43 164.61,110.78 170.83,104.57 172.96,104.57 186.44,91.08 186.44,87.94 189.56,84.82 198.62,84.82 201.67,81.77 204.94,81.77 205.38,81.33 213.39,81.33 v1(214.01,80.71)
  IN2 w0.127: v1(23.16,96.85) 23.16,97.87 22.59,98.44 22.59,98.99 23.07,99.48 23.73,99.48 24.7,100.44 24.7,104.73 24.19,105.24 24.19,110.32 26.91,113.04 26.91,114.77 27.09,114.95 27.09,115.79 33.5,122.21 35.21,122.21 36.46,120.96 36.46,116.17 35.95,115.66 35.95,114.68 36.5,114.13 36.81,114.13 37.07,113.88 37.07,113.13 37.94,112.25 43.4,112.25 45.1,113.96 46.63,113.96 48.74,111.85 52.21,111.85 57.59,117.23 57.59,125.94 62.43,130.78 66.78,130.78 67.16,131.17 71.23,131.17 76.37,136.31 79.12,136.31 79.6,136.79 79.6,137.6 80.63,138.63 81.23,138.63 82.61,140.02 87.61,140.02 91.89,144.3 92.79,144.3 94.42,145.92 94.42,147.79 95.84,149.21 95.84,150.17 96.75,151.08 97.71,151.08 99.22,152.59 v1(99.84,152.59)
  IN3 w0.127: v1(164.05,111.85) 163.99,111.91 163.99,113.33 163.05,114.27 163.05,115.14 163.83,115.92 163.83,117.04 161.22,119.65 152.95,127.91 152.95,136.59 149.82,139.72 147.93,139.72 146.16,141.49 146.16,142.28 143.32,145.12 142.22,145.12 v1(142.15,145.04) 139.41,145.04 136.55,147.9 120.7,147.9 119.34,149.26 118.23,149.26 115.85,151.64 100.79,151.64 v1(99.84,152.59)
  BOTTOM w0.102: v1(99.84,152.59) 99.84,152.58 100.25,152.17 U51.B33 ; v1(164.05,111.85) 163.61,111.4 U39.17 ; v1(142.15,145.04) 142.15,143.29 143.3,142.14 JMINI4.10 ; U46.B25 213.95,80.77 v1(214.01,80.71)
LPC_LDRQ0#: length 1.8
  BOTTOM w0.102: T136.1 211.3,80.44 211.57,80.71 211.97,80.71 212.15,80.52 U46.A23
LPC_LDRQ1#: length 215
  TOP w0.102: UH1.G20 27.16,97.73 v1(26.75,97.32)
  IN2 w0.127: v1(26.75,97.32) 27.29,96.78 29.32,96.78 29.73,96.38 29.73,91.89 30.02,91.6 30.79,91.6 32.1,90.28 37.26,90.28 38.67,88.87 40.44,88.87 40.9,89.33 42.82,89.33 43.07,89.08 43.63,89.08 44.46,89.9 44.46,92.11 46.18,93.84 56.09,93.84 58.45,96.2 64.96,96.2 66.14,97.38 67.54,97.38 74.64,104.48 80.56,104.48 81.26,105.18 115.35,105.18 115.56,104.96 130.1,104.96 131.07,105.93 142.07,105.93 143.69,104.3 183.27,104.3 188.25,99.32 195.19,99.32 197.85,96.67 199.61,96.67 208.82,87.46 208.82,83.75 211.77,80.81 v1(211.77,80.3)
  BOTTOM w0.089: v1(26.75,97.32) 26.75,97.44 26.48,97.7 v2(26.48,97.77)
  BOTTOM w0.102: U46.A22 212.04,80.02 v1(211.77,80.3)
LPC_LFRAME#: length 296.4
  TOP w0.102: UH1.B21 25.03,98.36 24.67,98.36 24.39,98.08 23.76,98.08 23.02,98.81 v1(23.02,98.82) ; v1(101,152.64) 101,152.25 v2(101.27,151.98)
  IN1 w0.109: v1(211.72,79.44) 210.97,80.19 205.93,80.19 204.65,81.47 201.56,81.47 198.46,84.57 189.48,84.57 186.2,87.84 186.2,90.99 172.86,104.33 170.33,104.33 163.56,111.1 163.56,112.35 163.58,112.38 163.58,114.22 163.72,114.36 v1(163.72,114.37)
  IN2 w0.127: v1(23.02,98.82) 23.25,98.59 24.29,98.59 25,99.3 25,104.94 24.47,105.47 24.47,110.07 27.17,112.76 27.26,112.76 27.9,113.4 27.9,114.36 27.64,114.62 27.64,115.99 33.61,121.96 35.1,121.96 36.2,120.85 36.2,116.28 35.57,115.64 35.57,113.52 37.09,112 43.5,112 45.2,113.7 46.53,113.7 49.09,111.14 52.89,111.14 53.87,112.11 53.87,113.15 57.84,117.12 57.84,125.84 62.54,130.53 66.88,130.53 67.27,130.91 71.33,130.91 76.47,136.05 80.1,136.05 83.81,139.76 87.72,139.76 92,144.04 92.91,144.04 94.67,145.81 94.67,147 97.46,149.79 98.15,149.79 98.64,150.28 98.64,151.06 99.12,151.55 99.91,151.55 v1(101,152.64)
  IN3 w0.127: v1(163.72,114.37) 164.33,114.98 164.33,117.25 153.46,128.12 153.46,136.8 149.68,140.59 v1(148.27,140.59) 148.27,142 144.09,146.17 139,146.17 136.76,148.41 120.91,148.41 118.74,150.58 118.31,150.58 116.75,152.14 101.49,152.14 v1(101,152.64)
  BOTTOM w0.102: v1(211.72,79.44) 211.81,79.52 U46.A21 ; JMINI4.8 146.25,141.34 147.01,140.59 v1(148.27,140.59) ; U39.22 163.14,114.65 163.42,114.37 v1(163.72,114.37) ; U51.B31 101.25,152.39 v1(101,152.64)
LX_CHG: length 17.9
  IN3 w0.762: v3(182.91,47.53) 183.3,47.53 188.5,52.74 v3(195.49,52.74)
  BOTTOM w0.254: PU700.19 180.67,48 v2(181.14,47.53) PC734.1
  BOTTOM w0.508: v3(182.91,47.53) PC734.1
M_CLK_DDR0: length 53.8
  TOP w0.102: JCPU1.V4 103.59,57.16 104,56.75 v1(104.12,56.75)
  IN1 w0.089: v1(104.12,56.75) 104.12,56.3 104.19,56.23 104.46,56.23 104.53,56.3 104.53,58 104.89,58.35 107.28,58.35 107.62,58.7 108.79,58.7 109.39,58.1 109.78,58.1 109.8,58.12 109.87,58.12 109.88,58.13 109.89,58.13
  IN1 w0.109: 109.89,58.13 120.66,58.13 120.94,58.41 135.95,58.41 136.52,58.97 144.73,58.97 145,58.71 145,57.67 145.12,57.54 145.52,57.54 145.63,57.65 145.63,58.6 145.89,58.86 146.37,58.86 146.63,58.6 146.63,57.65 146.77,57.52 147.34,57.52 147.53,57.71 147.53,57.9 v1(147.18,58.25)
  BOTTOM w0.102: v1(147.18,58.25) 147.43,58 147.43,57.87 147.35,57.8 147.02,57.8 146.67,58.15 JDIMM2.101
M_CLK_DDR1: length 52.6
  TOP w0.102: v1(105.12,56.75) JCPU1.V3
  IN1 w0.089: v1(105.12,56.75) 105.12,56.56 105.27,56.4 105.43,56.4 105.54,56.51 105.54,57.15 105.72,57.34 106.26,57.34 106.5,57.58 106.5,57.77 106.69,57.97 107.44,57.97 107.74,58.27 108.35,58.27 108.56,58.06 108.56,57.62 108.41,57.48 108.41,57.29 108.49,57.21 109.39,57.21 109.65,57.47 109.87,57.47 109.89,57.49 109.9,57.49
  IN1 w0.109: 109.9,57.49 120.93,57.49 121.21,57.77 128.09,57.77 128.33,57.52 128.33,57.37 128.44,57.26 128.77,57.26 128.88,57.37 128.88,57.52 129.12,57.77 129.64,57.77 129.88,57.52 129.88,57.37 129.99,57.26 130.32,57.26 130.43,57.37 130.43,57.52 130.67,57.77 131.19,57.77 131.43,57.52 131.43,57.37 131.54,57.26 131.87,57.26 131.98,57.37 131.98,57.52 132.22,57.77 132.74,57.77 132.98,57.52 132.98,57.37 133.09,57.26 133.86,57.26 133.95,57.35 133.95,57.56 134.15,57.77 136.25,57.77 136.36,57.87 137.25,57.87 137.34,57.96 137.34,58.09 137.59,58.33 138.1,58.33 138.35,58.09 138.35,57.96 138.43,57.87 138.8,57.87 138.91,57.98 138.91,58.11 139.12,58.33 143.21,58.33 143.42,58.13 143.42,57.85 v1(143.59,57.67)
  BOTTOM w0.102: v1(143.59,57.67) 143.43,57.83 143.43,58.08 143.05,58.46 139.66,58.46 138.88,57.67 138.77,57.67 138.59,57.85 JDIMM2.102
M_CLK_DDR2: length 70.6
  TOP w0.102: JCPU1.AA4 v1(104.12,59.75)
  IN3 w0.089: v1(104.12,59.75) 104.12,59.33 104.21,59.24 104.31,59.24 104.54,59.47 104.54,59.99 104.92,60.36 107.88,60.36 109.71,58.53 109.89,58.53
  IN3 w0.102: 109.89,58.53 132.61,58.53 133.24,59.16 144.4,59.16 145.44,60.2 150.74,60.2 151.44,59.49 159.21,59.49 159.31,59.59 159.31,61.28 159.57,61.54 160.1,61.54 160.36,61.28 160.36,58.52 160.78,58.1 161.57,58.1 161.66,58.18 161.66,58.71 v1(161.37,58.99)
  BOTTOM w0.102: JDIMM4.101 160.35,58.16 160.44,58.07 160.44,57.89 160.55,57.79 161.09,57.79 161.73,58.43 161.73,58.63 v1(161.37,58.99)
M_CLK_DDR3: length 69.6
  TOP w0.102: v1(105.12,59.75) JCPU1.AA3
  IN3 w0.089: v1(105.12,59.75) 105.12,59.3 105.19,59.23 105.53,59.23 105.7,59.06 105.7,58.58 105.93,58.35 106.38,58.35 106.92,57.82 107.83,57.82 109.07,56.59 109.81,56.59 109.82,56.59 109.89,56.59
  IN3 w0.102: v1(155.89,58.23) 156.08,58.23 156.31,58 156.31,57.77 156.52,57.55 159.21,57.55 159.34,57.43 159.34,57.12 159.21,56.99 155.79,56.99 155.65,57.13 155.65,57.57 155.42,57.81 154.93,57.81 154.69,57.57 154.69,57.19 154.59,57.09 152.32,57.09 151.81,57.6 150.45,57.6 150.1,57.95 148.93,57.95 148.83,57.85 147.56,57.85 146.31,56.59 139.16,56.59 138.45,55.89 131.6,55.89 130.89,56.59 109.89,56.59
  BOTTOM w0.102: v1(155.89,58.23) 156.12,58.23 156.26,58.09 156.26,57.86 156.07,57.67 152.4,57.67 152.22,57.86 JDIMM4.102
M_CLK_DDR4: length 51.2
  TOP w0.102: JDIMM1.101 138.51,58.15 138.7,57.97 139.07,57.97 139.28,57.76 139.28,57.26 139.73,56.81 139.87,56.81 140.01,56.94 140.44,56.94 140.58,56.81 140.81,56.81 141.02,57.01 141.02,57.13 140.9,57.24 140.9,57.53 140.76,57.67 v1(140.55,57.67) ; JCPU1.V2 v1(106.12,56.75)
  IN1 w0.089: v1(106.12,56.75) 106.12,56.3 106.19,56.23 106.42,56.23 106.53,56.35 106.53,57.07 107.03,57.57 107.57,57.57 107.81,57.33 107.81,56.88 107.88,56.81 109.85,56.81 109.88,56.84 109.89,56.84
  IN1 w0.109: 109.89,56.84 115.06,56.84 115.06,56.84 121.67,56.84 121.95,57.12 122.47,57.12 122.71,56.88 122.71,56.05 122.84,55.92 123.13,55.92 123.26,56.05 123.26,56.88 123.5,57.12 124.02,57.12 124.26,56.88 124.26,55.94 124.39,55.81 124.68,55.81 124.81,55.94 124.81,56.88 125.05,57.12 125.57,57.12 125.81,56.88 125.81,55.94 125.94,55.81 126.23,55.81 126.36,55.94 126.36,56.88 126.6,57.12 127.12,57.12 127.36,56.88 127.36,56.38 127.48,56.26 127.59,56.26 127.94,56.62 134.13,56.62 134.64,57.12 136.52,57.12 136.62,57.22 140.76,57.22 140.91,57.37 140.91,57.55 140.8,57.67 v1(140.55,57.67)
M_CLK_DDR5: length 50.2
  TOP w0.102: v1(149.06,57.24) 148.88,57.06 148.27,57.06 147.68,57.64 146.92,57.64 146.71,57.85 JDIMM1.102 ; JCPU1.V1 v1(107.12,56.75)
  IN1 w0.089: v1(107.12,56.75) 107.52,56.35 107.95,56.35 108.11,56.19 109.87,56.19 109.88,56.2 109.89,56.2
  IN1 w0.109: 109.89,56.2 121.29,56.2 121.57,55.92 121.57,55.6 121.7,55.48 122.38,55.48 122.68,55.17 127.41,55.17 128.21,55.97 134.46,55.97 134.96,56.48 136.78,56.48 136.88,56.58 141.05,56.58 141.38,56.9 145.66,56.9 145.88,56.68 145.88,56.18 146.01,56.06 146.3,56.06 146.43,56.18 146.43,56.61 146.69,56.87 147.44,56.87 147.67,56.64 147.67,56.39 147.8,56.26 148.18,56.26 148.31,56.39 148.31,56.86 148.54,57.08 148.9,57.08 v1(149.06,57.24)
M_CLK_DDR6: length 68.4
  TOP w0.102: JDIMM3.101 152.02,58.16 152.39,57.79 152.8,57.79 153.1,57.49 153.1,57.28 153.18,57.2 154.22,57.2 154.34,57.32 154.34,57.46 153.98,57.82 153.98,58.08 153.83,58.23 v1(153.6,58.23) ; JCPU1.AA2 v1(106.12,59.75)
  IN3 w0.089: v1(106.12,59.75) 106.12,59.37 106.19,59.29 106.51,59.29 106.72,59.09 106.72,58.61 106.97,58.35 108.01,58.35 109.11,57.25 109.87,57.25 109.87,57.26 109.89,57.26
  IN3 w0.102: 109.89,57.26 131.63,57.26 131.86,57.03 131.86,56.7 131.96,56.6 132.27,56.6 132.37,56.7 132.37,57.03 132.6,57.26 133.22,57.26 133.44,57.04 133.44,56.65 133.57,56.52 133.86,56.52 133.98,56.65 133.98,57.66 134.22,57.9 134.71,57.9 134.94,57.66 134.94,56.65 135.07,56.52 135.32,56.52 135.45,56.65 135.45,57.66 135.68,57.9 136.18,57.9 136.41,57.66 136.41,56.65 136.54,56.52 136.79,56.52 136.92,56.65 136.92,57.66 137.15,57.9 137.64,57.9 137.88,57.66 137.88,56.68 138.01,56.55 138.23,56.55 138.35,56.68 138.35,57.64 138.59,57.87 139.08,57.87 139.31,57.64 139.31,57.36 139.41,57.26 144.53,57.26 145.21,57.94 145.54,57.94 145.9,57.57 146.08,57.57 146.26,57.75 146.26,57.93 145.9,58.29 145.9,58.63 146.21,58.93 150.05,58.93 150.76,58.23 152.07,58.23 152.58,57.72 153.82,57.72 153.97,57.87 153.97,58.13 153.87,58.23 v1(153.6,58.23)
M_CLK_DDR7: length 67.3
  TOP w0.102: JDIMM3.102 160.61,57.86 160.61,57.86 160.8,57.86 161.48,57.19 v1(161.48,55.89) ; JCPU1.AA1 v1(107.12,59.75)
  IN3 w0.089: v1(107.12,59.75) 107.47,59.4 107.9,59.4 109.43,57.87 109.85,57.87 109.88,57.89 109.89,57.89
  IN3 w0.102: 109.89,57.89 132.87,57.89 133.5,58.53 144.66,58.53 145.7,59.57 150.48,59.57 151.18,58.86 153.88,58.86 153.88,58.86 159.12,58.86 160.51,57.47 162.39,57.47 162.44,57.52 162.44,57.76 162.7,58.02 163.19,58.02 163.44,57.76 163.44,56.72 163.19,56.46 161.55,56.46 161.43,56.34 161.43,55.94 v1(161.48,55.89)
M_CLK_DDR#0: length 53.9
  TOP w0.102: JCPU1.U4 v1(104.12,55.75)
  IN1 w0.089: v1(104.12,55.75) 104.12,55.95 104.19,56.03 104.55,56.03 104.74,56.21 104.74,57.91 104.97,58.15 107.36,58.15 107.71,58.49 108.71,58.49 109.31,57.89 109.87,57.89 109.87,57.9 109.89,57.9
  IN1 w0.109: 109.89,57.9 120.76,57.9 121.04,58.18 136.05,58.18 136.61,58.74 144.64,58.74 144.77,58.62 144.77,57.58 145.03,57.31 145.62,57.31 145.86,57.56 145.86,58.51 145.99,58.63 146.28,58.63 146.41,58.51 146.41,57.56 146.67,57.29 147.43,57.29 147.76,57.62 v1(147.76,58.25)
  BOTTOM w0.102: v1(147.76,58.25) 147.66,58.15 147.66,57.81 147.44,57.59 146.74,57.59 146.7,57.55 JDIMM2.103
M_CLK_DDR#1: length 52.6
  TOP w0.102: v1(105.03,55.74) 104.89,55.74 104.59,56.05 JCPU1.U3
  IN1 w0.089: v1(105.03,55.74) 105.03,56.07 105.16,56.2 105.52,56.2 105.75,56.42 105.75,57.07 105.81,57.13 106.34,57.13 106.71,57.49 106.71,57.68 106.78,57.76 107.53,57.76 107.83,58.06 108.27,58.06 108.35,57.98 108.35,57.7 108.21,57.56 108.21,57.2 108.41,57 109.48,57 109.73,57.26 109.95,57.26
  IN1 w0.109: v1(142.83,57.67) 143.09,57.67 143.19,57.77 143.19,58.03 143.12,58.1 139.22,58.1 139.14,58.02 139.14,57.89 138.89,57.64 138.34,57.64 138.12,57.86 138.12,57.99 138.01,58.1 137.68,58.1 137.57,57.99 137.57,57.87 137.35,57.64 136.46,57.64 136.35,57.54 134.25,57.54 134.18,57.47 134.18,57.25 133.96,57.03 133,57.03 132.75,57.27 132.75,57.43 132.64,57.54 132.32,57.54 132.21,57.43 132.21,57.27 131.96,57.03 131.45,57.03 131.2,57.27 131.2,57.43 131.09,57.54 130.77,57.54 130.66,57.43 130.66,57.27 130.41,57.03 129.9,57.03 129.65,57.27 129.65,57.43 129.54,57.54 129.22,57.54 129.11,57.43 129.11,57.27 128.86,57.03 128.35,57.03 128.1,57.27 128.1,57.43 128,57.54 121.3,57.54 121.02,57.26 109.96,57.26 109.95,57.26
  BOTTOM w0.102: v1(142.83,57.67) 143.07,57.67 143.2,57.8 143.2,57.98 142.95,58.23 139.76,58.23 138.97,57.44 138.69,57.44 138.5,57.25 JDIMM2.104
M_CLK_DDR#2: length 70.7
  TOP w0.102: JCPU1.Y4 v1(104.12,58.75)
  IN3 w0.089: 109.89,58.3 109.88,58.3 109.85,58.33 109.81,58.33 109.8,58.34 109.63,58.34 107.8,60.17 105,60.17 104.73,59.91 104.73,59.4 104.39,59.05 104.24,59.05 104.12,58.94 v1(104.12,58.75)
  IN3 w0.102: 109.89,58.3 132.7,58.3 133.33,58.93 144.5,58.93 145.53,59.97 150.65,59.97 151.35,59.27 159.3,59.27 159.53,59.5 159.53,61.19 159.66,61.31 160.01,61.31 160.13,61.19 160.13,58.42 160.68,57.87 161.67,57.87 161.88,58.09 161.88,58.8 161.88,58.8 161.88,58.91 v1(161.96,58.99)
  BOTTOM w0.102: JDIMM4.103 161.18,57.56 161.96,58.34 v1(161.96,58.99)
M_CLK_DDR#3: length 69.6
  TOP w0.102: JCPU1.Y3 104.59,59.26 v1(105.11,58.74)
  IN3 w0.089: v1(105.11,58.74) 105.11,58.81 105.34,59.04 105.45,59.04 105.51,58.98 105.51,58.47 105.84,58.14 106.3,58.14 106.83,57.61 107.74,57.61 108.98,56.37 109.55,56.37 109.56,56.37 109.89,56.37
  IN3 w0.102: 109.89,56.37 130.8,56.37 131.51,55.66 138.55,55.66 139.25,56.37 146.4,56.37 147.65,57.62 148.92,57.62 149.02,57.72 150,57.72 150.36,57.37 151.72,57.37 152.23,56.86 154.68,56.86 154.92,57.1 154.92,57.48 155.02,57.58 155.32,57.58 155.43,57.48 155.43,57.04 155.7,56.77 159.31,56.77 159.56,57.03 159.56,57.52 159.31,57.78 156.62,57.78 156.54,57.86 156.54,58.11 v1(156.65,58.23)
  BOTTOM w0.102: v1(156.65,58.23) 156.49,58.06 156.49,57.76 156.17,57.45 152.38,57.45 152.2,57.26 JDIMM4.104
M_CLK_DDR#4: length 51.2
  TOP w0.102: JCPU1.U2 v1(106.12,55.75) ; JDIMM1.103 138.53,57.55 138.71,57.74 138.97,57.74 139.05,57.66 139.05,57.17 139.64,56.58 139.96,56.58 140.1,56.72 140.34,56.72 140.48,56.58 140.9,56.58 141.25,56.92 141.25,57.22 141.13,57.34 141.13,57.49 v1(141.31,57.67)
  IN1 w0.089: 109.89,56.61 109.87,56.61 109.87,56.6 107.79,56.6 107.6,56.8 107.6,57.24 107.48,57.36 107.12,57.36 106.74,56.98 106.74,56.26 106.51,56.03 106.29,56.03 106.12,55.86 v1(106.12,55.75)
  IN1 w0.109: 109.89,56.61 115.15,56.61 115.15,56.62 121.77,56.62 122.05,56.89 122.37,56.89 122.48,56.78 122.48,55.95 122.74,55.69 123.23,55.69 123.49,55.95 123.49,56.78 123.6,56.89 123.92,56.89 124.03,56.78 124.03,55.85 124.29,55.58 124.78,55.58 125.04,55.85 125.04,56.78 125.15,56.89 125.47,56.89 125.58,56.78 125.58,55.85 125.84,55.58 126.32,55.58 126.59,55.85 126.59,56.78 126.69,56.89 127.02,56.89 127.13,56.78 127.13,56.29 127.39,56.03 127.68,56.03 128.04,56.39 134.22,56.39 134.73,56.89 136.62,56.89 136.71,56.99 140.86,56.99 141.14,57.27 141.14,57.5 v1(141.31,57.67)
M_CLK_DDR#5: length 50.2
  TOP w0.102: v1(149.06,56.65) 148.88,56.83 148.17,56.83 147.59,57.41 146.93,57.41 146.77,57.25 JDIMM1.104 ; JCPU1.U1 v1(107.12,55.75)
  IN1 w0.089: 109.89,55.97 109.87,55.97 109.86,55.98 108.02,55.98 107.86,56.14 107.52,56.14 v1(107.12,55.75)
  IN1 w0.109: 109.89,55.97 121.2,55.97 121.34,55.82 121.34,55.51 121.61,55.25 122.28,55.25 122.59,54.94 127.5,54.94 128.3,55.74 134.55,55.74 135.06,56.25 136.88,56.25 136.98,56.35 141.15,56.35 141.47,56.67 145.57,56.67 145.66,56.58 145.66,56.09 145.92,55.83 146.4,55.83 146.66,56.09 146.66,56.52 146.79,56.65 147.34,56.65 147.44,56.55 147.44,56.3 147.7,56.04 148.27,56.04 148.54,56.3 148.54,56.76 148.63,56.86 148.85,56.86 v1(149.06,56.65)
M_CLK_DDR#6: length 68.4
  TOP w0.102: JDIMM3.103 152.7,57.56 152.87,57.39 152.87,57.18 153.08,56.97 154.31,56.97 154.57,57.22 154.57,57.55 154.21,57.91 154.21,58.08 v1(154.36,58.23) ; JCPU1.Y2 v1(106.12,58.75)
  IN3 w0.089: v1(106.12,58.75) 106.12,58.96 106.27,59.1 106.43,59.1 106.53,59.01 106.53,58.49 106.88,58.14 107.92,58.14 109.02,57.04 109.82,57.04 109.83,57.03 109.89,57.03
  IN3 w0.102: v1(154.36,58.23) 154.2,58.06 154.2,57.78 153.91,57.49 152.49,57.49 151.98,58 150.66,58 149.96,58.71 146.3,58.71 146.12,58.53 146.12,58.39 146.48,58.03 146.48,57.66 146.17,57.35 145.81,57.35 145.44,57.71 145.3,57.71 144.63,57.04 139.32,57.04 139.09,57.27 139.09,57.54 138.99,57.65 138.68,57.65 138.58,57.54 138.58,56.59 138.32,56.33 137.91,56.33 137.65,56.59 137.65,57.57 137.55,57.67 137.25,57.67 137.14,57.57 137.14,56.55 136.89,56.29 136.44,56.29 136.18,56.55 136.18,57.57 136.08,57.67 135.78,57.67 135.68,57.57 135.68,56.55 135.42,56.29 134.98,56.29 134.72,56.55 134.72,57.57 134.61,57.67 134.31,57.67 134.21,57.57 134.21,56.55 133.95,56.29 133.48,56.29 133.22,56.55 133.22,56.94 133.13,57.03 132.7,57.03 132.6,56.93 132.6,56.61 132.36,56.37 131.87,56.37 131.64,56.61 131.64,56.93 131.54,57.03 109.89,57.03
M_CLK_DDR#7: length 67.2
  TOP w0.102: JDIMM3.104 160.41,57.26 160.52,57.37 160.52,57.57 160.58,57.63 160.71,57.63 161.25,57.09 161.25,56.25 v1(160.89,55.89) ; JCPU1.Y1 v1(107.12,58.75)
  IN3 w0.089: v1(107.12,58.75) 107.12,59.05 107.27,59.21 107.82,59.21 109.35,57.68 109.82,57.68 109.83,57.67 109.89,57.67
  IN3 w0.102: v1(160.89,55.89) 161.2,56.2 161.2,56.43 161.46,56.69 163.09,56.69 163.22,56.82 163.22,57.67 163.09,57.8 162.79,57.8 162.67,57.67 162.67,57.42 162.48,57.24 160.42,57.24 159.03,58.64 153.88,58.64 153.88,58.63 151.09,58.63 150.38,59.34 145.8,59.34 144.76,58.3 133.6,58.3 132.96,57.67 109.89,57.67
M_ID2#: length 7.5
  TOP w0.102: C15.1 v2(81.87,167.3) 81.87,169.57 JCRT1.4
M_ODT0: length 58.5
  TOP w0.102: JCPU1.M8 v1(100.12,50.75)
  IN1 w0.089: v1(100.12,50.75) 100.12,51.01 100,51.14 99.79,51.14 99.69,51.04 99.69,50.48 99.82,50.35 101.42,50.35 101.51,50.44 101.51,51.24 101.64,51.37 107.56,51.37
  IN1 w0.178: 107.56,51.37 107.92,51.74 108.24,51.74 108.4,51.57 108.4,51.31 108.16,51.06 108.16,50.74 108.45,50.44 108.82,50.44 108.95,50.57 108.95,51.2 109.08,51.33 109.38,51.33 109.51,51.2 109.51,50.8 109.64,50.68 111.56,50.68 113.86,48.38 114.19,48.38 114.37,48.2 114.37,47.87 114.5,47.74 114.95,47.74 115.08,47.87 115.08,48.25 115.21,48.38 115.67,48.38 115.79,48.25 115.79,47.86 115.92,47.73 116.38,47.73 116.5,47.86 116.5,48.25 116.63,48.38 117.09,48.38 117.21,48.25 117.21,47.86 117.34,47.73 117.8,47.73 117.93,47.86 117.93,48.2 118.1,48.38 125.02,48.38 125.22,48.58 125.22,48.96 125.48,49.22 125.98,49.22 126.11,49.1 126.11,48.51 126.23,48.38 128.19,48.38 128.32,48.51 128.32,49.1 128.44,49.22 129.74,49.22 129.92,49.4 129.92,49.64 130.1,49.82 130.45,49.82 130.63,49.64 130.63,49.11 130.9,48.84 131.28,48.84 131.57,49.13 131.57,49.32 131.13,49.75 131.13,49.93 131.46,50.25 131.63,50.25 132.1,49.79 132.23,49.79 133.07,50.62 133.27,50.62 133.43,50.46 133.43,50.35 133.56,50.23 134.06,50.23 134.18,50.35 134.18,50.46 134.31,50.58 135.18,50.58 135.7,51.1 v1(135.7,51.12)
  BOTTOM w0.102: JDIMM2.116 136.31,53.65 136.18,53.52 136.18,53.2 136.05,53.07 135.34,53.07 135.23,52.95 135.23,52.78 135.34,52.66 136.08,52.66 136.2,52.54 136.2,52.37 136.08,52.26 135.27,52.26 135.15,52.14 135.15,51.97 135.27,51.85 135.57,51.85 135.7,51.72 v1(135.7,51.12)
M_ODT1: length 58.8
  TOP w0.102: JCPU1.L7 101.1,50.28 101.23,50.15 101.23,49.86 v1(101.12,49.75)
  IN1 w0.089: 109.89,49.61 108.41,49.61 107.65,50.37 101.95,50.37 101.33,49.75 v1(101.12,49.75)
  IN1 w0.178: 109.89,49.61 111.12,49.61 114.06,46.67 118.5,46.67 119.14,47.31 129.2,47.31 129.66,47.78 131.73,47.78 133.11,49.16 135.27,49.16 136.89,50.79 142.25,50.79 143.35,51.89 144.93,51.89 145.06,52.02 145.06,52.52 144.93,52.64 143.19,52.64 142,51.45 v1(141.04,51.45)
  BOTTOM w0.102: JDIMM2.120 138.68,52.45 139.07,52.06 141.19,52.06 141.32,51.93 141.32,51.57 141.19,51.45 v1(141.04,51.45)
M_ODT2: length 70.7
  TOP w0.102: JCPU1.R4 103.59,54.28 v1(104.12,53.75)
  IN3 w0.089: v1(104.12,53.75) 104.52,53.75 104.92,53.35 105.65,53.35 105.84,53.16 106.28,53.16 106.49,52.95 106.49,52.44 106.73,52.19 107.59,52.19 109.64,50.15 109.89,50.15
  IN3 w0.152: 109.89,50.15 112.27,50.15 117.78,44.65 127.93,44.65 128.09,44.8 128.09,45.75 128.21,45.87 128.57,45.87 128.7,45.75 128.7,44.8 128.85,44.65 129.15,44.65 129.31,44.8 129.31,45.25 129.43,45.38 129.79,45.38 129.92,45.25 129.92,44.8 130.07,44.65 130.37,44.65 130.53,44.8 130.53,45.25 130.65,45.38 130.98,45.38 131.13,45.22 131.13,44.85 131.28,44.7 131.59,44.7 131.74,44.85 131.74,45.22 131.89,45.38 132.2,45.38 132.35,45.22 132.35,44.85 132.5,44.7 133.31,44.7 133.44,44.83 133.44,45.32 133.31,45.45 133.13,45.45 132.96,45.62 132.96,45.83 133.35,46.23 133.6,46.23 133.75,46.07 133.75,45.79 133.9,45.64 134.21,45.64 134.36,45.79 134.36,46.07 134.51,46.23 140.56,46.23 140.63,46.29 144.12,46.29 147.42,49.6 151.81,49.6 152.05,49.83 154.03,49.83 v1(154.46,50.27)
  BOTTOM w0.102: JDIMM4.116 152.1,53.66 152.66,53.1 152.66,51.27 153.22,50.71 154.01,50.71 v1(154.46,50.27)
M_ODT3: length 71
  TOP w0.102: v1(105.12,53.75) JCPU1.R3
  IN3 w0.089: v1(105.12,53.75) 105.16,53.71 105.6,53.71 105.88,53.43 105.88,53.4 105.93,53.35 106.43,53.35 106.66,53.12 106.66,52.63 106.92,52.37 107.84,52.37 109.61,50.61 109.89,50.61
  IN3 w0.152: 109.89,50.61 112.46,50.61 117.97,45.1 120.13,45.1 120.28,45.26 120.28,45.75 120.41,45.88 120.76,45.88 120.89,45.75 120.89,45.26 121.04,45.1 121.35,45.1 121.5,45.26 121.5,46.2 121.63,46.33 121.98,46.33 122.11,46.2 122.11,45.26 122.26,45.1 122.57,45.1 122.72,45.26 122.72,46.2 122.85,46.33 123.2,46.33 123.33,46.2 123.33,45.26 123.48,45.1 123.79,45.1 123.94,45.26 123.94,46.2 124.07,46.33 124.42,46.33 124.55,46.2 124.55,45.26 124.7,45.1 125.01,45.1 125.16,45.26 125.16,46.2 125.28,46.33 125.64,46.33 125.77,46.2 125.77,45.26 125.92,45.1 126.22,45.1 126.38,45.26 126.38,46.2 126.5,46.33 126.86,46.33 126.99,46.2 126.99,45.26 127.14,45.1 127.44,45.1 127.6,45.26 127.6,46.2 127.72,46.33 129.3,46.33 129.8,45.83 132.31,45.83 133.16,46.68 140.02,46.68 140.08,46.75 143.93,46.75 147.23,50.05 151.62,50.05 151.97,50.4 152.8,50.4 v1(152.93,50.27)
  BOTTOM w0.102: v1(152.93,50.27) 152.38,50.82 152.38,52.18 152.11,52.46 JDIMM4.120
M_ODT4: length 57.9
  TOP w0.102: JCPU1.L8 v1(100.12,49.75) ; JDIMM1.116 144.96,53.65 142.67,51.36 v1(142.67,49.72)
  IN1 w0.089: 108.62,49.08 108.26,49.43 108.26,49.51 107.58,50.19 102.02,50.19 101.61,49.78 101.61,49.7 101.25,49.35 100.52,49.35 v1(100.12,49.75)
  IN1 w0.178: v1(142.67,49.72) 142.81,49.72 143.35,50.26 144.56,50.26 144.69,50.39 144.69,50.67 144.56,50.8 143.02,50.8 142.47,50.25 137.12,50.25 135.49,48.63 133.33,48.63 131.95,47.24 129.88,47.24 129.42,46.78 119.37,46.78 118.72,46.13 113.84,46.13 110.9,49.08 108.62,49.08
M_ODT5: length 59.4
  TOP w0.102: JCPU1.L10 v1(98.12,49.75) ; JDIMM1.120 144.62,52.45 143.82,51.66 143.82,50.09 v1(144.2,49.72)
  IN1 w0.089: v1(98.12,49.75) 98.36,49.51 98.36,49.24 98.66,48.93 98.66,48.59 98.88,48.37 99.6,48.37 99.78,48.19 102.35,48.19 102.53,48.37 105.38,48.37 105.44,48.44 106.83,48.44 106.89,48.37 106.99,48.37 107.17,48.19 108.16,48.19 108.62,47.74
  IN1 w0.178: 108.62,47.74 108.88,47.48 110.23,47.48 113.18,44.53 130.59,44.53 131.24,45.18 132.15,45.18 133.64,46.67 135.8,46.67 137.74,48.62 142.18,48.62 142.35,48.79 142.35,49.01 142.53,49.18 142.89,49.18 143.07,49.01 143.07,48.79 143.24,48.62 145.13,48.62 145.26,48.74 145.26,49.59 145.13,49.72 v1(144.2,49.72)
M_ODT6: length 68.6
  TOP w0.089: JCPU1.R1 v1(107.12,53.75)
  TOP w0.102: JDIMM3.116 158.42,53.66 158.14,53.38 155.82,52.35 153.64,52.35 v1(153.1,51.81)
  IN3 w0.089: 109.89,51.98 109.53,51.98 107.77,53.75 v1(107.12,53.75)
  IN3 w0.152: v1(153.1,51.81) 150.85,51.81 150.47,51.43 146.52,51.43 144.37,49.27 143.42,49.27 143.26,49.12 143.26,48.86 143.14,48.73 142.78,48.73 142.65,48.86 142.65,49.19 142.53,49.31 142.18,49.31 142.06,49.19 142.06,48.86 141.93,48.73 141.57,48.73 141.45,48.86 141.45,49.16 141.32,49.29 140.96,49.29 140.84,49.16 140.84,48.86 140.71,48.73 140.35,48.73 140.23,48.86 140.23,49.12 140.07,49.27 139.77,49.27 139.62,49.12 139.62,48.89 139.46,48.73 135.63,48.73 135.19,49.17 133.6,49.17 133.56,49.21 132.96,49.21 132.81,49.06 132.81,48.7 132.66,48.55 132.36,48.55 132.2,48.7 132.2,49.06 132.05,49.21 131.75,49.21 131.59,49.06 131.59,48.7 131.44,48.55 131.14,48.55 130.98,48.7 130.98,49.06 130.83,49.21 128.46,49.21 128.33,49.08 128.33,47.83 128.2,47.7 127.83,47.7 127.68,47.85 127.68,49.08 127.55,49.21 127.2,49.21 127.07,49.08 127.07,47.85 126.92,47.7 126.61,47.7 126.46,47.85 126.46,48.36 126.33,48.48 125.98,48.48 125.85,48.36 125.85,47.85 125.7,47.7 125.39,47.7 125.24,47.85 125.24,48.4 125.11,48.52 124.76,48.52 124.63,48.4 124.63,47.85 124.48,47.7 117.31,47.7 113.03,51.98 109.89,51.98
M_ODT7: length 69.7
  TOP w0.102: JDIMM3.120 158.36,52.46 158.17,52.27 158.17,51.06 157.38,50.27 v1(155.98,50.27) ; v1(106.11,52.75) 105.59,53.27 JCPU1.P2
  IN3 w0.089: v1(106.11,52.75) 105.7,52.34 105.7,51.64 105.97,51.37 108.08,51.37 109.76,49.69 109.89,49.69
  IN3 w0.152: v1(155.98,50.27) 158.29,50.27 158.42,50.14 158.42,49.5 158.29,49.38 152.24,49.38 152,49.14 147.61,49.14 143.89,45.42 139.43,45.42 139.28,45.57 139.28,45.64 139.15,45.77 138.79,45.77 138.67,45.64 138.67,45.57 138.51,45.42 138.21,45.42 138.06,45.57 138.06,45.64 137.93,45.77 137.57,45.77 137.45,45.64 137.45,45.57 137.3,45.42 136.99,45.42 136.84,45.57 136.84,45.64 136.71,45.77 136.36,45.77 136.23,45.64 136.23,45.57 136.08,45.42 135.77,45.42 135.62,45.57 135.62,45.64 135.49,45.77 135.14,45.77 135.01,45.64 135.01,45.57 134.86,45.42 134.67,45.42 133.45,44.19 117.59,44.19 112.08,49.69 109.89,49.69
M_REXT: length 2.5
  BOTTOM w0.102: U637.9 217.87,68.11 R757.1 v2(219.19,68.46)
MASK_BASE_LEDS#: length 124.7
  TOP w0.102: v1(16.24,80.4) 15.04,79.2 JIO1.108 ; v1(12.07,148.4) 12.4,148.07 13.62,148.07 14.23,148.68 14.23,149.21 15.58,150.56 15.58,150.94 13.47,153.05 v2(9.58,153.05) 9.03,153.05 8.21,152.23 8.21,151.24 8.64,150.81 9.1,150.81 9.36,151.06 9.36,151.5 9.31,151.55 Q74.2 ; Q78.2 v1(15.1,145.12)
  IN2 w0.127: v1(16.24,80.4) 15.81,79.97 14.2,79.97 12.23,81.95 12.23,90.33 11.78,90.78 10.52,90.78 8.14,93.16 8.14,112.7 9.41,113.98 10.71,113.98 13.65,116.92 13.65,123.34 10.8,126.18 10.8,133.65 12.61,135.46 12.61,141.06 8.91,144.76 8.53,144.76 8.09,145.2 8.09,145.66 10.17,147.74 11.62,147.74 12.07,148.19 v1(12.07,148.4)
  BOTTOM w0.102: U58.4 18.27,151.82 20.61,149.49 Q344.5 20.06,148.52 15.86,148.52 15.32,147.99 15.32,145.35 v1(15.1,145.12) 12.07,148.14 v1(12.07,148.4) 12.07,149.04 11.61,149.5 Q318.2
MASK_SATA_LED#: length 265.2
  TOP w0.102: Q74.5 9.31,150.38 9.48,150.56 10.12,150.56 10.52,150.15 10.52,149.85 10.83,149.54 10.83,147.66 12.07,146.42 14.97,146.42 17.46,148.91 22.36,148.91 24.27,147 25.52,147 27.19,145.34 v2(27.83,145.34) 28.88,145.34 29.91,144.31 33.77,144.31 35.56,142.52 37.25,142.52 37.72,142.99 39.02,142.99 v1(42.55,146.52)
  IN3 w0.127: v1(217.92,77.37) 217.92,77.38 218.4,77.85 218.4,79.21 215.6,82 213.57,82 213.42,81.85 210.49,81.85 208.13,84.21 190.28,84.21 186.54,87.94 186.54,88.63 183.74,91.44 180.11,91.44 179.56,91.98 179.23,91.98 177.52,93.7 171.95,93.7 160.28,105.37 151.01,105.37 144.26,112.13 130.67,112.13 129.62,113.17 108.79,113.17 105.75,116.21 105.75,117.87 103.01,120.61 103.01,123.1 98.18,127.93 98.18,130.24 89.7,138.72 89.7,143.9 86.17,147.42 67.71,147.42 67.7,147.41 58.81,147.41 56.12,144.71 54.38,144.71 49.77,140.1 48.8,140.1 47.8,139.1 45.75,139.1 42.55,142.31 v1(42.55,146.52)
  BOTTOM w0.102: v1(217.92,77.37) U46.B9
MB_DP_CA_DET: length 105.7
  IN2 w0.127: v1(243.49,90.76) 245.02,92.29 245.02,95.32 255.69,106 255.69,116.4 257.41,118.12 257.41,132.85 262.06,137.5 262.06,140.12 262.59,140.65 262.59,156.02 JDP1.13
  IN3 w0.127: v1(243.49,90.76) 247.1,87.16 247.1,70.37 v1(245.32,68.59)
  BOTTOM w0.102: v1(243.49,90.76) 243.75,91.02 R62.2 C1341.1 242.58,91.12 U22.10 ; v2(245.82,68.86) 245.55,68.59 v1(245.32,68.59) Q339.2
MB_DP_HPD: length 76.4
  TOP w0.102: v1(262.01,141.31) 263.56,142.86 v2(263.56,144.98) 263.56,151.55 266.5,154.49 266.5,154.87 JDP1.18
  IN2 w0.127: v1(262.01,141.31) 261.53,140.83 261.53,138.47 256.98,133.92 256.98,118.32 255.43,116.77 255.43,106.17 244.52,95.26 244.52,92.89 242.99,91.35 242.99,90.35 v1(243.08,90.26)
  BOTTOM w0.102: U22.11 v1(243.08,90.26)
MB_DP_RP_AUX: length 93.6
  IN1 w0.109: JDP1.15 264.72,157.15 264.28,156.71 263.41,156.71 262.99,156.29 262.99,141.66 261.83,140.5 261.83,126.64 260.9,125.7 260.9,123.22 261.32,122.79 261.32,119.47 259.75,117.89 259.75,116.65 259.16,116.06 259.16,110.78 259.67,110.28 259.67,95 252.61,87.95 252.61,85.41 249.09,81.88 242.99,81.88 242.69,81.58 242.69,81.14 v1(242.53,80.98)
  BOTTOM w0.102: U22.28 242.08,82.07 242.25,81.9 242.25,81.68 242.71,81.22 242.71,81.16 v1(242.53,80.98) 242.73,80.78 242.73,80.5 243.06,80.17 243.06,80.07 R59.2
MB_DP_RP_AUX#: length 93.6
  IN1 w0.109: JDP1.17 264.49,155.92 264.22,155.92 264.09,156.04 264.09,156.32 263.94,156.47 263.51,156.47 263.23,156.2 263.23,141.56 262.07,140.41 262.07,126.54 261.13,125.6 261.13,123.31 261.56,122.89 261.56,119.37 259.99,117.79 259.99,116.55 259.39,115.96 259.39,110.88 259.9,110.37 259.9,94.9 252.85,87.85 252.85,85.31 249.18,81.65 243.09,81.65 242.93,81.48 242.93,81.12 243.07,80.98 v5(243.17,80.98)
  BOTTOM w0.102: R56.2 243.29,80.07 243.29,80.27 242.96,80.6 242.96,80.77 v5(243.17,80.98) 242.93,81.21 242.93,81.32 242.48,81.77 242.48,81.87 242.58,81.97 U22.27
MB_DP_RP_C_N0: length 2.3
  BOTTOM w0.102: C304.2 245.9,83.61 245.77,83.61 245.37,84.01 244.91,84.01 244.79,84.14 U22.22
MB_DP_RP_C_N1: length 2.2
  BOTTOM w0.102: C308.2 245.89,85.38 245.57,85.38 245.45,85.5 244.98,85.5 244.84,85.64 U22.19
MB_DP_RP_C_N2: length 2.2
  BOTTOM w0.102: U22.16 244.84,87.14 244.96,87.02 245.23,87.02 245.4,87.18 245.92,87.18 C309.2
MB_DP_RP_C_N3: length 2.3
  BOTTOM w0.102: U22.13 244.81,88.64 244.93,88.52 245.14,88.52 245.56,88.94 245.89,88.94 C302.2
MB_DP_RP_C_P0: length 2.3
  BOTTOM w0.102: U22.23 244.84,83.64 244.94,83.75 245.26,83.75 245.66,83.34 245.9,83.34 C307.2
MB_DP_RP_C_P1: length 2.1
  BOTTOM w0.102: U22.20 244.86,85.14 244.96,85.23 245.34,85.23 245.46,85.11 245.91,85.11 C295.2
MB_DP_RP_C_P2: length 2.2
  BOTTOM w0.102: C306.2 245.88,86.92 245.51,86.92 245.34,86.75 244.94,86.75 244.83,86.64 U22.17
MB_DP_RP_C_P3: length 2.3
  BOTTOM w0.102: U22.14 244.83,88.14 244.94,88.25 245.26,88.25 245.67,88.67 245.91,88.67 C303.2
MB_DP_RP_N0: length 91.6
  IN1 w0.117: JDP1.3 264.72,162.97 264.4,162.65 264.24,162.65 264.09,162.8 264.09,163.49 264.02,163.56 263.78,163.56 263.43,163.21 263.43,162.03 261.28,159.88 261.28,145.13 260.56,144.41 260.56,128.74 259.57,127.76 259.57,120.88 258.28,119.59 258.28,117.42 256.54,115.68 256.54,106.66 253.59,103.71 253.59,98.57 251.58,96.56 251.58,86.18 249.79,84.39 247.6,84.39 247.41,84.2 247.41,83.75 247.55,83.61 247.78,83.61 v1(247.95,83.78)
  BOTTOM w0.102: v1(247.95,83.78) 247.78,83.61 247.44,83.61 C304.1
MB_DP_RP_N1: length 94.8
  IN1 w0.117: JDP1.6 266,161.93 266.72,161.93 267.12,162.33 267.12,163.71 265.69,165.14 263.82,165.14 262.11,163.43 262.11,162.28 260.18,160.36 260.18,145.57 258.93,144.33 258.93,133.47 257.72,132.26 257.72,124.73 257.21,124.22 257.21,117.89 255.46,116.15 255.46,107.13 252.39,104.05 252.39,98.89 249.49,95.99 249.49,86.26 248.85,85.62 248.44,85.62 v1(248.26,85.8)
  BOTTOM w0.102: C308.1 247.44,85.38 247.58,85.38 247.82,85.62 248.08,85.62 v1(248.26,85.8)
MB_DP_RP_N2: length 86
  IN1 w0.117: v1(252.88,90.01) 252.67,89.8 252.51,89.8 252.39,89.92 252.39,92.91 255.65,96.17 255.65,103.95 256.06,104.36 256.06,104.81 256.92,105.67 257.61,105.67 258.63,106.69 258.63,116.62 259.07,117.05 259.07,119.13 260.37,120.43 260.37,126.79 261.34,127.76 261.34,143.89 262.21,144.77 262.21,159.4 263.32,160.51 263.97,160.51 264.04,160.44 264.04,159.75 264.14,159.65 264.4,159.65 264.72,159.97 JDP1.9
  BOTTOM w0.102: C309.1 247.44,87.16 247.68,87.16 248.78,88.25 248.78,88.73 v3(249.19,89.15) 249.86,89.82 252.69,89.82 v1(252.88,90.01)
MB_DP_RP_N3: length 97
  IN1 w0.117: JDP1.12 266,158.93 267.03,158.93 267.93,159.83 267.93,164.09 266.06,165.95 263.49,165.95 261.19,163.65 261.19,162.56 259.36,160.73 259.36,145.92 258.15,144.71 258.15,134.6 256.73,133.18 256.73,125.52 256.42,125.21 256.42,118.21 254.64,116.43 254.64,111.35 251.61,108.32 251.61,99.26 248.52,96.17 248.52,89.1 248.36,88.94 248.12,88.94 v1(247.94,89.12)
  BOTTOM w0.102: v1(247.94,89.12) 247.76,88.93 247.44,88.93 C302.1
MB_DP_RP_P0: length 91.6
  IN1 w0.117: v1(247.95,83.15) 247.78,83.33 247.43,83.33 247.13,83.63 247.13,84.31 247.49,84.67 249.67,84.67 251.29,86.3 251.29,96.67 253.31,98.69 253.31,103.83 256.26,106.78 256.26,115.79 258,117.53 258,119.7 259.29,120.99 259.29,127.88 260.27,128.86 260.27,144.52 260.99,145.24 260.99,160 263.15,162.15 263.15,163.32 263.66,163.84 264.41,163.84 JDP1.1
  BOTTOM w0.102: v1(247.95,83.15) 247.76,83.34 247.44,83.34 C307.1
MB_DP_RP_P1: length 94.8
  IN1 w0.117: JDP1.4 265.72,162.88 265.92,163.08 266.23,163.08 266.33,162.98 266.33,162.32 266.43,162.22 266.61,162.22 266.84,162.44 266.84,163.59 265.57,164.85 263.93,164.85 262.39,163.31 262.39,162.16 260.47,160.24 260.47,145.46 259.22,144.21 259.22,133.35 258.01,132.14 258.01,124.61 257.5,124.1 257.5,117.78 255.75,116.03 255.75,107.01 252.68,103.93 252.68,98.77 249.78,95.88 249.78,86.14 248.97,85.34 248.44,85.34 v1(248.26,85.16)
  BOTTOM w0.102: C295.1 247.43,85.11 247.69,85.11 247.93,85.35 248.07,85.35 v1(248.26,85.16)
MB_DP_RP_P2: length 86
  IN1 w0.117: v1(252.88,89.37) 252.74,89.52 252.39,89.52 252.1,89.81 252.1,93.03 255.37,96.29 255.37,104.07 255.78,104.48 255.78,104.93 256.8,105.95 257.49,105.95 258.35,106.81 258.35,116.73 258.78,117.17 258.78,119.25 260.09,120.55 260.09,126.91 261.06,127.88 261.06,144.01 261.93,144.88 261.93,159.51 263.21,160.79 264.36,160.79 JDP1.7
  BOTTOM w0.102: v1(252.88,89.37) 252.7,89.55 249.97,89.55 249.04,88.62 249.04,88.14 v3(248.29,87.38) 247.79,86.89 247.43,86.89 C306.1
MB_DP_RP_P3: length 97
  IN1 w0.117: v1(247.94,88.48) 248.12,88.66 248.47,88.66 248.8,88.99 248.8,96.05 251.89,99.14 251.89,108.2 254.92,111.23 254.92,116.32 256.7,118.1 256.7,125.09 257.01,125.4 257.01,133.06 258.44,134.49 258.44,144.6 259.65,145.81 259.65,160.61 261.48,162.44 261.48,163.54 263.61,165.67 265.95,165.67 267.64,163.97 267.64,159.95 266.91,159.22 266.45,159.22 266.33,159.34 266.33,160.01 266.23,160.11 265.97,160.11 265.72,159.85 JDP1.10
  BOTTOM w0.102: v1(247.94,88.48) 247.76,88.67 247.43,88.67 C303.1
MB_DP_RST#: length 4.5
  BOTTOM w0.102: v2(238.43,77.98) C88.1 R415.2 238.43,81.42 238.58,81.57 U22.35
MCARD_MISC_PWREN: length 163.8
  TOP w0.102: v1(170.99,126.49) 176.51,120.97 180.65,120.97 184.35,117.27 184.35,109.85 182.96,108.47 182.96,102.73 186.08,99.62 198.1,99.62 204.48,93.24 221.31,93.24 221.64,92.91 221.64,92.45 221.45,92.26 221.45,89.37 221.67,89.14 221.67,86.09 221.81,85.96 v1(221.81,84.93)
  IN3 w0.127: v1(110.69,142.15) 110.73,142.15 111.06,142.48 117.02,142.48 117.86,141.63 117.86,140.56 118.27,140.16 119.21,140.16 119.69,139.67 119.69,137.17 122.93,133.93 138.83,133.93 v1(139.44,134.54)
  IN4 w0.109: v1(170.99,126.49) 171.62,127.12 171.62,128.54 169.98,130.18 166.22,130.18 165.73,130.67 164.96,130.67 163.86,131.76 149.92,131.76 147.44,134.24 139.75,134.24 v1(139.44,134.54)
  BOTTOM w0.102: v1(110.69,142.15) 109.83,143.01 109.83,145.31 R733.1 109.72,145.82 110.48,146.58 v2(110.84,146.58) 111.05,146.58 111.66,145.97 112.04,145.97 112.09,145.92 U56.3 ; U46.B53 221.97,84.77 v1(221.81,84.93)
MCARD_PCIE#_SATA: length 16.3
  IN3 w0.127: v1(218.73,62.32) 220.68,62.32 222.79,64.43 222.79,66.69 224.49,68.39 v1(224.49,69.96)
  BOTTOM w0.102: Q322.1 224.7,69.76 v1(224.49,69.96) ; v2(219.82,61.06) 219.55,61.33 R785.2 ; U637.17 217.87,62.19 R785.2 ; R785.2 v1(218.73,62.32)
MCARD_PCIE_SATA#: length 296.7
  TOP w0.102: v1(220.84,77.38) 220.92,77.3 220.92,76.05 v1(223.58,73.39) ; v1(13.67,111.8) 14.44,111.8 14.62,111.62 18.6,111.62 v2(18.91,111.92) RH16.1 ; UH1.AN2 37.99,90.2 38.11,90.08 38.11,89.66 38.26,89.5 38.26,88.91 40.93,86.24 40.93,85.08 40.47,84.62 40.47,83.83 40.5,83.81 40.5,83.35 RH226.1 v1(40.93,83.55)
  IN2 w0.127: v1(223.58,73.39) 223.15,73.82 218.64,73.82 217.31,72.49 217.31,71.96 215.85,70.51 208.18,70.51 203.79,74.89 203.79,78.98 199.55,83.22 199.55,93.7 198.65,94.6 180.5,94.6 175.45,99.65 141,99.65 137.9,102.75 133.62,102.75 130.31,99.45 130.31,97.66 129.08,96.43 119.54,96.43 117.58,98.38 114.02,98.38 113.8,98.6 88.08,98.6 87.58,98.1 87.58,97.68 87.15,97.24 84.24,97.24 80.92,93.91 75.99,93.91 72.05,89.98 70.8,89.98 66.04,85.21 61.67,85.21 61.04,85.85 59.64,85.85 59.33,85.55 52.21,85.55 50.96,84.3 47.1,84.3 46.77,83.97 41.35,83.97 v1(40.93,83.55)
  IN4 w0.109: v1(13.67,111.8) 13.67,111.7 12.91,110.93 12.91,108.39 12.36,107.84 12.36,101.4 13.09,100.67 13.09,93.78 13.93,92.93 14.54,92.93 15.1,93.49 15.1,93.62 15.44,93.95 15.82,93.95 16.25,93.52 16.25,93.3 17.11,92.45 17.11,91.44 18.77,89.77 19.13,89.77 19.61,89.29 19.61,88.26 21.85,86.03 24.75,86.03 25.01,85.76 25.63,85.76 26.04,85.35 31.53,85.35 31.77,85.11 34.89,85.11 35.24,84.76 39.72,84.76 v1(40.93,83.55)
  BOTTOM w0.102: v1(220.84,77.38) 220.92,77.3 U46.B3 ; Q322.2 223.58,72.63 v1(223.58,73.39)
MCARD_WWAN_PWREN: length 11.3
  TOP w0.102: v1(217.13,85.2) 216.72,84.8 216.72,84.44 217.15,84.01 219.67,84.01 219.9,84.24 219.9,86.55 219.39,87.06 217.99,87.06 217.74,87.31 217.74,87.84 v1(217.89,88)
  BOTTOM w0.102: U46.B42 217.42,85.6 217.18,85.35 217.18,85.25 v1(217.13,85.2) ; T127.1 217.89,88.45 v1(217.89,88)
ME_FWP: length 254.6
  TOP w0.102: RH45.1 v1(16.04,100.24)
  IN2 w0.127: v1(189.57,96.19) 187.11,98.65 187.11,98.66 182.73,103.03 142.81,103.03 141.18,104.66 132.54,104.66 128.39,100.51 116.73,100.51 116.15,101.09 115.24,101.09 114.8,100.66 111.09,100.66 110.35,101.39 109.32,101.39 109.1,101.18 91.64,101.18 91.47,101.34 82,101.34 79.91,99.25 78.33,99.25 76.78,97.7 74.15,97.7 72.3,95.85 72.3,94.42 70.9,93.03 70.19,93.03 65.97,88.81 64.55,88.81 64.09,88.35 62.95,88.35 62.42,88.89 57.51,88.89 56.74,88.12 51.65,88.12 51.07,88.71 50.12,88.71 49.44,88.02 46.96,88.02 45.22,86.28 40.1,86.28 39.99,86.17 38.05,86.17 37.38,86.84 35.82,86.84 35.21,87.45 31.02,87.45 30.35,86.78 29.14,86.78 28.12,87.79 25.51,87.79 24.93,88.38 20.19,88.38 19.91,88.66 19.91,89.54 19.57,89.88 19.57,91.93 18.94,92.56 17.96,92.56 17.22,93.3 17.22,94.36 16.79,94.78 16.79,96.61 16.29,97.11 16.29,99.99 v1(16.04,100.24)
  BOTTOM w0.102: U46.A8 v2(218.17,74.76) 218.17,73.9 217.64,73.37 217.64,71.87 216.75,70.98 214.11,70.98 212.81,69.68 207.46,69.68 203.16,73.99 203.16,87.82 203.67,88.33 203.67,90.39 202.29,91.78 196.32,91.78 191.62,96.48 189.86,96.48 v1(189.57,96.19)
ME_SUS_PWR_ACK: length 311.1
  TOP w0.102: UH1.J4 28.25,90.65 28.54,90.36 28.54,90.1 28.35,89.91 28.35,88.73 27.43,87.8 24.88,87.8 24.45,87.38 24.45,86.64 23.93,86.12 23.33,86.12 21.96,84.75 21.79,84.75 RH91.1 21.26,83.61 v1(21.32,83.55) 21.32,83.25 RH75.2
  IN2 w0.127: v1(21.32,83.55) 21.32,83.81 23.02,85.51 31,85.51 31.67,86.18 34.68,86.18 35.96,84.9 40.51,84.9 40.63,85.01 46.37,85.01 48.09,86.73 57.14,86.73 58.03,87.62 60.71,87.62 62.1,86.23 65.4,86.23 70.16,90.99 71.63,90.99 75.58,94.94 79.37,94.94 80.7,96.28 81.06,96.28 82.27,97.48 82.27,97.85 83.59,99.17 86.49,99.17 86.93,99.62 114.22,99.62 114.44,99.4 118.99,99.4 119.79,98.6 120.28,98.6 120.48,98.4 121.03,97.85 123.32,97.85 124.11,98.64 128.06,98.64 133.19,103.77 138.69,103.77 141.01,101.45 181.95,101.45 v1(182.04,101.53)
  IN3 w0.127: v1(116.29,168.08) 116.5,168.08 119.45,165.14 123.75,165.14 125.92,162.96 128.81,162.96 129.14,162.63 136.26,162.63 140.75,158.14 144.73,158.14 147.16,155.71 147.16,154.78 150.38,151.56 151.27,151.56 154.19,148.64 154.38,148.45 154.38,146.9 156.18,145.1 156.18,143.62 156.31,143.5 156.31,142.44 159.06,139.69 159.06,133.32 160.79,131.6 164.08,131.6 164.99,130.68 165.77,130.68 167.53,128.92 167.53,125.18 174.89,117.83 174.89,109.17 182.04,102.02 v1(182.04,101.53)
  BOTTOM w0.102: v1(116.29,168.08) 115.86,167.65 v2(115.86,166.55) 115.86,160.46 113.32,157.92 111.26,157.92 110.04,156.7 109.61,156.7 109.54,156.77 U51.A8
MEC_XTAL1: length 7.4
  BOTTOM w0.102: Y6.1 108.95,166.22 C743.1 108.95,165.04 108.03,164.12 106.68,164.12 v2(106.22,163.66) 106.22,162.58 106,162.36 U51.A61
MEC_XTAL2: length 7
  BOTTOM w0.102: U51.A62 106.5,162.56 107.72,163.78 v2(107.84,163.78) 108.01,163.78 108.72,164.49 108.85,164.49 C741.1 109.81,166.22 Y6.2
MEM_SMBCLK: length 20.1
  TOP w0.102: UH1.R10 30.52,93.51 v1(30.21,93.2) ; QH4.6 18.31,88.06 18.93,87.44 v2(20.82,87.44) 22.34,87.44 v1(22.51,87.62)
  IN1 w0.089: v1(30.21,93.2) 30.45,93.2 30.57,93.07 30.57,91.68 30.11,91.22 30.11,90.92 30.08,90.89 30.08,90.87
  IN1 w0.109: 30.08,90.87 30.08,89.95 27.18,87.05 26.65,87.05 26.1,86.5 23.45,86.5 23.21,86.74 23.21,87.18 22.94,87.44 22.69,87.44 v1(22.51,87.62)
  BOTTOM w0.102: v1(22.51,87.62) 22.41,87.51 21.98,87.51 21.84,87.65 RPH5.1
