# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D54: length 58.7
  TOP w0.102: v1(101.12,40.75) JCPU1.B6
  TOP w0.14: JDIMM1.174 144.91,36.25 142.54,33.88 v1(142.54,33.81)
  IN1 w0.089: v1(101.12,40.75) 101.12,40.48 101.63,39.96 101.63,39.54 102.41,38.77
  IN1 w0.147: 102.41,38.77 106.71,34.47 106.93,34.47 108.29,33.11 111.53,33.11 112.3,32.34 119.48,32.34 119.6,32.22 119.6,31.85 119.75,31.7 120.05,31.7 120.19,31.85 120.19,32.22 120.32,32.34 120.66,32.34 120.78,32.22 120.78,31.85 120.93,31.7 132.99,31.7 134.37,33.09 136.11,33.09 136.26,32.94 136.26,32.71 136.41,32.56 136.7,32.56 136.85,32.71 136.85,32.94 136.99,33.09 138.16,33.09 139.54,34.47 142.41,34.47 142.54,34.34 v1(142.54,33.81)
  BOTTOM w0.14: v1(142.54,33.81) 142.69,33.81 143.12,34.25 143.67,34.25 144.2,34.78 144.2,35.47 144.69,35.95 JDIMM2.175
DDR_A_D55: length 56.8
  TOP w0.102: v1(101.12,39.75) JCPU1.A6
  TOP w0.14: JDIMM1.177 138.58,35.35 139.49,34.44 v1(139.49,33.81)
  IN1 w0.147: v1(139.49,33.81) 137.85,32.17 134.01,32.17 133.15,31.32 118.99,31.32 118.84,31.46 118.84,31.81 118.69,31.95 118.4,31.95 118.25,31.81 118.25,31.46 118.11,31.32 117.81,31.32 117.66,31.46 117.66,31.81 117.52,31.95 117.22,31.95 117.07,31.81 117.07,31.46 116.93,31.32 116.63,31.32 116.48,31.46 116.48,31.81 116.34,31.95 116.04,31.95 115.9,31.81 115.9,31.46 115.75,31.32 115.45,31.32 115.31,31.46 115.31,31.81 115.16,31.95 114.86,31.95 114.72,31.81 114.72,31.46 114.57,31.32 114.27,31.32 114.13,31.46 114.13,31.81 113.98,31.95 113.69,31.95 113.54,31.81 113.54,31.46 113.39,31.32 113.1,31.32 112.95,31.46 112.95,31.81 112.8,31.95 112.51,31.95 112.36,31.81 112.36,31.46 112.21,31.32 111.92,31.32 111.77,31.46 111.77,32.32 111.37,32.72 111.02,32.72 110.87,32.57 110.87,32.29 110.75,32.17 110.41,32.17 110.28,32.29 110.28,32.57 110.14,32.72 108.13,32.72 106.77,34.08 106.54,34.08 101.12,39.51 v1(101.12,39.75)
  BOTTOM w0.14: JDIMM2.176 138.66,35.65 139.49,34.83 v1(139.49,33.81)
DDR_A_D56: length 66.7
  TOP w0.102: v1(95.12,43.75) JCPU1.E12
  TOP w0.14: v1(139.81,31.78) 139.81,32.17 138.42,33.55 JDIMM1.183
  IN1 w0.089: 99.56,38.77 98.72,39.61 98.72,40.01 98.52,40.21 98.52,40.91 98.28,41.16 97.88,41.16 97.52,41.51 97.52,41.91 97.28,42.16 96.85,42.16 96.67,42.34 96,42.34 95.51,42.83 95.51,43.36 v1(95.12,43.75)
  IN1 w0.147: 99.56,38.77 105.89,32.44 106.12,32.44 108.02,30.55 108.92,30.55 109.07,30.4 109.07,29.81 109.19,29.68 109.53,29.68 109.66,29.81 109.66,30.4 109.8,30.55 110.13,30.55 110.26,30.42 110.26,29.83 110.38,29.7 134.43,29.7 134.56,29.83 134.56,30.43 134.68,30.56 136.19,30.56 136.34,30.41 136.34,29.81 136.47,29.68 136.8,29.68 136.93,29.81 136.93,30.41 137.08,30.56 137.37,30.56 137.52,30.41 137.52,29.84 137.65,29.72 137.98,29.72 138.11,29.84 138.11,30.41 138.26,30.56 138.8,30.56 138.95,30.7 138.95,30.86 139.1,31.01 139.39,31.01 139.54,30.86 139.54,30.7 139.69,30.56 140.09,30.56 140.22,30.68 140.22,31.29 140.09,31.42 139.93,31.42 139.81,31.54 v1(139.81,31.78)
  BOTTOM w0.14: v1(139.81,31.78) 139.81,32.4 138.62,33.59 138.62,33.69 138.46,33.85 JDIMM2.182
DDR_A_D57: length 68.5
  TOP w0.102: v1(95.12,42.75) JCPU1.D12
  TOP w0.14: v1(141.33,31.78) 141.31,31.78 139.94,33.16 139.4,33.16 138.85,33.72 138.85,33.84 138.54,34.15 JDIMM1.181
  IN1 w0.089: 99.01,38.77 98.53,39.25 98.53,39.9 98.09,40.35 97.96,40.35 97.72,40.58 97.72,41.04 97.42,41.35 96.96,41.35 96.72,41.58 96.72,41.98 96.55,42.15 95.5,42.15 95.12,42.52 v1(95.12,42.75)
  IN1 w0.147: v1(141.33,31.78) 141.33,31.48 141.46,31.35 143.06,31.35 143.19,31.22 143.19,30.87 143.06,30.75 140.83,30.75 140.16,30.07 138.88,30.07 138.11,29.29 108.72,29.29 105.96,32.05 105.73,32.05 99.01,38.77
  BOTTOM w0.14: v1(141.33,31.78) 141.33,31.79 139.89,33.23 139.43,33.23 138.97,33.69 138.97,34.1 138.62,34.45 JDIMM2.180
DDR_A_D58: length 67.9
  TOP w0.102: v1(96.12,40.75) JCPU1.B11
  TOP w0.14: JDIMM1.192 144.87,30.85 142.59,28.57 v1(142.59,28.48)
  IN1 w0.089: 95.72,38.77 95.11,39.37 94.97,39.37 94.75,39.59 94.75,40.9 94.97,41.12 95.53,41.12 95.9,40.75 v1(96.12,40.75)
  IN1 w0.147: 95.72,38.77 104.76,29.73 105,29.73 108.3,26.43 142.59,26.43 142.72,26.55 142.72,28.35 142.59,28.48 v1(142.59,28.48)
  BOTTOM w0.14: JDIMM2.191 145.79,31.15 144.89,31.15 142.59,28.85 v1(142.59,28.48)
DDR_A_D59: length 65.6
  TOP w0.102: v1(96.12,39.75) JCPU1.A11
  TOP w0.14: v1(144.11,28.48) 144.11,29.43 144.93,30.25 JDIMM1.194
  IN1 w0.089: 97.36,38.77 96.4,39.74 96.13,39.74 v1(96.12,39.75)
  IN1 w0.147: v1(144.11,28.48) 145.22,28.48 145.35,28.61 145.35,29.04 145.22,29.17 145.02,29.17 144.87,29.32 144.87,29.67 144.72,29.82 144.43,29.82 144.28,29.67 144.28,29.32 144.13,29.17 143.84,29.17 143.69,29.32 143.69,29.67 143.55,29.82 143.25,29.82 143.1,29.67 143.1,29.32 142.96,29.17 142.51,29.17 142.25,28.91 139.36,28.91 138.05,27.59 127.35,27.59 126.81,28.14 108.24,28.14 105.48,30.89 105.24,30.89 97.36,38.77
  BOTTOM w0.14: JDIMM2.193 145.79,30.55 144.9,30.55 144.11,29.76 v1(144.11,28.48)
DDR_A_D60: length 66
  TOP w0.102: JCPU1.E11 96.59,44.21 v1(96.19,43.75)
  TOP w0.14: v1(147.6,33.79) 146.93,34.45 JDIMM1.180
  IN1 w0.089: v1(96.19,43.75) 96.79,43.15 97.25,43.15 97.52,42.88 97.52,42.82 98,42.34 98.13,42.34 98.56,41.91 98.56,41.72 98.97,41.31 99.09,41.31 99.72,40.68 99.72,39.62 100.03,39.3 100.14,39.3 100.67,38.77
  IN1 w0.147: 100.67,38.77 106.22,33.22 106.45,33.22 108.34,31.33 110.45,31.33 111.3,30.48 133.5,30.48 134.36,31.33 138.2,31.33 139.73,32.86 140.7,32.86 141.2,33.36 146.77,33.36 146.9,33.49 146.9,34.62 147.02,34.75 147.48,34.75 147.61,34.62 147.61,33.81 v1(147.6,33.79)
  BOTTOM w0.14: v1(147.6,33.79) 147.6,33.78 147.47,33.65 147.19,33.65 147.06,33.78 147.06,34.02 146.93,34.15 JDIMM2.181
DDR_A_D61: length 67.3
  TOP w0.102: v1(96.12,42.75) JCPU1.D11
  TOP w0.14: v1(142.85,31.78) 142.85,31.91 144.8,33.85 JDIMM1.182
  IN1 w0.089: v1(96.12,42.75) 96.53,42.75 96.93,42.35 97.36,42.35 97.72,41.98 97.72,41.58 97.96,41.35 98.45,41.35 98.7,41.1 98.7,40.48 98.89,40.29 99.34,40.29 99.53,40.1 99.53,39.35 100.11,38.77
  IN1 w0.147: v1(142.85,31.78) 142.85,32.13 142.98,32.26 144.34,32.26 144.47,32.38 144.47,32.84 144.34,32.97 141.36,32.97 140.86,32.47 139.89,32.47 138.36,30.95 134.52,30.95 133.66,30.09 111.14,30.09 110.29,30.94 108.18,30.94 106.29,32.83 106.05,32.83 100.11,38.77
  BOTTOM w0.14: v1(142.85,31.78) 142.85,32.88 142.98,33.01 144.32,33.01 144.87,33.55 JDIMM2.183
DDR_A_D62: length 67.2
  TOP w0.102: v1(95.12,40.75) JCPU1.B12
  TOP w0.14: v1(139.54,28.48) 139.54,29.62 138.6,30.55 JDIMM1.193
  IN1 w0.089: v1(95.12,40.75) 95.59,40.75 95.72,40.62 95.72,39.6 96.02,39.3 96.28,39.3 96.81,38.77
  IN1 w0.147: v1(139.54,28.48) 139.54,27.34 139.41,27.21 126.6,27.21 126.46,27.35 126.46,27.6 126.31,27.75 126.01,27.75 125.87,27.6 125.87,27.35 125.72,27.21 125.42,27.21 125.28,27.35 125.28,27.6 125.13,27.75 124.83,27.75 124.69,27.6 124.69,27.35 124.54,27.21 124.25,27.21 124.1,27.35 124.1,27.6 123.95,27.75 123.66,27.75 123.51,27.6 123.51,27.35 123.36,27.21 123.07,27.21 122.92,27.35 122.92,27.6 122.77,27.75 122.48,27.75 122.33,27.6 122.33,27.35 122.18,27.21 121.89,27.21 121.74,27.35 121.74,27.6 121.59,27.75 121.3,27.75 121.15,27.6 121.15,27.35 121,27.21 120.71,27.21 120.56,27.35 120.56,27.6 120.42,27.75 120.12,27.75 119.97,27.6 119.97,27.35 119.83,27.21 119.53,27.21 119.38,27.35 119.38,27.6 119.24,27.75 118.94,27.75 118.79,27.6 118.79,27.35 118.65,27.21 118.35,27.21 118.21,27.35 118.21,27.6 118.06,27.75 117.76,27.75 117.62,27.6 117.62,27.35 117.47,27.21 117.17,27.21 117.03,27.35 117.03,27.6 116.88,27.75 116.58,27.75 116.44,27.6 116.44,27.35 116.29,27.21 116,27.21 115.85,27.35 115.85,27.6 115.7,27.75 115.41,27.75 115.26,27.6 115.26,27.35 115.11,27.21 114.82,27.21 114.67,27.35 114.67,27.6 114.52,27.75 108.08,27.75 105.32,30.51 105.08,30.51 96.81,38.77
  BOTTOM w0.14: v1(139.54,28.48) 139.69,28.48 139.94,28.73 139.94,29.05 138.73,30.25 JDIMM2.194
DDR_A_D63: length 68.3
  TOP w0.102: v1(95.12,39.75) JCPU1.A12
  TOP w0.14: v1(141.06,28.48) 141.06,29.03 138.94,31.15 JDIMM1.191
  IN1 w0.089: v1(95.12,39.75) 95.29,39.75 96.21,38.82
  IN1 w0.147: 96.21,38.82 104.92,30.12 105.16,30.12 107.92,27.36 109.26,27.36 109.41,27.21 109.41,26.96 109.56,26.82 109.85,26.82 110,26.96 110,27.21 110.14,27.36 110.52,27.36 110.67,27.21 110.67,26.96 110.82,26.82 111.11,26.82 111.26,26.96 111.26,27.21 111.4,27.36 111.7,27.36 111.85,27.21 111.85,26.96 111.99,26.82 112.29,26.82 112.44,26.96 112.44,27.21 112.58,27.36 112.88,27.36 113.02,27.21 113.02,26.96 113.17,26.82 113.47,26.82 113.61,26.96 113.61,27.21 113.76,27.36 114.06,27.36 114.2,27.21 114.2,26.96 114.35,26.82 140.02,26.82 140.17,26.96 140.17,27.23 140.3,27.35 140.63,27.35 140.76,27.23 140.76,26.96 140.91,26.82 141.28,26.82 141.41,26.94 141.41,28.35 141.28,28.48 v1(141.06,28.48)
  BOTTOM w0.14: v1(141.06,28.48) 141.28,28.48 141.41,28.61 141.41,28.94 141.28,29.06 140.54,29.06 138.75,30.85 JDIMM2.192
DDR_A_DQS0: length 73.8
  TOP w0.102: JCPU1.AP14 v1(94.12,73.75)
  TOP w0.14: JDIMM1.12 144.85,87.25 144.71,87.39 144.71,87.51 144.63,87.59 144.07,87.59 143.8,87.87 143.8,88.23 144.07,88.49 144.07,88.8 143.7,89.16 142.49,89.16 142.37,89.04 142.37,88.8 142.53,88.64 v1(142.74,88.64)
  IN1 w0.089: 94.77,77.25 94.77,77.23 94.74,77.2 94.74,74.55 94.32,74.14 93.86,74.14 93.71,73.99 93.71,73.89 93.86,73.75 v1(94.12,73.75)
  IN1 w0.147: v1(142.74,88.64) 142.57,88.47 142.57,88.16 142.32,87.92 140.96,87.92 140.15,88.73 129.26,88.73 128.93,88.4 120.26,88.4 119.49,87.63 100.17,87.63 97.54,85 97.54,80.81 94.77,78.04 94.77,77.25
  BOTTOM w0.14: JDIMM2.12 138.66,87.25 138.89,87.48 142.27,87.48 142.74,87.95 v1(142.74,88.64)
DDR_A_DQS1: length 62.2
  TOP w0.102: JCPU1.AP9 v1(99.12,73.75)
  TOP w0.14: JDIMM1.29 138.41,82.15 140.14,83.88 142.01,83.88 142.18,83.71 142.18,83.6 142.02,83.45 v1(141.81,83.45)
  IN1 w0.089: 100.76,77.25 100.7,77.19 100.7,77.15 99.55,76.01 99.55,74.18 v1(99.12,73.75)
  IN1 w0.147: v1(141.81,83.45) 142.05,83.21 142.05,83.02 141.94,82.92 140.86,82.92 140.7,83.07 136.83,83.07 136.56,82.79 133.64,82.79 132.47,83.96 121.08,83.96 121.06,83.94 114.37,83.94 113.87,83.44 108.91,83.44 107.93,82.46 107.93,81.48 103.96,77.51 101.01,77.51 100.76,77.25
  BOTTOM w0.14: JDIMM2.29 145.79,82.15 144.41,82.15 144.21,82.36 144.05,82.36 143.65,82.77 143.23,82.77 142.82,82.36 141.97,82.36 141.72,82.61 141.72,82.95 141.9,83.14 141.9,83.35 141.81,83.44 v1(141.81,83.45)
DDR_A_DQS2: length 62.6
  TOP w0.102: JCPU1.AK8 v1(100.12,69.75)
  TOP w0.14: JDIMM1.47 139.06,76.75 139.71,77.4 142.19,77.4 142.58,77.8 142.58,77.99 v1(142.73,78.14)
  IN1 w0.089: 108.47,76.3 108.45,76.28 108.45,76.27 107.73,75.55 107.09,75.55 106.52,74.99 106.52,74.59 106.28,74.34 105.81,74.34 105.53,74.06 105.53,73.52 105.34,73.33 103.88,73.33 103.52,72.96 103.52,72.56 103.31,72.34 102.82,72.34 102.55,72.08 102.55,71.56 102.31,71.33 101.86,71.33 101.54,71.01 101.54,70.58 101.3,70.34 100.89,70.34 100.52,69.97 100.52,69.52 100.41,69.41 100.28,69.41 100.12,69.57 v1(100.12,69.75)
  IN1 w0.147: v1(142.73,78.14) 142.73,78.14 142.57,78.31 142.57,78.53 142.22,78.88 140.09,78.88 139.85,78.64 139.85,78.4 139.7,78.26 139.26,78.26 139.11,78.4 139.11,78.54 138.82,78.84 138.16,78.84 137.87,78.54 137.87,78.4 137.72,78.26 137.28,78.26 137.13,78.4 137.13,78.54 136.84,78.84 132.01,78.84 131.49,79.36 114.98,79.36 113.87,78.25 110.45,78.25 108.82,76.62 108.78,76.62 108.47,76.3
  BOTTOM w0.14: v1(142.73,78.14) 142.56,78.14 142.38,78.32 142.38,78.45 142.76,78.83 143.43,78.83 143.98,78.27 143.98,77.42 144.31,77.09 144.49,77.09 144.83,76.75 JDIMM2.47
DDR_A_DQS3: length 57
  TOP w0.089: JCPU1.AG3 104.74,66.28 105.12,66.66 v1(105.12,66.75)
  TOP w0.14: v1(141.49,73.05) 141.49,73.04 141.52,73.02 141.52,72.5 142.05,71.97 142.9,71.97 143.24,72.3 143.71,72.3 143.87,72.15 143.87,72.03 144.24,71.65 JDIMM1.64
  IN1 w0.089: 108.44,71.02 108.41,70.99 108.4,70.99 108.4,70.98 107.91,70.98 107.68,70.75 107.68,68.76 106.27,67.35 105.78,67.35 105.77,67.35 105.77,67.34 105.55,67.12 105.55,66.24 105.49,66.18 105.2,66.18 105.12,66.25 v1(105.12,66.75)
  IN1 w0.147: 108.44,71.02 109.06,71.64 109.42,71.64 112.09,74.3 116.09,74.3 117.2,75.42 127.47,75.42 127.75,75.14 127.75,75.02 127.88,74.9 128.36,74.9 128.49,75.02 128.49,75.14 128.76,75.42 129.45,75.42 129.73,75.14 129.73,75.05 129.88,74.9 133.27,74.9 133.87,74.3 138.07,74.3 139.76,72.6 141.54,72.6 141.64,72.71 141.64,72.9 v1(141.49,73.05)
  BOTTOM w0.14: v1(141.49,73.05) 141.76,73.05 141.84,73.12 141.84,73.37 141.62,73.59 140.66,73.59 140.02,72.94 140.02,72.83 139.18,71.99 138.82,71.99 138.69,71.86 138.69,71.72 138.62,71.65 JDIMM2.64
DDR_A_DQS4: length 55.5
  TOP w0.102: v1(105.12,46.75) JCPU1.H3
  TOP w0.14: JDIMM1.137 138.38,47.35 139.5,46.23 139.5,46.07 140.48,45.09 141.85,45.09 142.16,45.41 142.16,45.7 v1(142.32,45.86)
  IN1 w0.089: 108.62,44.81 108.61,44.81 108.58,44.84 108.53,44.84 108.5,44.86 108.26,44.86 108,45.12 108,45.46 107.46,46 106.49,46 106.4,46.1 105.93,46.1 105.85,46.18 105.77,46.26 105.52,46.52 105.52,46.52 105.5,46.54 105.5,47.05 105.4,47.15 105.29,47.15 105.12,46.98 v1(105.12,46.75)
  IN1 w0.147: v1(142.32,45.86) 142.17,45.71 142.17,45.44 141.9,45.16 140.11,45.16 139.82,45.46 139.82,45.72 139.67,45.86 139.23,45.86 139.08,45.72 139.08,45.46 138.78,45.16 138.08,45.16 136.92,44 134.75,44 133.26,42.51 132.35,42.51 131.7,41.86 112.07,41.86 109.13,44.81 108.62,44.81
  BOTTOM w0.14: v1(142.32,45.86) 142.12,45.86 141.99,45.98 141.99,46.49 142.13,46.63 142.53,46.63 142.88,46.28 143.52,46.28 143.86,46.63 144.21,46.63 144.76,47.18 144.76,47.46 144.84,47.53 144.99,47.53 145.17,47.35 JDIMM2.137
DDR_A_DQS5: length 56
  TOP w0.102: v1(104.12,43.75) JCPU1.E3
  TOP w0.14: v1(141.58,40.45) 141.6,40.45 141.66,40.38 141.66,39.96 141.94,39.68 143.4,39.68 143.85,40.14 143.85,41.13 144.42,41.69 144.42,42.14 144.54,42.25 JDIMM1.154
  IN1 w0.089: v1(104.12,43.75) 104.47,43.75 104.58,43.64 104.58,43.4 104.86,43.12 105.28,43.12 105.52,42.88 105.52,42.53 105.91,42.14 106.25,42.14 108.36,40.04 108.36,40.02 108.4,39.98 108.4,39.94 108.41,39.93
  IN1 w0.147: 108.41,39.93 110.42,37.92 133.35,37.92 133.97,38.55 136.85,38.55 138.34,40.04 138.57,40.04 139.41,40.88 141.66,40.88 141.77,40.77 141.77,40.64 v1(141.58,40.45)
  BOTTOM w0.14: JDIMM2.154 138.4,42.25 138.59,42.44 138.72,42.44 138.81,42.35 138.81,41.36 139.19,40.98 141.86,40.98 142.01,40.83 142.01,40.71 141.92,40.62 141.92,40.5 141.87,40.45 v1(141.58,40.45)
DDR_A_DQS6: length 60.1
  TOP w0.102: v1(101.12,41.75) JCPU1.C6
  TOP w0.14: v1(141.47,35.34) 141.64,35.34 141.88,35.58 141.88,35.75 141.66,35.97 139.5,35.97 138.99,36.48 138.99,37.06 138.76,37.29 138.65,37.29 138.52,37.15 JDIMM1.171
  IN1 w0.089: v1(101.12,41.75) 101.46,41.75 101.52,41.68 101.52,40.51 101.88,40.15 102.26,40.15 102.51,39.91 102.51,39.55 102.9,39.16 103.25,39.16 103.59,38.83 103.59,38.79 103.6,38.77
  IN1 w0.147: 103.6,38.77 107.03,35.34 107.4,35.34 108.79,33.95 111.88,33.95 112.65,33.18 133.28,33.18 134.04,33.95 137.82,33.95 139.64,35.76 140.95,35.76 141.09,35.9 141.55,35.9 141.74,35.71 141.74,35.61 v1(141.47,35.34)
  BOTTOM w0.14: v1(141.47,35.34) 141.47,35.33 141.59,35.22 141.59,34.86 141.84,34.61 143.26,34.61 143.73,35.08 143.73,35.86 144.53,36.66 144.53,37.07 144.62,37.15 JDIMM2.171
DDR_A_DQS7: length 71.4
  TOP w0.102: v1(95.12,41.75) JCPU1.C12
  TOP w0.14: v1(142.47,30.25) 142.24,30.25 142.13,30.37 142.13,30.79 142.4,31.06 143.08,31.06 143.43,30.71 144.07,30.71 144.39,31.03 144.39,32.27 144.51,32.39 144.65,32.39 144.74,32.31 144.74,32.18 144.86,32.05 JDIMM1.188
  IN1 w0.089: 98.01,38.77 98.01,38.78 98.01,38.82 97.53,39.3 97.53,40.01 97.39,40.15 96.75,40.15 96.54,40.37 96.54,40.95 96.35,41.14 95.76,41.14 95.4,41.5 95.4,41.54 95.19,41.75 v1(95.12,41.75)
  IN1 w0.147: 98.01,38.77 105.44,31.35 105.67,31.35 108.43,28.59 127.12,28.59 127.27,28.44 127.27,28.32 127.54,28.05 128.24,28.05 128.51,28.32 128.51,28.46 128.64,28.59 129.12,28.59 129.25,28.46 129.25,28.32 129.52,28.05 130.22,28.05 130.49,28.32 130.49,28.46 130.62,28.59 131.1,28.59 131.23,28.46 131.23,28.34 131.52,28.05 132.18,28.05 132.47,28.34 132.47,28.46 132.6,28.59 133.08,28.59 133.21,28.46 133.21,28.34 133.51,28.05 134.16,28.05 134.45,28.34 134.45,28.44 134.6,28.59 135.04,28.59 135.19,28.44 135.19,28.34 135.49,28.05 137.86,28.05 139.17,29.36 142.06,29.36 142.38,29.68 142.38,30.16 v1(142.47,30.25)
  BOTTOM w0.14: JDIMM2.188 138.82,32.05 139.09,31.78 139.09,31.14 140.73,29.51 142.15,29.51 142.39,29.74 142.39,30.17 v1(142.47,30.25)
DDR_A_DQS#0: length 73.7
  TOP w0.102: JCPU1.AP15 v1(93.12,73.75)
  TOP w0.14: JDIMM1.10 144.18,87.85 144.06,87.98 144.06,88.12 144.33,88.39 144.33,88.91 143.81,89.42 142.37,89.42 142.11,89.16 142.11,88.77 v1(141.97,88.64)
  IN1 w0.089: 94.52,77.25 94.52,77.23 94.55,77.2 94.55,74.64 94.24,74.33 93.79,74.33 93.52,74.07 93.52,73.94 93.33,73.75 v1(93.12,73.75)
  IN1 w0.147: v1(141.97,88.64) 142.11,88.64 142.31,88.44 142.31,88.27 142.22,88.17 141.06,88.17 140.25,88.98 129.16,88.98 128.82,88.65 120.16,88.65 119.39,87.88 100.07,87.88 97.29,85.1 97.29,80.91 94.52,78.14 94.52,77.25
  BOTTOM w0.14: v1(141.97,88.64) 142.13,88.64 142.48,88.3 142.48,88.06 142.16,87.74 138.99,87.74 138.79,87.74 138.68,87.85 137.6,87.85 JDIMM2.10
DDR_A_DQS#1: length 62.4
  TOP w0.102: JCPU1.AP8 v1(100.12,73.75)
  TOP w0.14: JDIMM1.27 138.65,82.75 140.03,84.14 142.11,84.14 142.44,83.82 142.44,83.58 v1(142.57,83.45)
  IN1 w0.089: 100.94,77.07 100.87,77.01 100.83,77.01 99.75,75.92 99.75,74.12 v1(100.12,73.75)
  IN1 w0.147: v1(142.57,83.45) 142.3,83.17 142.3,82.92 142.05,82.66 140.75,82.66 140.6,82.81 136.94,82.81 136.66,82.54 133.53,82.54 132.37,83.7 121.18,83.7 121.16,83.68 114.47,83.68 113.97,83.19 109.02,83.19 108.19,82.36 108.19,81.37 104.07,77.25 101.12,77.25 100.94,77.07
  BOTTOM w0.14: v1(142.57,83.45) 142.41,83.45 142.16,83.2 142.16,83.03 141.97,82.85 141.97,82.72 142.08,82.62 142.71,82.62 143.12,83.02 143.75,83.02 144.16,82.62 144.32,82.62 144.52,82.41 144.58,82.41 144.66,82.5 144.66,82.7 144.71,82.75 JDIMM2.27
DDR_A_DQS#2: length 62.8
  TOP w0.102: JCPU1.AJ8 v1(100.12,68.75)
  TOP w0.14: JDIMM1.45 138.67,77.35 138.74,77.28 138.74,77.09 138.82,77.01 138.95,77.01 139.6,77.66 142.08,77.66 142.32,77.91 142.32,78.03 142.21,78.14 v1(141.94,78.14)
  IN1 w0.089: 108.65,76.12 108.64,76.11 108.59,76.11 108.56,76.08 108.53,76.08 107.81,75.36 107.16,75.36 106.71,74.91 106.71,74.51 106.36,74.15 105.89,74.15 105.89,74.15 105.73,73.98 105.73,73.44 105.42,73.13 103.97,73.13 103.72,72.88 103.72,72.48 103.39,72.15 102.9,72.15 102.74,71.99 102.74,71.48 102.39,71.13 101.94,71.13 101.74,70.93 101.74,70.5 101.38,70.14 100.97,70.14 100.72,69.89 100.72,69.44 100.49,69.21 100.25,69.21 100.12,69.09 v1(100.12,68.75)
  IN1 w0.147: v1(141.94,78.14) 142.21,78.14 142.31,78.24 142.31,78.43 142.12,78.62 140.2,78.62 140.1,78.53 140.1,78.3 139.81,78 139.15,78 138.86,78.3 138.86,78.44 138.71,78.59 138.27,78.59 138.12,78.44 138.12,78.3 137.83,78 137.17,78 136.88,78.3 136.88,78.44 136.73,78.59 131.91,78.59 131.39,79.11 115.09,79.11 113.97,77.99 110.56,77.99 108.93,76.36 108.89,76.36 108.65,76.12
  BOTTOM w0.14: JDIMM2.45 144.42,77.35 144.24,77.53 144.24,78.38 143.54,79.09 142.65,79.09 142.12,78.55 142.12,78.31 141.94,78.14 v1(141.94,78.14)
DDR_A_DQS#3: length 57.1
  TOP w0.089: JCPU1.AF3 104.65,65.28 v1(105.12,65.75)
  TOP w0.14: v1(142.26,73.05) 142.1,73.05 141.78,72.73 141.78,72.6 142.16,72.23 142.8,72.23 143.14,72.56 143.82,72.56 144.13,72.25 144.13,72.13 144.32,71.94 144.49,71.94 144.55,71.99 144.55,72.16 144.64,72.25 JDIMM1.62
  IN1 w0.089: v1(105.12,65.75) 105.12,65.82 105.29,65.99 105.57,65.99 105.74,66.16 105.74,67.04 105.75,67.04 105.87,67.16 106.36,67.16 107.87,68.67 107.87,70.67 107.99,70.79 108.48,70.79 108.48,70.79 108.53,70.79 108.57,70.83 108.61,70.83 108.62,70.84
  IN1 w0.147: v1(142.26,73.05) 141.89,72.69 141.89,72.6 141.64,72.35 139.66,72.35 137.96,74.04 133.77,74.04 133.17,74.64 129.77,74.64 129.48,74.94 129.48,75.04 129.35,75.16 128.87,75.16 128.74,75.04 128.74,74.92 128.46,74.64 127.77,74.64 127.5,74.92 127.5,75.04 127.37,75.16 117.31,75.16 116.19,74.05 112.19,74.05 109.53,71.39 109.17,71.39 108.62,70.84
  BOTTOM w0.14: JDIMM2.62 139.08,72.25 139.76,72.93 139.76,73.05 140.56,73.85 141.77,73.85 141.91,73.71 142.11,73.51 142.11,73.19 v1(142.26,73.05)
DDR_A_DQS#4: length 55.9
  TOP w0.102: v1(105.12,47.75) JCPU1.J3
  TOP w0.14: JDIMM1.135 138.74,47.95 138.92,47.78 138.92,47.18 139.76,46.34 139.76,46.18 140.59,45.35 141.74,45.35 141.91,45.51 141.91,45.73 141.78,45.86 v1(141.56,45.86)
  IN1 w0.089: v1(105.12,47.75) 105.12,47.49 105.27,47.34 105.48,47.34 105.7,47.13 105.7,46.62 105.71,46.6 105.71,46.6 105.91,46.4 105.99,46.32 106.01,46.3 106.48,46.3 106.57,46.2 107.54,46.2 108.2,45.54 108.2,45.2 108.34,45.06 108.59,45.06 108.6,45.06 108.62,45.06
  IN1 w0.147: v1(141.56,45.86) 141.75,45.86 141.92,45.69 141.92,45.54 141.79,45.42 140.22,45.42 140.07,45.57 140.07,45.82 139.77,46.12 139.12,46.12 138.82,45.82 138.82,45.57 138.68,45.42 137.97,45.42 136.81,44.25 134.64,44.25 133.15,42.76 132.24,42.76 131.6,42.12 112.18,42.12 109.23,45.06 108.62,45.06
  BOTTOM w0.14: JDIMM2.135 144.84,47.95 144.73,47.84 144.73,47.79 144.5,47.57 144.5,47.29 144.1,46.89 143.75,46.89 143.41,46.54 142.99,46.54 142.64,46.89 142.02,46.89 141.74,46.6 141.74,46.03 v1(141.56,45.86)
DDR_A_DQS#5: length 56
  TOP w0.102: v1(105.12,43.75) JCPU1.E2
  TOP w0.14: v1(142.34,40.45) 142.17,40.45 141.92,40.2 141.92,40.06 142.05,39.94 143.29,39.94 143.59,40.24 143.59,41.23 144.16,41.8 144.16,42.25 144.43,42.51 144.6,42.51 144.94,42.85 JDIMM1.152
  IN1 w0.089: v1(105.12,43.75) 104.93,43.75 104.77,43.58 104.77,43.49 104.94,43.32 105.36,43.32 105.72,42.96 105.72,42.61 105.99,42.34 106.34,42.34 108.56,40.11 108.59,40.11
  IN1 w0.147: v1(142.34,40.45) 142.02,40.77 142.02,40.88 141.77,41.13 139.3,41.13 138.46,40.3 138.24,40.3 136.75,38.8 133.87,38.8 133.24,38.17 110.53,38.17 108.59,40.11
  BOTTOM w0.14: JDIMM2.152 137.6,42.85 138.68,42.85 139.07,42.46 139.07,41.46 139.3,41.23 141.97,41.23 142.27,40.94 142.27,40.52 v1(142.34,40.45)
DDR_A_DQS#6: length 60.2
  TOP w0.102: v1(102.12,41.75) JCPU1.C5
  TOP w0.14: v1(142.23,35.34) 142.14,35.43 142.14,35.86 141.77,36.23 139.61,36.23 139.25,36.59 139.25,37.16 138.66,37.75 JDIMM1.169
  IN1 w0.089: v1(102.12,41.75) 101.71,41.34 101.71,40.59 101.95,40.35 102.35,40.35 102.7,39.99 102.7,39.63 102.98,39.36 103.34,39.36 103.72,38.97 103.77,38.97 103.78,38.95
  IN1 w0.147: 103.78,38.95 107.14,35.6 107.51,35.6 108.9,34.2 111.99,34.2 112.75,33.44 133.18,33.44 133.94,34.2 137.72,34.2 139.53,36.01 140.84,36.01 140.99,36.15 141.66,36.15 141.99,35.82 141.99,35.57 v1(142.23,35.34)
  BOTTOM w0.14: v1(142.23,35.34) 142.05,35.34 141.85,35.13 141.85,34.97 141.94,34.87 143.15,34.87 143.47,35.19 143.47,35.96 144.28,36.77 144.28,37.18 144.51,37.41 144.63,37.41 144.7,37.47 144.7,37.69 144.76,37.75 JDIMM2.169
DDR_A_DQS#7: length 71.4
  TOP w0.102: v1(96.12,41.75) JCPU1.C11
  TOP w0.14: v1(141.71,30.25) 141.72,30.25 141.87,30.4 141.87,30.9 142.29,31.32 143.19,31.32 143.54,30.97 143.96,30.97 144.13,31.14 144.13,32.38 144.41,32.65 JDIMM1.186
  IN1 w0.089: 98.19,38.95 98.18,38.97 98.14,38.97 97.72,39.38 97.72,40.09 97.47,40.35 96.83,40.35 96.73,40.45 96.73,41.03 96.72,41.03 96.43,41.33 95.84,41.33 95.59,41.58 95.59,41.79 95.68,41.88 95.99,41.88 v1(96.12,41.75)
  IN1 w0.147: 98.19,38.95 105.54,31.6 105.78,31.6 108.53,28.84 127.22,28.84 127.52,28.55 127.52,28.43 127.65,28.3 128.13,28.3 128.26,28.43 128.26,28.57 128.53,28.84 129.23,28.84 129.5,28.57 129.5,28.43 129.63,28.3 130.11,28.3 130.24,28.43 130.24,28.57 130.51,28.84 131.21,28.84 131.48,28.57 131.48,28.45 131.63,28.3 132.07,28.3 132.22,28.45 132.22,28.57 132.5,28.84 133.19,28.84 133.46,28.57 133.46,28.45 133.61,28.3 134.05,28.3 134.2,28.45 134.2,28.55 134.5,28.84 135.15,28.84 135.45,28.55 135.45,28.45 135.59,28.3 137.75,28.3 139.07,29.62 141.95,29.62 142.12,29.78 142.12,30.01 141.88,30.25 v1(141.71,30.25)
  BOTTOM w0.14: v1(141.71,30.25) 141.87,30.25 142.13,30 142.13,29.85 142.05,29.77 140.84,29.77 139.35,31.25 139.35,31.89 138.93,32.31 138.83,32.31 138.73,32.41 138.73,32.51 138.59,32.65 JDIMM2.186
DDR_A_MA0: length 52.6
  TOP w0.102: JDIMM1.98 140.52,59.05 139.49,60.09 v1(139.49,60.1) ; v1(100.1,56.96) 99.78,57.28 JCPU1.V8
  IN1 w0.089: v1(100.1,56.96) 100.43,57.3 102.2,57.3 102.57,57.67 102.57,57.73 103.06,58.21 103.12,58.21 103.6,58.7 103.6,58.76 104.17,59.33 109.81,59.33 109.89,59.24
  IN1 w0.208: 109.89,59.24 120.2,59.24 120.48,59.52 135.49,59.52 136.07,60.1 v1(139.49,60.1)
  BOTTOM w0.102: JDIMM2.98 139.17,59.05 139.39,59.27 139.59,59.27 139.9,58.96 140.18,58.96 140.36,59.13 140.36,59.23 v1(139.49,60.1)
DDR_A_MA1: length 62.7
  TOP w0.102: v1(142.54,60.1) 142.11,60.52 139.31,60.52 138.95,60.16 138.95,59.68 138.62,59.35 JDIMM1.97 ; v1(102.12,62.75) 101.87,62.53 JCPU1.AC6
  IN1 w0.089: 109.89,60.41 109.25,60.41 109.18,60.34 101.63,60.34 101.51,60.46 101.51,62.62 101.63,62.75 v1(102.12,62.75)
  IN1 w0.208: v1(142.54,60.1) 142.54,60.83 142.66,60.96 145.14,60.96 145.27,61.08 145.27,61.67 145.14,61.8 141.54,61.8 141.41,61.67 141.41,61.39 141.28,61.26 133.57,61.26 133.02,61.81 121.29,61.81 121.09,61.61 121.09,60.78 121,60.68 120,60.68 119.72,60.41 109.89,60.41
  BOTTOM w0.102: v1(142.54,60.1) 143.28,59.35 JDIMM2.97
DDR_A_MA2: length 72.9
  TOP w0.102: JCPU1.V9 v1(99.12,56.75) ; JDIMM1.96 141.46,59.65 v1(141.01,60.1)
  IN1 w0.089: v1(99.12,56.75) 99.12,56.5 98.99,56.37 97.71,56.37 97.58,56.5 97.58,59.98 97.75,60.15 107.53,60.15 107.86,59.82 109.89,59.82
  IN1 w0.208: 109.89,59.82 119.96,59.82 120.24,60.1 121.46,60.1 121.67,60.31 121.67,61.02 121.88,61.23 122.3,61.23 122.51,61.02 122.51,60.31 122.71,60.1 123.13,60.1 123.34,60.31 123.34,61.02 123.55,61.23 123.96,61.23 124.17,61.02 124.17,60.31 124.38,60.1 124.8,60.1 125.01,60.31 125.01,61.02 125.21,61.23 125.63,61.23 125.84,61.02 125.84,60.31 126.05,60.1 126.46,60.1 126.67,60.31 126.67,61.02 126.88,61.23 127.3,61.23 127.5,61.02 127.5,60.31 127.71,60.1 128.23,60.1 128.35,60.23 128.35,61.1 128.48,61.23 129.15,61.23 129.27,61.1 129.27,60.23 129.4,60.1 129.96,60.1 130.17,60.31 130.17,61.1 130.3,61.23 130.88,61.23 131.01,61.1 131.01,60.31 131.21,60.1 131.63,60.1 131.84,60.31 131.84,61.1 131.97,61.23 132.54,61.23 132.67,61.1 132.67,60.31 132.88,60.1 135.25,60.1 135.83,60.68 141.13,60.68 141.26,60.55 141.26,60.22 141.13,60.1 v1(141.01,60.1)
  BOTTOM w0.102: v1(141.01,60.1) 140.55,60.56 139.12,60.56 138.87,60.31 138.87,59.88 138.64,59.65 JDIMM2.96
DDR_A_MA3: length 73.5
  TOP w0.102: v1(99.09,55.97) 98.79,56.28 JCPU1.U9 ; v1(143.93,60.1) 143.51,60.53 142.78,60.53 142.51,60.79 139.17,60.79 138.33,59.95 JDIMM1.95
  IN1 w0.089: 109.89,58.66 109.44,58.66 108.96,59.15 104.99,59.15 104.57,58.73 104.57,58.46 104.3,58.19 104.03,58.19 103.62,57.77 103.62,57.49 103.39,57.26 102.8,57.26 102.66,57.12 100.97,57.12 100.52,56.67 100.52,56.53 100.34,56.35 99.46,56.35 v1(99.09,55.97)
  IN1 w0.208: v1(143.93,60.1) 144.21,60.37 150.15,60.37 150.28,60.25 150.28,58.99 150.15,58.86 149.45,58.86 149.32,58.99 149.32,59.38 149.2,59.5 148.58,59.5 148.37,59.3 148.37,59.1 148.16,58.89 147.74,58.89 147.53,59.1 147.53,59.3 147.33,59.5 136.3,59.5 135.73,58.94 120.72,58.94 120.44,58.66 109.89,58.66
  BOTTOM w0.102: v1(143.93,60.1) 143.82,60.1 143.7,60.22 143.7,60.55 143.82,60.68 144.39,60.68 144.52,60.55 144.52,60.08 144.65,59.95 JDIMM2.95
DDR_A_MA4: length 64.8
  TOP w0.089: v1(103.05,62.65) 102.68,62.28 JCPU1.AC5
  TOP w0.102: JDIMM1.92 144.42,60.85 144.28,61 143.31,61 142.87,61.44 140.43,61.44 v1(139.48,62.39)
  IN1 w0.089: v1(103.05,62.65) 103.05,62.63 103.18,62.51 103.37,62.51 103.5,62.63 103.5,63.36 103.37,63.49 103.22,63.49 103.11,63.37 102.74,63.37 102.62,63.25 102.62,63.1 102.67,63.05 102.67,62.42 102.5,62.24 102.5,61.24 102.38,61.12 101.98,61.12 101.86,61 101.86,60.84 101.98,60.72 102.77,60.72 102.85,60.81 102.85,60.98 102.96,61.08 103.11,61.08 103.21,60.98 103.21,60.81 103.3,60.72 103.49,60.72 103.58,60.81 103.58,61.04 103.68,61.15 103.83,61.15 103.94,61.04 103.94,60.81 104.03,60.72 104.2,60.72 104.29,60.81 104.29,61.04 104.39,61.14 104.53,61.14 104.63,61.04 104.63,60.85 104.76,60.72 108.76,60.72 108.89,60.85 108.89,61.48
  IN1 w0.208: v1(139.48,62.39) 139.45,62.42 134.05,62.42 133.44,63.03 120.7,63.03 120.67,63 116.8,63 116.67,62.88 116.67,61.7 116.54,61.57 116.04,61.57 115.83,61.78 115.83,62.88 115.71,63 115.03,63 114.59,62.56 114.59,62.39 114.71,62.27 114.86,62.27 115,62.13 115,61.78 114.79,61.57 109.53,61.57 109.44,61.66 109.44,61.77 109.3,61.91 109.01,61.91 108.89,61.79 108.89,61.48
  BOTTOM w0.102: JDIMM2.92 137.6,60.85 138.73,60.85 138.91,61.04 141.16,61.04 141.28,61.17 141.28,61.76 141.16,61.89 139.57,61.89 139.44,62.01 139.44,62.35 v1(139.48,62.39)
DDR_A_MA5: length 66.7
  TOP w0.089: JCPU1.AC4 103.65,62.28 v1(104.12,62.75)
  TOP w0.102: JDIMM1.91 138.63,61.15 138.76,61.29 139.3,61.29 139.42,61.4 139.42,61.77 139.02,62.16 139.02,62.48 139.33,62.79 142.08,62.79 142.4,62.47 v1(142.4,62.39)
  IN1 w0.089: v1(104.12,62.75) 104.2,62.83 104.2,63.07 104.07,63.19 103.81,63.19 103.68,63.07 103.68,62.53 103.78,62.43 103.91,62.43 104.02,62.32 104.02,62.19 103.73,61.9 103.55,61.9 103.45,62 103.45,62.18 103.36,62.27 102.83,62.27 102.73,62.16 102.73,61.39 102.85,61.26 103.35,61.26 103.44,61.35 103.44,61.5 103.56,61.63 103.71,61.63 103.83,61.51 103.83,61.4 103.92,61.32 104.39,61.32 104.52,61.44 104.52,61.89 104.64,62.01 104.81,62.01 104.94,61.89 104.94,61.68 105.06,61.55 105.28,61.55 105.37,61.46 105.37,61.33 105.28,61.24 104.92,61.24 104.82,61.14 104.82,61.01 104.92,60.92 105.41,60.92 105.56,61.07 105.77,61.07 105.92,60.92 107.44,60.92 107.56,61.04 107.56,61.16 107.69,61.28 107.82,61.28 107.95,61.16 107.95,61.03 108.07,60.91 108.54,60.91 108.67,61.03 108.67,61.22 108.54,61.35 108.18,61.35 108.09,61.45 108.09,61.59 108.18,61.68 108.34,61.68 108.47,61.81 108.47,61.97 108.66,62.15 108.87,62.15 109,62.28 109,62.43 109.11,62.55 109.27,62.55 109.38,62.43 109.38,62.28 109.51,62.15 109.89,62.15
  IN1 w0.208: 109.89,62.15 113.86,62.15 114.01,62.29 114.01,62.8 114.79,63.58 120.43,63.58 120.46,63.61 133.68,63.61 134.29,63.01 141.1,63.01 141.25,62.86 141.85,62.86 141.99,63.01 142.44,63.01 142.57,62.88 142.57,62.52 142.44,62.39 v1(142.4,62.39)
  BOTTOM w0.102: v1(142.4,62.39) 142.4,62.22 142.25,62.06 141.94,62.06 141.82,61.94 141.82,60.79 141.94,60.67 142.15,60.67 142.27,60.79 142.27,61.03 142.4,61.15 142.61,61.15 142.72,61.05 142.72,60.9 142.84,60.78 143,60.78 143.12,60.9 143.12,61.05 143.22,61.15 145.79,61.15 JDIMM2.91
DDR_A_MA6: length 65.9
  TOP w0.089: JCPU1.AD6 101.65,63.28 v1(102.12,63.75)
  TOP w0.102: v1(140.88,62.39) 140.65,62.39 140.52,62.27 140.52,62.08 140.65,61.95 143.42,61.95 143.52,61.86 143.52,61.6 143.65,61.48 143.84,61.48 143.96,61.6 143.96,61.8 144.08,61.91 144.24,61.91 144.36,61.8 144.36,61.58 144.48,61.45 JDIMM1.90
  IN1 w0.089: 109.89,60.99 109.27,60.99 109.14,60.86 109.14,60.66 109.01,60.53 101.81,60.53 101.68,60.66 101.68,62.24 101.81,62.37 102.37,62.37 102.5,62.49 102.5,62.98 102.22,63.26 102.02,63.26 101.71,62.95 101.55,62.95 101.43,63.06 101.43,63.22 101.96,63.75 v1(102.12,63.75)
  IN1 w0.208: 109.89,60.99 117.04,60.99 117.25,61.2 117.25,62.29 117.38,62.42 117.96,62.42 118.08,62.29 118.08,61.2 118.29,60.99 118.79,60.99 118.96,61.15 118.96,61.66 118.96,62.29 119.08,62.42 119.63,62.42 119.76,62.29 119.76,61.39 119.88,61.27 120.38,61.27 120.51,61.39 120.51,62.26 120.64,62.39 133.26,62.39 133.81,61.84 140.78,61.84 140.9,61.97 140.9,62.37 v1(140.88,62.39)
  BOTTOM w0.102: v1(140.88,62.39) 140.99,62.39 141.12,62.52 141.12,62.76 141.25,62.89 141.52,62.89 141.65,63.02 141.65,63.24 141.52,63.37 140.89,63.37 140.76,63.24 140.76,63.08 140.64,62.95 139.38,62.95 138.95,62.52 138.95,61.76 138.64,61.45 137.6,61.45 JDIMM2.90
DDR_A_MA7: length 66
  TOP w0.089: JCPU1.AC3 104.61,62.28 v1(105.08,62.75)
  TOP w0.102: JDIMM1.86 144.4,62.65 143.49,63.57 141,63.57 139.99,64.58 v1(139.99,64.78)
  IN1 w0.089: v1(105.08,62.75) 105.34,62.75 105.46,62.86 105.46,63.02 105.34,63.13 105.16,63.13 105.09,63.2 105.09,63.31 105.35,63.57 105.5,63.57 105.56,63.51 105.56,63.36 105.62,63.29 105.77,63.29 105.85,63.22 105.85,63.03 105.75,62.92 105.75,62.66 105.62,62.53 105.44,62.53 105.32,62.41 105.32,62.27 105.54,62.05 105.69,62.05 105.95,62.32 106.08,62.32 106.49,61.91 106.65,61.91 106.87,62.12 107.3,62.12 107.46,61.96 107.58,61.96 107.74,62.12 107.87,62.12 108,62.25 108,62.39 108.14,62.53 108.28,62.53 108.94,63.19 109.43,63.19 109.54,63.31 109.54,63.55 109.89,63.9
  IN1 w0.208: v1(139.99,64.78) 139.96,64.75 136.1,64.75 135.49,65.36 132.89,65.36 132.76,65.49 132.76,65.86 132.64,65.99 132.2,65.99 132.08,65.86 132.08,65.49 131.95,65.36 131.43,65.36 131.3,65.49 131.3,66 131.17,66.13 130.67,66.13 130.54,66 130.54,65.49 130.42,65.36 129.84,65.36 129.71,65.49 129.71,66 129.58,66.13 129,66.13 128.88,66 128.88,65.49 128.75,65.36 128.17,65.36 128.04,65.49 128.04,66 127.92,66.13 127.34,66.13 127.21,66 127.21,65.49 127.08,65.36 126.5,65.36 126.38,65.49 126.38,66 126.25,66.13 125.67,66.13 125.54,66 125.54,65.49 125.42,65.36 124.84,65.36 124.71,65.49 124.71,66 124.58,66.13 124,66.13 123.88,66 123.88,65.49 123.75,65.36 123.17,65.36 123.04,65.49 123.04,66 122.92,66.13 122.34,66.13 122.21,66 122.21,65.49 122.08,65.36 121.51,65.36 121.38,65.49 121.38,66 121.25,66.13 120.67,66.13 120.55,66 120.55,65.49 120.42,65.36 119.84,65.36 119.71,65.49 119.71,66 119.59,66.13 119.01,66.13 118.88,66 118.88,65.54 118.67,65.33 114.07,65.33 112.63,63.9 109.89,63.9
  BOTTOM w0.102: JDIMM2.86 138.54,62.65 139.43,63.54 139.43,63.82 139.56,63.94 139.75,63.94 139.87,63.82 139.87,63.57 140,63.45 140.22,63.45 140.34,63.57 140.34,63.79 140.47,63.92 140.87,63.92 140.99,64.04 140.99,64.21 140.87,64.34 139.75,64.34 139.63,64.46 139.63,64.62 139.76,64.74 139.95,64.74 v1(139.99,64.78)
DDR_A_MA8: length 66.8
  TOP w0.102: v1(102.94,63.75) 102.59,63.44 JCPU1.AD5 ; JDIMM1.89 138.33,61.75 138.79,62.22 138.79,62.55 139.24,62.99 143.02,62.99 v1(143.62,62.39)
  IN1 w0.089: 109.89,62.73 108.98,62.73 107.94,61.69 107.85,61.69 107.27,61.12 105.97,61.12 104.89,62.2 104.82,62.2 104.5,62.51 104.5,63.02 104.15,63.37 103.84,63.37 103.47,63.75 v1(102.94,63.75)
  IN1 w0.208: 109.89,62.73 113.12,62.73 114.55,64.17 120.19,64.17 120.22,64.2 133.92,64.2 134.53,63.59 142.79,63.59 143.34,63.04 146.47,63.04 147.09,62.42 147.09,61.2 146.96,61.07 146,61.07 145.87,61.2 145.87,62.15 145.63,62.39 v1(143.62,62.39)
  BOTTOM w0.102: JDIMM2.89 144.61,61.75 144.56,61.8 144.56,62.34 144.45,62.46 144.28,62.46 144.17,62.34 144.17,61.69 144.1,61.63 142.78,61.63 142.72,61.69 142.72,61.86 142.84,61.99 143.32,61.99 143.61,62.28 143.61,62.38 v1(143.62,62.39)
DDR_A_MA9: length 64.3
  TOP w0.089: JCPU1.AC2 105.78,62.09 105.97,62.09 106.12,62.24 v1(106.12,62.75)
  TOP w0.102: v1(141.21,64.78) 141.38,64.78 141.46,64.86 141.46,65.1 141.4,65.16 139.83,65.16 139.36,64.69 139.36,64.18 139.49,64.06 139.84,64.06 139.96,63.93 139.96,63.68 139.84,63.55 139.11,63.55 138.52,62.95 JDIMM1.85
  IN1 w0.089: v1(106.12,62.75) 106.12,62.53 106.35,62.3 106.47,62.3 106.52,62.35 106.52,62.53 106.61,62.62 106.7,62.62 106.79,62.53 106.79,62.37 106.86,62.3 107.73,62.3 107.82,62.38 107.82,62.5 107.56,62.76 107.56,62.88 107.69,63.01 107.81,63.01 108.08,62.74 108.23,62.74 108.33,62.84 108.33,62.99 108.03,63.29 108.03,63.44 108.13,63.54 108.28,63.54 108.59,63.24 108.73,63.24 108.84,63.34 108.84,63.49 108.21,64.12 108.21,64.21 108.37,64.36 108.47,64.36 109.21,63.62 109.36,63.62 109.46,63.72 109.46,63.87 108.74,64.59 108.74,64.74 109.04,65.03 109.04,65.1 108.94,65.2 108.94,65.33 109.06,65.45 109.18,65.45 109.64,65 109.64,64.89 109.33,64.58 109.33,64.48 109.52,64.29 109.65,64.29 109.84,64.48 109.89,64.48
  IN1 w0.208: 109.89,64.48 112.39,64.48 113.83,65.91 114.66,65.91 114.79,66.04 114.79,66.17 114.92,66.3 115.55,66.3 115.67,66.17 115.67,66.04 115.8,65.91 116.46,65.91 116.58,66.04 116.58,66.17 116.71,66.3 117.29,66.3 117.42,66.17 117.42,66.04 117.54,65.91 118.17,65.91 118.3,66.04 118.3,66.58 118.43,66.71 133.18,66.71 133.31,66.58 133.31,66.07 133.43,65.94 133.73,65.94 133.94,66.15 133.94,66.5 134.15,66.71 134.5,66.71 134.63,66.58 134.63,66.07 134.76,65.94 135.11,65.94 135.24,66.07 135.24,66.44 135.37,66.57 135.67,66.57 135.8,66.44 135.8,66.07 135.92,65.94 136.08,65.94 136.2,65.81 136.2,65.56 136.2,65.47 136.34,65.33 141.32,65.33 141.45,65.21 141.45,64.91 141.32,64.78 v1(141.21,64.78)
  BOTTOM w0.102: v1(141.21,64.78) 141.58,64.41 141.58,64.06 142.68,62.95 JDIMM2.85
DDR_A_MA10: length 68.7
  TOP w0.089: JCPU1.V6 v1(102.12,56.75)
  TOP w0.102: JDIMM1.107 138.51,56.35 138.77,56.62 138.92,56.62 139.06,56.48 139.06,56.37 138.87,56.17 138.87,56.05 139.05,55.88 139.18,55.88 139.39,56.09 140.6,56.09 140.71,55.98 140.71,55.83 140.6,55.72 140.07,55.72 139.94,55.59 139.82,55.59 139.75,55.66 139.54,55.66 139.37,55.48 139.37,55.43 v1(139.48,55.31)
  IN1 w0.089: v1(102.12,56.75) 102.12,56.82 101.99,56.94 101.62,56.94 101.5,56.82 101.5,56.32 101.62,56.2 101.8,56.2 101.91,56.31 102.1,56.31 102.22,56.2 102.38,56.2 102.47,56.28 102.47,56.52 102.57,56.62 102.72,56.62 102.83,56.52 102.83,56.28 102.91,56.2 103.4,56.2 103.52,56.07 103.52,55.28 103.65,55.15 107.46,55.15 107.91,54.71
  IN1 w0.208: 107.91,54.71 107.92,54.7 108.49,54.7 108.61,54.81 108.61,55.1 108.71,55.2 109.19,55.2 109.53,54.86 113.82,54.86 113.95,54.73 113.95,53.96 114.08,53.83 114.66,53.83 114.79,53.96 114.79,54.65 115,54.86 115.41,54.86 115.62,54.65 115.62,53.33 115.75,53.2 116.33,53.2 116.45,53.33 116.45,54.65 116.66,54.86 117.08,54.86 117.29,54.65 117.29,53.33 117.41,53.2 117.99,53.2 118.12,53.33 118.12,54.65 118.33,54.86 118.74,54.86 118.95,54.65 118.95,53.33 119.08,53.2 119.66,53.2 119.79,53.33 119.79,54.65 119.99,54.86 120.41,54.86 120.62,54.65 120.62,53.33 120.75,53.2 121.28,53.2 121.41,53.33 121.41,54.01 121.53,54.13 121.82,54.13 122.12,53.83 127.99,53.83 128.42,54.26 130.65,54.26 131.02,54.63 135.07,54.63 135.58,55.14 137.49,55.14 137.58,55.23 139.4,55.23 v1(139.48,55.31)
  BOTTOM w0.102: v1(139.48,55.31) 140.52,56.35 145.79,56.35 JDIMM2.107
DDR_A_MA11: length 63.8
  TOP w0.102: JCPU1.AC1 v1(107.12,62.75) ; v1(142.66,64.78) 142.54,64.78 142.41,64.65 142.41,64.15 142.54,64.02 144.49,64.02 144.6,63.91 144.6,63.77 144.49,63.66 144.22,63.66 144.08,63.52 144.08,63.42 144.25,63.25 JDIMM1.84
  IN1 w0.089: v1(107.12,62.75) 107.15,62.75 107.85,63.44 107.85,64.1 108.74,64.99 108.74,65.39 108.99,65.63 109.25,65.63 109.83,65.06 109.89,65.06
  IN1 w0.208: v1(142.66,64.78) 143.23,65.33 144.65,65.33 144.69,65.29 148,65.29 148.13,65.41 148.13,65.79 148,65.91 137.14,65.91 135.77,67.29 117.82,67.29 117.41,66.88 113.97,66.88 112.15,65.06 109.89,65.06
  BOTTOM w0.102: JDIMM2.84 138.55,63.25 139.05,63.75 139.05,64.62 139.67,65.24 142.2,65.24 v1(142.66,64.78)
DDR_A_MA12: length 67
  TOP w0.102: v1(144.03,64.78) 143.99,64.78 143.42,65.35 139.75,65.35 138.87,64.47 138.87,64.13 138.29,63.55 JDIMM1.83 ; JCPU1.AD4 v1(104.12,63.75)
  IN1 w0.089: 109.89,63.31 109.83,63.31 109.5,62.98 108.98,62.98 107.87,61.87 107.78,61.87 107.25,61.35 105.99,61.35 104.97,62.37 104.89,62.37 104.67,62.59 104.67,63.19 v1(104.12,63.75)
  IN1 w0.208: 109.89,63.31 112.87,63.31 114.31,64.75 119.95,64.75 119.98,64.78 135.25,64.78 135.86,64.17 143.03,64.17 143.55,63.65 147.96,63.65 148.09,63.52 148.63,63.52 148.75,63.65 148.75,64.58 148.63,64.7 144.1,64.7 v1(144.03,64.78)
  BOTTOM w0.102: v1(144.03,64.78) 144.03,64.34 143.9,64.21 143.06,64.21 142.93,64.08 142.93,63.68 143.06,63.55 JDIMM2.83
DDR_A_MA13: length 59.3
  TOP w0.102: JDIMM1.119 138.59,52.75 138.8,52.55 141.76,52.55 142.69,53.48 v1(142.71,53.48) ; JCPU1.V7 v1(101.12,56.75)
  IN1 w0.089: v1(101.12,56.75) 100.99,56.75 100.39,56.14 99.99,56.14 99.75,55.9 99.75,55.59 100.11,55.23 100.17,55.23 100.64,54.76 100.64,54.7 101.15,54.19 101.21,54.19 101.56,53.84 101.56,53.78 102.08,53.26 102.14,53.26 102.62,52.77 102.62,52.71 102.97,52.37 107.62,52.37 107.83,52.16 109.46,52.16 109.84,51.78 109.89,51.78
  IN1 w0.208: 109.89,51.78 112.02,51.78 114.31,49.48 124.18,49.48 125.02,50.32 127.38,50.32 127.98,50.92 129.19,50.92 129.63,51.35 131.97,51.35 132.34,51.72 136.28,51.72 136.57,52.01 141.76,52.01 142.71,52.96 v1(142.71,53.48)
  BOTTOM w0.102: JDIMM2.119 145.79,52.75 143.44,52.75 v1(142.71,53.48)
DDR_A_MA14: length 66.3
  TOP w0.102: v1(143.48,67.08) 143.48,66.98 143.58,66.88 143.58,66.72 143.46,66.6 142.55,66.6 142.43,66.47 142.43,66.28 142.55,66.15 142.81,66.15 142.93,66.03 142.93,65.94 143.06,65.81 143.16,65.81 143.29,65.94 143.29,66.03 143.42,66.15 143.58,66.15 143.71,66.03 143.71,65.35 143.84,65.23 144.32,65.23 144.59,64.96 144.59,64.73 144.86,64.45 JDIMM1.80 ; v1(104.98,63.75) 104.59,63.4 JCPU1.AD3
  IN1 w0.089: 109.89,65.64 109.83,65.64 109.66,65.81 108.91,65.81 108.56,65.46 108.56,65.06 107.67,64.17 107.67,63.52 107.28,63.12 106.2,63.12 105.57,63.75 v1(104.98,63.75)
  IN1 w0.208: 109.89,65.64 111.91,65.64 113.73,67.46 117.17,67.46 117.58,67.87 136.01,67.87 137.39,66.5 147.56,66.5 147.69,66.62 147.69,67.47 147.56,67.6 146.93,67.6 146.81,67.47 146.81,67.2 146.68,67.08 v1(143.48,67.08)
  BOTTOM w0.102: JDIMM2.80 138.55,64.45 139.87,65.77 142.17,65.77 v1(143.48,67.08)
DDR_A_MA15: length 64.2
  TOP w0.089: v1(106.12,63.75) 105.65,63.28 JCPU1.AD2
  TOP w0.102: v1(140.43,67.08) 140.9,67.55 143.59,67.55 144.23,66.91 144.23,65.85 145.02,65.05 JDIMM1.78
  IN1 w0.089: 109.89,66.22 109.66,66.22 109.54,66.1 109.19,66.1 109.15,66.14 108.89,66.14 108.39,65.63 108.39,65.22 107.5,64.33 107.5,63.59 107.2,63.3 106.28,63.3 106.12,63.46 v1(106.12,63.75)
  IN1 w0.208: 109.89,66.22 111.67,66.22 113.49,68.04 116.93,68.04 117.34,68.46 119.26,68.46 119.46,68.66 119.46,69.02 119.59,69.15 120.17,69.15 120.3,69.02 120.3,68.58 120.42,68.46 121,68.46 121.13,68.58 121.13,69.35 121.26,69.48 121.84,69.48 121.96,69.35 121.96,68.58 122.09,68.46 122.67,68.46 122.8,68.58 122.8,69.35 122.92,69.48 123.5,69.48 123.63,69.35 123.63,68.58 123.76,68.46 124.34,68.46 124.46,68.58 124.46,69.35 124.59,69.48 125.17,69.48 125.3,69.35 125.3,68.58 125.42,68.46 126,68.46 126.13,68.58 126.13,69.35 126.26,69.48 126.84,69.48 126.96,69.35 126.96,68.58 127.09,68.46 127.67,68.46 127.8,68.58 127.8,69.35 127.92,69.48 128.5,69.48 128.63,69.35 128.63,68.58 128.76,68.46 129.34,68.46 129.46,68.58 129.46,69.35 129.59,69.48 130.17,69.48 130.3,69.35 130.3,68.58 130.42,68.46 130.87,68.46 131,68.58 131,68.81 131.12,68.94 131.57,68.94 131.69,68.81 131.69,68.58 131.82,68.46 136.25,68.46 137.63,67.08 v1(140.43,67.08)
  BOTTOM w0.102: JDIMM2.78 138.43,65.05 138.97,65.59 138.97,66.03 139.09,66.15 139.4,66.15 139.53,66.28 139.53,66.55 139.66,66.67 139.89,66.67 140.01,66.55 140.01,66.38 140.14,66.25 140.92,66.25 141.04,66.38 141.04,66.61 140.92,66.74 140.56,66.74 140.43,66.86 v1(140.43,67.08)
DDR_A_RAS#: length 64.3
  TOP w0.102: JCPU1.U6 101.63,56.28 v1(102.12,55.78) ; JDIMM1.110 144.79,55.45 144.45,55.79 144.19,55.79 144.09,55.89 144.09,56.16 143.97,56.28 143.8,56.28 143.68,56.16 143.68,55.89 143.58,55.79 143.46,55.79 143.33,55.92 143.33,56.16 143.21,56.28 143.04,56.28 142.92,56.16 142.92,55.9 142.53,55.51 v1(142.53,55.31)
  IN1 w0.089: 109.89,53.52 108.09,53.52 107.47,54.15 102.76,54.15 102.5,54.41 102.5,55.41 v1(102.12,55.78)
  IN1 w0.208: 109.89,53.52 112.74,53.52 115.04,51.22 123.46,51.22 124.3,52.07 126.66,52.07 127.25,52.66 128.47,52.66 128.9,53.1 131.25,53.1 131.62,53.47 135.55,53.47 136.06,53.97 137.97,53.97 138.06,54.07 143.23,54.07 143.35,53.94 143.35,53.34 143.48,53.21 145.39,53.21 145.51,53.34 145.51,53.86 145.39,53.99 144.01,53.99 143.89,54.11 143.89,54.66 143.76,54.79 142.66,54.79 142.53,54.91 v1(142.53,55.31)
  BOTTOM w0.102: v1(142.53,55.31) 142.35,55.31 141.97,54.93 141.21,54.93 140.67,54.39 139.1,54.39 138.81,54.68 138.81,55.03 138.66,55.18 138.66,55.2 138.41,55.45 JDIMM2.110
DDR_A_WE#: length 61.1
  TOP w0.089: JCPU1.U7 v1(101.12,55.75)
  TOP w0.102: v1(139.64,53.48) 139.64,53.83 139.77,53.96 141.42,53.96 141.54,54.08 141.54,54.24 141.42,54.36 139.54,54.36 139.33,54.14 139.04,54.14 138.91,54.27 138.91,54.43 138.78,54.55 JDIMM1.113
  IN1 w0.089: v1(101.12,55.75) 101.12,55.6 100.99,55.47 100.67,55.47 100.54,55.6 100.54,56.05 100.75,56.25 101.32,56.25 101.71,55.86 101.71,54.45 101.82,54.35 102.31,54.35 102.72,53.93 102.72,53.52 102.89,53.35 103.28,53.35 103.46,53.53 103.77,53.53 103.95,53.35 104.27,53.35 104.47,53.54 104.79,53.54 104.99,53.35 105.28,53.35 105.46,53.53 105.8,53.53 105.98,53.35 107.68,53.35 107.78,53.25
  IN1 w0.208: 107.78,53.25 108.56,53.25 108.69,53.12 108.69,52.72 108.82,52.6 109.14,52.6 109.27,52.72 109.27,52.98 109.39,53.11 109.6,53.11 109.77,52.94 112.5,52.94 114.8,50.64 123.7,50.64 124.54,51.49 126.9,51.49 127.49,52.08 128.71,52.08 129.15,52.52 131.49,52.52 131.86,52.89 135.79,52.89 135.96,53.05 136.3,53.39 136.75,53.39 136.96,53.18 137.48,53.18 137.68,53.38 138.4,53.38 138.6,53.18 139.13,53.18 139.44,53.48 v1(139.64,53.48)
  BOTTOM w0.102: v1(139.64,53.48) 139.64,53.84 139.76,53.96 140.91,53.96 141.38,54.43 144.59,54.43 144.71,54.55 145.79,54.55 JDIMM2.113
DDR_B_BS0: length 84.1
  TOP w0.102: v1(156.03,55.9) 155.05,54.93 152.94,54.93 152.11,55.76 JDIMM3.109 ; JCPU1.R7 v1(101.12,53.75)
  IN3 w0.089: v1(101.12,53.75) 101.71,54.34 101.71,54.87 101.99,55.15 102.27,55.15 102.71,55.59 102.71,55.94 102.95,56.17 103.36,56.17 103.54,56.35 107.6,56.35 109.04,54.91 109.89,54.91
  IN3 w0.178: v1(156.03,55.9) 156.22,55.9 156.35,55.78 156.35,55.51 156.22,55.39 151.79,55.39 151.17,54.77 145.59,54.77 144.84,54.02 140.39,54.02 140.21,54.2 129.09,54.2 128.83,53.95 128.83,52.89 128.66,52.71 128.3,52.71 128.12,52.89 128.12,54.79 128,54.91 127.54,54.91 127.41,54.79 127.41,52.89 127.23,52.71 126.88,52.71 126.7,52.89 126.7,54.79 126.57,54.91 126.12,54.91 125.99,54.79 125.99,52.89 125.81,52.71 125.46,52.71 125.28,52.89 125.28,54.79 125.15,54.91 124.69,54.91 124.57,54.79 124.57,52.89 124.39,52.71 116.45,52.71 114.25,54.91 109.89,54.91
  BOTTOM w0.102: v1(156.03,55.9) 155.79,55.9 155.66,56.03 155.66,56.33 155.79,56.46 157.71,56.46 158.41,55.76 JDIMM4.109
DDR_B_BS1: length 86.5
  TOP w0.102: v1(152.98,55.9) 153.56,56.47 157.87,56.47 158.28,56.06 JDIMM3.108 ; JCPU1.P8 v1(100.12,52.75)
  IN3 w0.089: v1(100.12,52.75) 100.36,52.75 100.75,53.13 100.75,53.93 101.1,54.29 101.3,54.29 101.52,54.51 101.52,54.97 101.86,55.3 101.86,55.3 101.88,55.33 102.19,55.33 102.52,55.65 102.52,56 102.87,56.35 103.29,56.35 103.52,56.58 103.52,56.94 103.74,57.16 107.3,57.16 109.05,55.41 109.89,55.41
  IN3 w0.178: v1(152.98,55.9) 151.58,55.9 150.94,55.27 145.38,55.27 144.63,54.52 140.6,54.52 140.42,54.7 131.11,54.7 130.4,55.41 124.13,55.41 124,55.28 124,53.39 123.82,53.21 123.47,53.21 123.29,53.39 123.29,55.28 123.16,55.41 122.71,55.41 122.58,55.28 122.58,53.39 122.4,53.21 122.05,53.21 121.87,53.39 121.87,55.28 121.74,55.41 121.28,55.41 121.16,55.28 121.16,53.39 120.98,53.21 120.62,53.21 120.45,53.39 120.45,55.28 120.32,55.41 119.86,55.41 119.74,55.28 119.74,53.39 119.56,53.21 116.65,53.21 114.45,55.41 109.89,55.41
  BOTTOM w0.102: JDIMM4.108 152.4,56.06 152.52,56.19 152.52,56.84 152.65,56.97 154.34,56.97 154.47,56.84 154.47,56.55 154.34,56.42 153.11,56.42 152.98,56.3 v1(152.98,55.9)
DDR_B_BS2: length 81.4
  TOP w0.102: v1(153.63,66.61) 153.63,66.3 153.35,66.03 153.21,66.03 152.95,66.28 152.95,66.37 153.17,66.58 153.17,66.72 153.07,66.82 152.93,66.82 152.45,66.35 152.45,66.2 152.92,65.74 152.92,65.59 152.08,64.76 JDIMM3.79 ; JCPU1.AA9 v1(99.12,59.75)
  IN3 w0.089: 109.89,66.5 108.41,66.5 107.25,65.35 101.94,65.35 101.63,65.66 101.63,65.8 101.3,66.13 100.87,66.13 100.69,65.95 100.69,61.32 v1(99.12,59.75)
  IN3 w0.178: 109.89,66.5 118.79,66.5 120.6,68.31 128.91,68.31 129.09,68.13 129.09,67.76 129.22,67.63 129.67,67.63 129.8,67.76 129.8,68.13 129.98,68.31 130.33,68.31 130.51,68.13 130.51,67.76 130.64,67.63 131.1,67.63 131.22,67.76 131.22,68.13 131.4,68.31 131.76,68.31 131.93,68.13 131.93,67.76 132.06,67.63 132.52,67.63 132.64,67.76 132.64,68.2 132.77,68.32 133.23,68.32 133.36,68.2 133.36,67.76 133.48,67.63 133.94,67.63 134.07,67.76 134.07,68.18 134.19,68.31 134.65,68.31 134.78,68.18 134.78,67.76 134.91,67.63 139.65,67.63 140.33,68.31 144.82,68.31 145.09,68.58 149.42,68.58 151.35,66.65 153.58,66.65 v1(153.63,66.61)
  BOTTOM w0.102: v1(153.63,66.61) 154.1,67.08 157.4,67.08 158.05,66.43 158.05,65.29 158.58,64.76 JDIMM4.79
DDR_B_CAS#: length 83.5
  TOP w0.102: v1(154.6,53.85) 154.84,53.85 154.97,53.72 154.97,53.48 154.84,53.35 152.76,53.35 152.16,53.95 151.21,53.95 JDIMM3.115 ; JCPU1.P7 v1(101.12,52.75)
  IN3 w0.089: v1(101.12,52.75) 101.12,53.02 101.25,53.15 102.27,53.15 102.52,53.4 102.52,54.11 102.78,54.37 103.28,54.37 103.53,54.63 103.53,55.05 103.83,55.34 107.77,55.34 109.2,53.92 109.89,53.92
  IN3 w0.178: 109.89,53.92 113.84,53.92 116.03,51.72 129.66,51.72 129.84,51.9 129.84,53.08 129.96,53.21 130.42,53.21 130.55,53.08 130.55,51.9 130.72,51.72 131.08,51.72 131.26,51.9 131.26,53.08 131.38,53.21 131.84,53.21 131.97,53.08 131.97,51.84 132.1,51.72 132.55,51.72 132.68,51.84 132.68,53.08 132.81,53.21 133.15,53.21 133.32,53.03 133.32,52.68 133.45,52.56 133.91,52.56 134.03,52.68 134.03,53.03 134.21,53.21 134.57,53.21 134.75,53.03 134.75,52.68 134.87,52.56 135.33,52.56 135.46,52.68 135.46,53.03 135.63,53.21 135.99,53.21 136.17,53.03 136.17,52.64 136.3,52.51 136.75,52.51 136.88,52.64 136.88,53.03 137.06,53.21 137.41,53.21 137.59,53.03 137.59,51.92 137.72,51.79 138.17,51.79 138.3,51.92 138.3,52.76 138.43,52.89 138.9,52.89 139.03,52.76 139.03,52.52 139.16,52.39 142.67,52.39 142.79,52.26 142.79,51.92 142.92,51.79 143.32,51.79 143.45,51.92 143.45,52.88 143.58,53.01 143.89,53.01 144.07,52.83 144.07,52.6 144.24,52.42 144.6,52.42 144.78,52.6 144.78,52.83 144.95,53.01 145.23,53.01 146,53.77 151.58,53.77 152.2,54.39 154.81,54.39 154.93,54.27 154.93,53.98 154.81,53.85 v1(154.6,53.85)
  BOTTOM w0.102: v1(154.6,53.85) 155.09,54.34 157.87,54.34 158.25,53.96 JDIMM4.115
DDR_B_D0: length 87.4
  TOP w0.102: JCPU1.AR18 v1(90.12,74.75)
  TOP w0.14: v1(153.04,90.17) 152.22,89.36 JDIMM3.5
  IN3 w0.089: v1(90.12,74.75) 90.5,75.12 91.1,75.12 91.52,75.55 91.52,76.18 92.6,77.25
  IN3 w0.127: v1(153.04,90.17) 150.68,92.54 145.02,92.54 143.08,94.48 140.3,94.48 139.04,93.22 138.87,93.22 138.23,93.86 138.05,93.86 137.87,93.68 137.87,93.5 138.51,92.86 138.51,92.68 138.25,92.43 138.07,92.43 136.88,93.62 136.7,93.62 136.52,93.44 136.52,93.26 137.71,92.07 137.71,91.89 137.54,91.71 137.36,91.71 136.16,92.9 135.98,92.9 135.8,92.72 135.8,92.55 135.92,92.43 135.92,92.25 135.74,92.07 135.56,92.07 135.44,92.19 135.26,92.19 131.1,88.02 99.83,88.02 96.12,84.31 96.12,80.78 92.6,77.25
  BOTTOM w0.14: JDIMM4.4 152.52,89.66 v1(153.04,90.17)
