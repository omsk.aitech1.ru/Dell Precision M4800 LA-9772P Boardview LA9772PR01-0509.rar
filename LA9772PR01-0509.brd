# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FDI_RCOMP: length 5
  TOP w0.254: UH1.AR44 38.82,109.17 39.44,109.79 v1(39.68,109.79)
  BOTTOM w0.102: v1(39.68,109.79) 39.67,109.79 38.92,110.54 v2(38.92,110.88)
  BOTTOM w0.254: 40.04,108.7 40.04,109.43 v1(39.68,109.79)
FFS_INT2: length 295.2
  TOP w0.076: 37.88,89.93 37.87,89.94 37.86,89.94 37.69,90.11 37.69,90.36 38.01,90.67 38.01,91.12
  TOP w0.102: v1(39.71,86.84) 39.71,87.07 38.03,88.75 38.03,89.46 37.91,89.58 37.91,89.9 37.91,89.9 37.91,89.91 37.88,89.93
  IN2 w0.127: v1(206.77,73.02) 206.39,73.02 205.52,73.89 205.52,81.33 205.11,81.74 205.11,87.46 203.36,89.22 203.36,91.75 199.2,95.91 197.53,95.91 194.88,98.56 188.28,98.56 183.05,103.8 143.12,103.8 141.5,105.42 131.28,105.42 129.78,103.92 125.46,103.92 123.94,102.4 121.77,102.4 121.07,103.1 107.72,103.1 106.83,102.21 93.49,102.21 92.58,103.12 90.56,103.12 90.05,102.61 81.3,102.61 79.47,100.79 74.24,100.79 72.14,98.69 71.87,98.69 70.19,97.01 69.43,97.01 67.8,95.39 67.8,92.5 66.53,91.22 65.13,91.22 64.4,91.96 56.14,91.96 56.02,92.09 49.77,92.09 45.31,87.63 43.29,87.63 43.02,87.36 40.23,87.36 v1(39.71,86.84)
  IN3 w0.127: v1(206.77,73.02) 206.77,57.09 207.71,56.14 211.24,56.14 215.63,51.75 215.63,47 212.26,43.64 197.6,43.64 195.87,45.36 178.96,45.36 177.56,46.76 174.34,46.76 173.72,47.38 170.9,47.38 v1(169.96,46.44)
  BOTTOM w0.102: Q29.2 171.71,47.92 170.24,46.44 v1(169.96,46.44) 168.49,46.44 168.13,46.09 168.13,45.12 R504.2 168.2,44.93 v2(168.2,43.99) U88.9
FFS_INT2_Q: length 34.1
  TOP w0.102: v1(169.63,72.83) 169.63,73.33 170.07,73.77 JSATA1.18
  IN1 w0.109: v1(171.66,45.45) 171.66,45.78 169.27,48.17 169.27,51.83 169.68,52.23 169.68,54.72 170.93,55.97 170.93,71.54 v1(169.63,72.83)
  BOTTOM w0.102: Q29.3 172.12,46.53 v2(171.66,46.07) v1(171.66,45.45)
FFS_PCH_INT: length 15.2
  TOP w0.102: UH1.M15 29.55,95.71 29.25,95.42 v1(29.25,95.42)
  BOTTOM w0.102: v1(29.25,95.42) 29.25,94.64 29.74,94.15 v2(29.74,94.13) 29.74,93.6 29.55,93.41 29.55,91.6 29.65,91.5 29.65,90.54 28.76,89.65 28.76,88.27 27.15,86.66 26.39,86.66 26.02,86.29 26.02,83.75 RH106.1
FWP#: length 13
  TOP w0.102: v2(113.99,157.34) 114.41,157.76 R872.2 113.95,158.2 110.92,158.2 110.64,157.92 107.1,157.92 106.49,158.53 106.49,159.04 v1(105.85,159.68)
  BOTTOM w0.102: U51.B65 106.25,160.75 106.26,160.74 106.26,160.08 v1(105.85,159.68)
GFX_CLK_REQ#: length 43.4
  TOP w0.102: v1(55.03,81.14) 55.03,81.87 56.07,82.92 56.07,91.51 55.26,92.31 v2(53.16,92.31) 52.47,92.31 QH3.1 51.93,92.86 RH128.1 ; UH1.AF6 35.5,91.72 v1(35.79,92.01)
  IN1 w0.109: v1(55.03,81.14) 54.52,80.63 52.82,80.63 52.36,81.09 52.36,82.54 50.25,84.65 48.73,84.65 46.15,87.24 46.15,87.44 44.88,88.71 43.01,88.71 42.78,88.48 41.79,88.48 40.52,89.75 38.82,89.75 37.75,90.82 37.04,90.82 36.69,91.17 36.31,91.17 35.79,91.69 v1(35.79,92.01)
GPIO103: length 4.3
  TOP w0.102: v1(101.84,153.22) 101.86,153.2 T138.1
  BOTTOM w0.102: v1(101.84,153.22) 101.79,153.22 101.07,153.95 101.07,154.03 100.84,154.26 100.5,154.26 100.26,154.03 100.26,153.67 100.04,153.45 99.65,153.45 99.58,153.52 U51.B37
GPIO_PSID_SELECT: length 255.6
  TOP w0.102: v1(5.69,84.05) 5.69,84.85 5.55,84.99 5.26,84.99 5.11,84.85 PU1.6
  IN2 w0.127: v1(219.06,70.93) 218.96,70.83 217.97,70.83 216.35,69.2 207.69,69.2 202.19,74.69 202.19,78.39 197.89,82.69 197.89,88.69 194.01,92.57 185.33,92.57 183.91,91.15 177.3,91.15 176.97,90.82 175.8,90.82 173.92,92.7 161.83,92.7 158.46,96.07 154.59,96.07 153.85,96.81 139.22,96.81 138.16,97.88 135.42,97.88 134.55,97.01 134.55,96.32 131.57,93.34 124.54,93.34 123.71,92.52 117.43,92.52 116.52,91.6 115.81,91.6 114.92,92.49 114.92,92.7 114.37,93.24 113.03,93.24 112.75,93.52 96.8,93.52 91.41,88.14 88.13,88.14 82.94,82.94 70.18,82.94 68,80.76 58.43,80.76 57.03,79.36 53.34,79.36 52.7,78.72 50.66,78.72 49.17,77.23 48.49,77.23 47.12,78.6 39.69,78.6 39.09,77.99 36.1,77.99 35.71,77.59 32.66,77.59 31.43,78.83 29.7,78.83 29.47,78.6 25.97,78.6 25.33,77.96 19.77,77.96 19.13,77.33 12.98,77.33 6.51,83.81 5.93,83.81 v1(5.69,84.05)
  BOTTOM w0.102: U46.A6 219.17,75.44 219.16,75.44 v2(219.16,71.77) 219.16,71.03 v1(219.06,70.93)
GPIOL5: length 2.9
  BOTTOM w0.102: U46.B1 221.92,76.35 222.28,75.98 T135.1
GPU_PWR_LEVEL: length 131.5
  IN3 w0.127: v1(227.57,82.03) 226.91,81.37 224.19,81.37 222.87,80.05 222.87,78.09 221.45,76.67 211.15,76.67 208.73,79.08 204.77,79.08 204.14,79.72 204.14,80.87 203.77,81.24 187.77,81.24 182.77,86.24 175.81,86.24 164.76,97.29 152.79,97.29 144.18,105.9 132.9,105.9 130.01,103.01 123.15,103.01 v1(122.72,103.44)
  BOTTOM w0.102: U46.A52 224.09,83.52 224.57,83.04 224.57,82.61 225.61,81.57 R782.1 226.53,82.08 227.52,82.08 v1(227.57,82.03) 228.1,81.49 v2(228.1,79.64) ; U17.2 v1(122.72,103.44)
GPU_SMBCLK: length 72.3
  TOP w0.102: v1(109.9,157.14) 109.98,157.21 110.22,157.21 110.49,156.94 110.89,156.94 R822.2
  IN1 w0.109: v1(114.22,101.28) 114.04,101.46 114.04,102.28 114.49,102.73 114.49,104.73 111.34,107.88 111.34,110.93 109.91,112.36 109.91,117.49 108.37,119.04 107.63,119.04 107.27,119.4 107.27,120.79 106.51,121.55 106.51,122.9 106.99,123.38 108.29,123.38 108.77,123.86 108.77,125 109.78,126.01 109.78,133.12 107.07,135.83 107.07,137.93 106.38,138.62 106.38,141.56 108.6,143.78 108.6,146.06 109.15,146.62 109.15,147.94 110.21,149 110.21,149.89 112.1,151.77 112.1,154.68 111.03,155.75 109.61,155.75 109.18,156.17 109.18,157.14 109.3,157.27 109.77,157.27 v1(109.9,157.14)
  BOTTOM w0.102: U51.A7 109.77,157.27 v1(109.9,157.14) ; v1(114.22,101.28) 114.22,100.84 114.7,100.35 Q295.3
GPU_SMBCLK_R: length 9
  TOP w0.102: JMXM1.70 116,97.51 116.14,97.65 116.14,97.78 v1(115.96,97.95)
  BOTTOM w0.102: Q295.4 112.49,100.35 112.3,100.16 R1.2 112.33,99.76 115.32,99.76 115.58,100.01 v2(115.81,100.01) 115.96,100.01 116.14,99.83 116.14,98.13 v1(115.96,97.95)
GPU_SMBDAT: length 77.8
  TOP w0.102: v1(106.74,157.16) 107.15,157.57 110.19,157.57 110.59,157.17 110.87,157.17 R829.2
  IN1 w0.109: v1(113.64,101.26) 113.8,101.42 113.8,102.38 114.26,102.83 114.26,104.63 111.11,107.78 111.11,110.83 109.68,112.26 109.68,117.39 108.27,118.8 107.53,118.8 107.03,119.3 107.03,120.69 106.27,121.45 106.27,122.99 106.9,123.61 108.19,123.61 108.54,123.96 108.54,125.1 109.54,126.11 109.54,133.02 106.83,135.73 106.83,137.83 106.15,138.52 106.15,141.66 108.37,143.88 108.37,146.16 108.92,146.71 108.92,148.03 109.98,149.1 109.98,149.98 111.86,151.87 111.86,154.58 110.94,155.51 109.51,155.51 108.94,156.08 108.94,157.07 108.47,157.54 107.43,157.54 107.04,157.16 v1(106.74,157.16)
  BOTTOM w0.102: Q295.6 113.25,101.65 113.65,101.26 v1(113.64,101.26) ; U51.B7 107.1,157.52 v1(106.74,157.16)
GPU_SMBDAT_R: length 8.9
  TOP w0.102: JMXM1.68 116.5,97.51 116.36,97.65 116.36,97.77 v1(116.54,97.95)
  BOTTOM w0.102: Q295.1 114.9,102.51 v2(115.07,102.68) 115.53,102.68 R2.2 116.39,102.22 117.18,101.43 117.18,100.84 116.37,100.02 116.37,98.13 v1(116.54,97.95)
GREEN_CRT: length 14.9
  TOP w0.102: L2.1 74.2,165.47 74.01,165.28 C23.1 R54.1 74.79,163.15 75.4,163.15 75.81,162.74 v1(75.81,162.53)
  BOTTOM w0.102: v1(75.81,162.53) 75.81,162.75 76.68,163.61 76.83,163.61 76.96,163.49 76.96,163.19 77.08,163.07 77.35,163.07 77.48,163.19 77.48,163.49 77.61,163.61 v2(78.29,163.61) 81.72,163.61 82.2,163.13 U19.32
GREEN_CRT_L: length 6.1
  TOP w0.102: L2.2 74.3,166.61 v2(74.3,167.47) JCRT1.2
GREEN_DOCK: length 49.3
  TOP w0.102: v1(87.54,120.25) 87.87,120.25 v2(90.86,123.25) 92.24,124.62 92.24,130.16 90.29,132.11 90.29,134.37 89.57,135.09 89.39,135.27 89.04,135.27 87.58,136.74 87.58,139.77 85.53,141.82 85.53,152.66 85.1,153.1 85.1,154.95 84.01,156.04 81.44,156.04 80.5,156.98 v1(80.25,156.98)
  BOTTOM w0.102: U19.23 80.42,157.15 v1(80.25,156.98) ; v1(87.54,120.25) 87.99,120.25 88.7,119.54 JDOCK1.59
H_CATERR#: length 19.7
  TOP w0.102: v1(75.12,72.75) JCPU1.AN32
  BOTTOM w0.102: RC128.2 60.33,78.5 v2(61.5,78.5) 67.05,78.5 69.63,75.92 69.63,73.73 69.97,73.39 71.09,73.39 71.72,72.76 72.55,72.76 72.96,72.35 74.72,72.35 v1(75.12,72.75)
H_CPU_RSVD: length 16.6
  TOP w0.102: v1(81.12,46.75) JCPU1.G26
  BOTTOM w0.102: v1(81.12,46.75) 81.12,46.2 82.58,44.74 82.58,41.68 83.08,41.18 83.35,41.18 83.66,40.87 83.66,40.61 85.12,39.15 86.9,39.15 v2(88.89,37.16) 89.44,36.61 RC59.1
H_CPU_SVIDALRT#: length 9.8
  TOP w0.102: v1(80.12,75.75) 80.68,76.3 80.68,76.72 83.09,79.14 RC61.1 ; JCPU1.AM28 v1(79.12,71.75)
  BOTTOM w0.102: v1(80.12,75.75) 79.64,75.26 v2(79.64,75.06) 79.64,72.26 v1(79.12,71.75)
H_CPU_TESTLO: length 14.7
  TOP w0.102: v1(73.11,58.75) 73.58,58.28 JCPU1.W34
  BOTTOM w0.102: v1(73.11,58.75) 72.65,58.28 72.15,58.28 71.69,57.82 71.69,56.61 69.38,54.3 v2(69.38,50.24) 69.38,48.55 68.49,47.66 RC45.1
H_CPUPWRGD: length 171
  TOP w0.102: 40.04,90.69 40.13,90.6 40.13,90.14 40.35,89.92 40.35,89.84 40.77,89.42 40.77,88.92 42.18,87.51 48.52,87.51 49.56,86.47 49.56,85.94 49.36,85.74 49.36,85.28 49.54,85.1 49.54,83.82 49.26,83.54 49.26,79.08 49.67,78.67 49.67,78.32 v1(49.26,77.91) ; JCPU1.AL34 73.09,70.78 v1(72.25,70.78)
  IN1 w0.109: v1(49.26,77.91) 49.95,77.91 50.6,77.26 54.2,77.26 54.78,77.85 56.27,77.85 56.74,77.38 56.74,74.3 57.51,73.52 57.51,72.1 58.06,71.55 58.06,52.17 62.59,47.64 62.59,42.5 63.28,41.82 v1(63.28,40.42) 63.28,35.11 67.27,31.13 67.27,20.89 69.33,18.83 69.38,18.83 71.59,16.62 71.59,15.38 v1(71,14.79)
  IN3 w0.102: v1(72.25,70.78) 72.6,70.42 72.6,65.49 72.83,65.26 80.25,65.26 80.68,64.83 80.68,39.61 80.22,39.15 74.41,39.15 v1(70.37,35.11)
  BOTTOM w0.102: RC130.1 64.23,70.89 72.13,70.89 v1(72.25,70.78) ; v1(71,14.79) 71.28,14.51 RC5.1 ; v1(70.37,35.11) v4(67.55,37.93) 65.06,40.42 v1(63.28,40.42)
H_CPUPWRGD_XDP: length 4.5
  TOP w0.102: JXDP1.39 71.2,10.33 v1(71.69,9.84)
  BOTTOM w0.102: v1(71.69,9.84) 71.28,10.25 v2(71.28,10.82) RC5.2
H_PM_SYNC: length 47.2
  TOP w0.102: JCPU1.AT28 79.59,75.81 v1(80.12,76.34) ; v1(41.94,88.91) 41.21,89.65 41.21,89.95 40.85,90.31 UH1.AY3
  BOTTOM w0.102: v1(41.94,88.91) 42.35,88.5 42.91,88.5 42.97,88.57 T129.1 43.68,88.56 46.58,88.56 47.92,87.21 52.65,87.21 52.93,86.93 58.34,86.93 59.83,85.44 59.83,85.05 60.38,84.49 66.85,84.49 72.6,78.74 77.72,78.74 v1(80.12,76.34)
H_PROCHOT#: length 481.2
  TOP w0.102: v1(53.76,20.23) PC510.1 PR524.1 ; RC57.1 75.22,81.37 RC44.2 74.68,80.99 74.68,76.49 v1(74.96,76.21)
  IN1 w0.109: v1(74.96,76.21) 74.96,76.24 81.43,82.71 81.43,98.8 81.09,99.15 81.09,108.93 80.37,109.65 80.37,116.35 79.96,116.75 79.96,119.6 79.53,120.03 79.53,123.53 76.69,126.38 76.69,135.65 75.22,137.13 75.22,138.91 71.18,142.95 v1(71.18,146.16)
  IN3 w0.127: v1(221.09,67.96) 221.09,68.08 215.32,73.85 211.66,73.85 210.19,75.32 209.13,75.32 208.83,75.02 206.68,75.02 202.29,79.41 187.36,79.41 183.01,83.75 179.52,83.75 179.09,83.32 177.29,83.32 175.35,85.27 169.33,85.27 168.94,85.65 168.94,90.26 162.67,96.53 152.26,96.53 151.88,96.91 136.56,96.91 131.2,91.55 117.77,91.55 116.7,90.48 98.89,90.48 92.56,84.15 88.61,84.15 81.48,77.02 75.78,77.02 v1(74.96,76.21) 75.07,76.21 75.65,75.63 75.65,73.62 75.29,73.26 74.99,73.26 74.53,72.81 74.53,67.63 74.89,67.27 82.23,67.27 82.63,66.86 82.63,40.55 82.05,39.97 82.05,38.92 78.22,35.08 78.22,29.26 74.39,25.44 73.91,25.44 71.78,23.3 67.81,23.3 66.86,22.35 66.24,22.35 65.59,23 65.16,23 64.45,22.29 61.63,22.29 60.74,21.4 60.74,20.74 60.23,20.23 v1(53.76,20.23)
  IN4 w0.109: v1(87.14,151.32) 87.14,152.62 89.12,154.6 89.12,156.79 96.77,164.44 106.77,164.44 107.54,165.21 108.26,165.21 108.54,164.94 112.17,164.94 112.42,165.19 114.42,165.19 114.67,164.94 127.08,164.94 130.12,161.89 133.96,161.89 135.31,160.54 135.31,159.38 142.1,152.6 145.36,152.6 146.14,153.38 v1(149.79,153.38)
  BOTTOM w0.102: U51.A46 v2(97.28,159.27) 96.47,159.27 96.16,158.96 96,158.96 93.06,156.03 93.06,155.06 89.32,151.32 v1(87.14,151.32) 87.14,150.98 82.32,146.16 v1(71.18,146.16) ; v1(149.79,153.38) 149.79,155 150.66,155.87 153.32,155.87 154.61,154.58 PQ1080.6 154.61,152.93 155.36,152.18 155.36,149.26 155.1,149.01 154.09,149.01 153.7,149.39 153.7,150.66 153.31,151.05 PQ1080.3 ; v1(221.09,67.96) 221.27,67.78 225.32,67.78 228.26,64.83 229.93,64.83 230.84,63.92 PR739.2
H_PROCHOT#_R: length 10.7
  TOP w0.102: v1(75.09,75.63) 75.42,75.96 75.42,76.39 75.09,76.72 75.09,78.73 75.22,78.86 RC57.2 ; v1(77.12,70.78) 77.12,70.81 JCPU1.AM30
  IN4 w0.109: v1(77.12,70.78) 76.51,71.39 76.51,74.92 75.8,75.63 v1(75.09,75.63)
H_THERMTRIP#: length 159.4
  TOP w0.102: Q28.3 158.67,135.15 v2(159.52,134.3) 159.8,134.02 v1(159.8,133.84) ; v1(90.23,85.99) 87.87,83.63 82.37,83.63 81.66,82.92 75.08,82.92 74.7,83.3 68.66,83.3 63.2,77.84 58.23,77.84 57.34,76.94 57.34,75.52 58,74.86 58,74.59 58.26,74.33 59.17,74.33 RC126.2 60.31,75.47 61.96,75.47 62.21,75.73 66.77,75.73 71.22,71.28 JCPU1.AM35
  IN3 w0.127: v1(90.23,85.99) 92.96,85.99 96.17,89.2 96.17,89.21 98.08,91.12 98.08,92.29 99.27,93.48 99.74,93.48 100.16,93.89 103.67,93.89 108.87,99.1 110.65,99.1 113.19,101.64 113.19,103.87 113.8,104.48 114.26,104.48 116.26,106.49 116.26,109.41 v1(116.82,109.97)
  BOTTOM w0.102: v1(159.8,133.84) 155.37,129.42 148.19,129.42 144.05,125.28 144.05,118.74 139.06,113.75 131.72,113.75 128.09,117.38 122.76,117.38 116.82,111.45 v1(116.82,109.97)
HDD1_DET#: length 284.4
  TOP w0.102: JSATA1.12 169.83,66.15 v1(169.6,65.92) ; v1(37.93,119.14) 37.93,119.09 37.32,118.48 RH11.1 ; UH1.AT1 39.23,89.25 42.74,85.74 43.98,85.74 44.46,85.25 44.46,83.81 v2(44.83,83.44) 44.83,83.08 44.99,82.92 v1(45.04,82.92) 44.99,82.87 RH36.1
  IN2 w0.127: v1(165.21,95.41) 161.91,98.72 155.63,98.72 154.95,99.4 140.89,99.4 137.79,102.5 133.72,102.5 130.63,99.41 130.63,97.56 129.24,96.18 119.43,96.18 118.18,97.43 114.61,97.43 113.7,98.35 89.33,98.35 87.97,96.99 84.35,96.99 81.02,93.66 76.09,93.66 72.16,89.72 70.91,89.72 66.15,84.96 61.57,84.96 60.93,85.6 59.74,85.6 59.44,85.29 52.31,85.29 51.07,84.05 47.54,84.05 45.98,82.48 45.47,82.48 v1(45.04,82.92)
  IN3 w0.127: v1(45.04,82.92) 44.64,82.51 38.17,82.51 37.41,83.27 37.41,83.87 37.11,84.17 35.52,84.17 35.2,83.86 35.2,83.3 35,83.09 13.81,83.09 8.5,88.4 8.5,89.04 5.7,91.84 5.7,96.12 7.45,97.88 7.45,113.22 7.83,113.6 8.75,113.6 9.38,114.23 10.55,114.23 18.16,121.84 25.18,121.84 25.83,122.49 30.92,122.49 33.44,119.97 37.07,119.97 37.91,119.14 v1(37.93,119.14)
  IN4 w0.109: v1(165.21,95.41) 170.62,90 170.62,83.12 169.63,82.13 169.63,73.47 168.99,72.83 168.99,66.54 v1(169.6,65.92)
HDD_FALL_INT: length 242.1
  IN3 w0.127: v1(169.91,44.46) 169.12,43.67 169.12,32.17 168.26,31.3 168.26,26.78 166.05,24.57 152.46,24.57 149.34,21.46 136.33,21.46 133.05,24.74 114.2,24.74 111.84,27.1 96.65,27.1 94.41,29.33 84.21,29.33 74.38,19.5 74.38,15.88 73.14,14.64 71.69,14.64 68.91,11.86 67.3,11.86 65.42,9.98 61.13,9.98 59.13,11.98 59.13,13.11 55.64,16.6 51.37,16.6 47.66,20.31 47.66,26.59 46.19,28.06 46.19,31.23 41.65,35.76 41.65,43.78 42.73,44.86 42.73,55.38 40.6,57.52 40.6,66.56 35.39,71.77 35.39,74.29 33.74,75.94 33.19,75.94 32.74,75.49 v1(30.96,75.49)
  BOTTOM w0.102: v1(30.96,75.49) 30.21,76.24 v2(27.15,76.24) 24.93,76.24 23.73,77.43 23.73,78.37 23.48,78.62 23.48,79.97 24.09,80.58 24.09,81.54 24.93,82.38 RH106.2 ; v1(169.91,44.46) 169.39,44.98 R503.2 U88.11
HDMI_CEC: length 5.1
  TOP w0.102: R1165.1 21.23,164.82 21.6,165.19 21.6,166.37 v2(21.34,166.62) 21.05,166.91 20.41,166.91 19.08,168.24 JHDMI1.13
HDMI_HPD_SINK: length 16.6
  TOP w0.102: R1164.1 24.32,164.34 24.32,165.36 v1(24.14,165.54) 24.19,165.54 v2(24.87,166.22) ; U9.17 v1(17.89,158.94)
  IN3 w0.127: v1(17.89,158.94) 17.89,163.65 19.17,164.93 20.8,164.93 21.91,166.05 23.63,166.05 v1(24.14,165.54)
  BOTTOM w0.102: R1128.2 17.91,158.91 v1(17.89,158.94)
HDMI_HPD_SINK_R: length 9.2
  TOP w0.102: R1164.2 23.85,165.25 23.72,165.38 23.72,165.9 v2(23.59,166.03) 23.57,166.05 23.57,170.13 v1(22.97,170.72)
  IN1 w0.109: JHDMI1.19 22.16,168.33 22.16,169.91 v1(22.97,170.72)
HDMI_SCL_SINK: length 22.8
  TOP w0.102: JHDMI1.15 20.35,168.24 20.48,168.11 20.48,167.52 20.61,167.4 20.96,167.4 21.06,167.49 21.06,167.56 21.15,167.65 21.5,167.65 21.62,167.52 21.62,167.09 21.75,166.96 22.01,166.96 22.13,167.09 22.13,167.55 22.26,167.68 22.49,167.68 22.62,167.55 22.62,166.73 22.34,166.45 22.34,165.74 v5(22.13,165.53) 22.32,165.34 22.32,165.1 R461.2 ; v1(26.63,156.63) 26.45,156.45 26.32,156.45 26.23,156.54 U9.48
  IN3 w0.127: v1(26.63,156.63) 26.83,156.42 27.29,156.42 27.8,156.93 27.8,158.84 27.14,159.5 27.14,163.16 26.48,163.82 25.79,163.82 24.82,164.78 22.61,164.78 22.34,165.06 22.34,165.33 v5(22.13,165.53)
HDMI_SDA_SINK: length 22.9
  TOP w0.102: R460.2 22.58,165.1 22.58,165.34 v1(22.77,165.53) 22.56,165.74 22.56,166.36 22.85,166.64 22.85,168.79 21.8,169.84 21.16,169.84 JHDMI1.16 ; U9.47 26.24,156.14 26.32,156.22 26.42,156.22 v1(26.63,156.02)
  IN3 w0.127: v1(26.63,156.02) 26.78,156.17 27.39,156.17 28.05,156.83 28.05,158.94 27.39,159.6 27.39,163.26 26.58,164.07 25.9,164.07 24.93,165.03 22.72,165.03 22.59,165.17 22.59,165.36 v1(22.77,165.53)
HOST_DEBUG_RX: length 5.1
  TOP w0.102: R855.2 99.22,157.72 100.44,157.72 100.8,157.36 v1(100.8,157.29) 100.8,157.06 100.91,156.94 100.91,156.25 v2(100.81,156.14)
  BOTTOM w0.102: v1(100.8,157.29) 100.8,157.34 100.41,157.72 99.63,157.72 99.33,158.02 U51.B46
HOST_DEBUG_TX: length 148.8
  TOP w0.102: JDEG2.3 169.55,114.74 169.88,114.4 169.88,114.29 170.21,113.96 v1(170.81,113.96) 171.76,113.96 172.31,113.41 R848.2 ; v1(111.16,141.77) 111.06,141.67 108.77,141.67 v2(108.67,141.77) 106.69,141.77 105.11,143.34 95.96,143.34 93.48,145.82 93.48,149.58 v1(94.1,150.2)
  IN1 w0.109: v1(165.06,118.29) 165.06,118.54 161.76,121.84 161.76,122.35 156.42,127.69 156.42,129.44 154.62,131.23 154.38,131.23 150.4,135.2 150.4,136.16 148.63,137.93 148.2,137.93 147.35,138.79 147.35,140.96 145.75,142.55 145.75,145.1 142.17,148.68 v1(142.17,148.91)
  IN2 w0.127: v1(99.86,156.75) 99.67,156.56 96.99,156.56 95.55,155.12 95.55,151.43 94.32,150.2 v1(94.1,150.2)
  IN3 w0.127: v1(99.86,156.75) 99.76,156.85 99.76,157.47 100.01,157.71 103.01,157.71 103.14,157.58 107.83,157.58 109.88,155.53 117.91,155.53 119.53,153.91 126.81,153.91 128.33,152.39 138.76,152.39 142.17,148.97 v1(142.17,148.91)
  BOTTOM w0.102: JMINI3.16 111.75,142.85 111.75,141.95 111.57,141.77 v1(111.16,141.77) ; C595.1 144.34,147.88 142.79,147.88 142.17,148.5 v1(142.17,148.91) ; v1(170.81,113.96) 170.81,119.21 170.17,119.85 166.62,119.85 v1(165.06,118.29) ; U51.B44 99.59,157.02 v1(99.86,156.75)
HSYNC: length 10.9
  TOP w0.076: v1(30.14,109.26) 30.14,108.67 29.94,108.48 29.94,108.33 30.22,108.06 30.22,107.85 29.88,107.51 29.88,107.07
  BOTTOM w0.102: RH94.2 24.29,110.87 24.88,110.29 24.88,109.95 v2(25.11,109.71) 25.67,109.15 26.93,109.15 27.57,108.52 28.76,108.52 29.5,109.26 v1(30.14,109.26)
HSYNC_BUF: length 4
  TOP w0.102: L4.1 84.83,163.09 v2(84.31,162.57) v1(83.8,162.06)
  BOTTOM w0.102: U19.37 84.2,161.21 84.24,161.25 84.24,161.63 v1(83.8,162.06)
HSYNC_DOCK: length 60.8
  TOP w0.102: v1(79.59,158.94) 80.07,159.42 80.88,159.42 81.26,159.04 82.79,159.04 83.93,160.18 86.78,160.18 87.26,159.7 87.84,159.7 89.49,158.05 89.49,154.56 90.15,153.9 90.15,145.08 91.77,143.47 91.77,139.21 v2(94.76,136.21) 95.77,135.21 95.77,126.91 96.58,126.1 96.58,122.75 94.28,120.46 92.57,120.46 91.75,119.64 v1(90.1,119.64)
  BOTTOM w0.102: v1(79.59,158.94) 80.02,159.37 80.43,159.37 80.64,159.15 U19.28 ; JDOCK1.65 90.2,119.52 90.13,119.59 90.13,119.62 v1(90.1,119.64)
HSYNC_L: length 13.5
  TOP w0.102: v1(83.78,167.19) 83.99,166.99 v2(83.99,165.78) L4.2
  IN3 w0.127: JCRT1.13 78.17,170.22 80.76,170.22 v1(83.78,167.19)
HW_GPS_DISABLE2#: length 72.4
  TOP w0.102: v1(209.91,86.14) 208.72,84.95 208.72,78.94 210.82,76.84 210.82,73.83 213.55,71.11 215.91,71.11 218.65,68.36 227.27,68.36 227.55,68.64 240.05,68.64 244.47,64.22 247.38,64.22 247.63,64.48 253.27,64.48 v1(253.5,64.25)
  BOTTOM w0.102: v1(253.5,64.25) 254.65,65.4 JMINI2.51 ; U46.B34 212.96,85.27 212.7,85.53 v2(211.21,85.53) 209.94,85.53 R798.2 v1(209.91,86.14)
IMON: length 3.1
  TOP w0.102: PR521.1 PC509.2 52.18,22.85 v2(52.38,23.06) 52.73,23.4 PU500.4
IMVP_PWRGD: length 327.8
  TOP w0.102: PR522.1 PR519.1 51.42,20.03 51.67,19.77 53.6,19.77 55.41,17.97 v2(55.41,15.09) v1(55.41,12.79)
  IN1 w0.109: v1(55.41,12.79) 57.08,11.12 72.59,11.12 76.56,15.09 76.56,18.28 84.55,26.27 89.01,26.27 89.36,25.93 103.91,25.93 107.46,22.38 131.83,22.38 132.43,21.78 195.1,21.78 195.91,22.59 222.23,22.59 236.46,36.82 250.16,36.82 251.34,37.99 256.69,37.99 258.83,40.14 264.14,40.14 270.95,46.94 270.95,69.66 260.9,79.71 253.88,79.71 250.67,76.5 246.12,76.5 244.38,74.76 227.08,74.76 v1(226.91,74.59)
  BOTTOM w0.102: U46.A62 224.44,78.52 225.46,77.51 225.46,75.98 226.86,74.59 v1(226.91,74.59)
IMVP_VR_ON: length 335.7
  TOP w0.102: v1(46.72,20.9) 47.06,21.25 PR513.1 ; v1(220.97,78.83) 221.17,78.83 224.59,75.41 v1(224.59,74.38)
  IN1 w0.109: v1(46.72,20.9) 47,20.62 47,16.66 47.82,15.84 49.38,15.84 50.39,14.83 51.44,14.83 52.12,15.5 53.43,15.5 57.58,11.35 72.49,11.35 76.32,15.18 76.32,18.38 84.45,26.5 89.11,26.5 89.45,26.16 104.01,26.16 107.56,22.61 131.93,22.61 132.53,22.02 195,22.02 195.81,22.82 222.14,22.82 236.36,37.05 250.07,37.05 251.24,38.23 256.59,38.23 258.73,40.37 264.04,40.37 270.61,46.94 270.61,69.66 260.8,79.47 253.97,79.47 250.76,76.26 246.21,76.26 244.46,74.51 227.47,74.51 227.02,74.06 224.9,74.06 v1(224.59,74.38)
  BOTTOM w0.102: v1(220.97,78.83) 221.14,78.83 221.69,78.27 U46.B66 ; v1(46.72,20.9) v2(46.72,21.8)
IN1_AEQ#: length 4.3
  TOP w0.102: v2(39.1,147.33) 38.9,147.13 R117.1 37.63,147.43 U629.59
IN1_PEQ: length 5.8
  TOP w0.102: v2(31.97,145.83) 31.99,145.84 R119.1 R121.1 32.85,147.99 33.13,148.27 33.77,148.27 34.1,147.94 34.5,147.94 34.83,148.27 U629.52
IN2_AEQ#: length 2.9
  TOP w0.102: R118.1 37.3,146.87 v2(37.3,147.22) 37.3,148.07 37.23,148.13 U629.58
IN2_PEQ: length 8.5
  TOP w0.102: U629.51 34.43,148.27 34.37,148.22 34.14,148.22 33.78,148.58 32.98,148.58 32.7,148.3 v2(32.44,148.3) 30.46,148.3 29.29,147.13 R120.1 28.66,147.74 28.66,148.75 R122.1
INTRUDER#: length 5.1
  TOP w0.102: RH43.2 19.97,92.67 v2(21.03,92.67) 22.67,92.67 22.89,92.44 23.73,92.44 24.24,92.95 24.58,92.95 UH1.A8
IRQ_SERIRQ: length 277.7
  TOP w0.102: v1(37.64,94.5) 37.64,94.49 37.26,94.1 UH1.AL11
  IN1 w0.109: v1(160.51,118.11) 160.51,118.04 161.93,116.62 161.93,113.93 162.82,113.04 162.82,111.17 170.13,103.86 172.66,103.86 185.7,90.83 185.7,87.58 189.19,84.08 198.25,84.08 203.3,79.03 209.99,79.03 210.91,78.12 213.29,78.12 213.78,78.6 v1(214,78.6)
  IN2 w0.127: v1(37.64,94.5) 38.98,95.84 41.41,95.84 42.38,96.81 50.13,96.81 51.14,97.82 51.14,101.39 52.16,102.41 53.2,102.41 54.56,103.77 60.53,103.77 62.21,102.09 64.04,102.09 66.99,105.04 66.99,106.78 68.13,107.92 68.13,110.45 70.29,112.61 81.42,112.61 82.61,113.8 89.47,113.8 90.79,115.12 90.79,117.72 91.93,118.86 91.93,125.36 93.33,126.75 93.33,131.97 93.91,132.56 93.91,135.99 98.46,140.53 98.46,146.85 101.96,150.35 v1(102.04,150.35)
  IN3 w0.127: v1(160.51,118.11) 160.14,118.11 159.01,119.24 158.64,119.24 158.07,119.82 158.07,121.56 151.82,127.81 151.82,136.2 149.77,138.25 146.4,138.25 140.95,143.7 139.68,143.7 136.29,147.09 128.84,147.09 127.48,145.73 121.79,145.73 120.51,147.01 114.32,147.01 112.53,148.8 112.53,149.23 111.01,150.75 102.44,150.75 v1(102.04,150.35)
  BOTTOM w0.102: v1(160.51,118.11) 161.02,118.11 161.22,117.9 U39.27 ; RH168.2 38.87,85.08 37.27,86.68 36.71,86.68 35.49,87.89 35.49,90.15 v2(36.25,90.91) 36.25,92.11 37.04,92.9 37.04,93.48 37.27,93.71 37.27,94.14 37.63,94.5 v1(37.64,94.5) ; U51.A28 102,150.4 v1(102.04,150.35) ; v1(214,78.6) 213.98,78.57 213.75,78.57 213.55,78.77 U46.B21
ISEN1: length 16.7
  TOP w0.203: PU500.12 56.04,26 v1(56.12,26.07)
  TOP w0.254: PR553.2 v1(55.41,35.75) PR556.1
  IN1 w0.254: v1(56.12,26.07) 56.12,26.58 57.3,27.76 57.3,33.86 v1(55.41,35.75)
  BOTTOM w0.102: v2(56.45,35.19) 56.3,35.04 PR556.1
  BOTTOM w0.254: v1(56.12,26.07) 56.7,26.07 57.08,26.45 PC539.2 ; v1(55.41,35.75) PR556.1
ISEN2: length 22
  TOP w0.102: v2(53.03,35.01) 53.03,35.63 v1(53.12,35.72)
  TOP w0.203: PU500.11 55.96,25.6 v1(56.12,25.44)
  TOP w0.254: PR546.1 53.81,35.04 v1(53.12,35.72) PR539.2
  IN4 w0.254: v1(56.12,25.44) 56.47,25.44 58.84,27.8 58.84,32.22 56.68,34.38 54.47,34.38 v1(53.12,35.72)
  BOTTOM w0.254: v1(56.12,25.44) 56.17,25.49 PC541.2 ; v1(53.12,35.72) 53.81,35.04 PR546.1
ISEN3: length 20.3
  TOP w0.102: PR516.2 v2(58.96,35.04)
  TOP w0.203: PU500.10 55.67,25.2 56.02,24.85 v1(56.12,24.85)
  TOP w0.254: v1(57.69,35.72) PR516.2 ; v1(57.69,35.72) 57.23,35.72 PR518.2 ; v1(57.69,35.72) PR510.1
  IN4 w0.254: v1(57.69,35.72) 59.62,33.79 59.62,27.54 56.93,24.85 v1(56.12,24.85)
  BOTTOM w0.254: PC543.2 56.99,24.85 v1(56.12,24.85)
IST_TRIGGER: length 1.3
  TOP w0.102: v1(81.12,70.75) JCPU1.AL26
  BOTTOM w0.089: v1(81.12,70.75) 81.12,70.84 T163.1
ISUMN: length 80.5
  TOP w0.254: PR555.2 v1(54.26,35.98) ; PH501.1 v1(50.2,54.85) ; PR544.2 v1(58.84,35.98) ; PR512.1 v1(56.55,35.98)
  IN4 w0.254: v1(64.5,24.47) 64.5,24.37 63.48,23.35 60.78,23.35 v1(60.17,23.96) 60.61,24.41 60.61,34.2 v1(58.84,35.98) 58.5,36.31 56.88,36.31 v1(56.55,35.98) 56.55,35.85 55.79,35.09 54.9,35.09 54.26,35.72 v1(54.26,35.98)
  BOTTOM w0.254: PC547.1 56.02,24.01 57.68,24.01 PC543.1 ; PR548.1 60.07,28.37 PR537.2 PR545.1 59.04,26.45 PC539.1 58.21,25.5 PC541.1 58.2,24.56 PC543.1 ; v1(50.2,54.85) 49.69,54.34 49.69,53.53 48.68,52.52 48.68,44.49 53.27,39.89 59.29,39.89 60,39.18 60,33.28 v2(60.71,32.58) 64.5,28.79 v1(64.5,24.47) ; PC543.1 58.21,24.36 PC528.1 PR550.1 v1(60.17,23.96)
ISUMP: length 38.6
  TOP w0.203: 55.75,27.52 55.43,27.2 PU500.15
  TOP w0.254: 55.75,27.52 55.75,28.14 55.79,28.18 v1(55.79,28.36)
  IN1 w0.254: v1(55.79,28.36) 55.63,28.2 55.63,24.65 57.84,22.44 v1(58.56,22.44) 60.41,22.44 61.02,21.83 v1(63.6,21.83)
  BOTTOM w0.254: PC528.2 v1(58.56,22.44) ; v1(63.6,21.83) PR551.2 63.01,22.44 PC538.2 PC532.2 60.75,22.44 PR550.2 ; PR511.1 57.5,36.61 55.6,36.61 PR552.1 55.22,36.61 53.31,36.61 PR535.1 52.64,35.94 v2(52.64,34.68) 53.76,33.56 56.98,33.56 58.53,32.01 58.53,31.1 57.26,29.83 PR558.2 56.4,29.26 56.4,28.97 v1(55.79,28.36)
IVR_ERROR: length 1.4
  TOP w0.102: JCPU1.AR32 75.54,74.28 v1(75.07,74.75)
  BOTTOM w0.102: T162.1 75.49,74.33 v1(75.07,74.75)
JETWAY_14M: length 3.8
  TOP w0.102: UH1.F39 26.13,106.3 v1(26.32,106.49)
  BOTTOM w0.102: RH161.2 23.48,106.08 v2(24.41,106.08) 25.92,106.08 v1(26.32,106.49)
JETWAY_CLK14M: length 246.8
  IN1 w0.109: v1(61.45,160.46) 62.16,160.46 63.81,162.11 65.8,162.11 67.07,163.38 71.99,163.38 72.65,164.04 86.04,164.04 86.57,163.51 93.98,163.51 102.08,171.61 110.93,171.61 114,168.54 116.42,168.54 116.94,168.01 118.96,168.01 125.7,161.28 127.43,161.28 128.24,160.46 130.51,160.46 135.09,155.88 138.08,155.88 147.31,146.65 147.31,142.4 152.67,137.04 152.67,134.96 157.47,130.16 163.79,130.16 166.53,127.41 166.53,121.63 167.67,120.49 167.67,111.62 169.01,110.28 v1(169.03,110.28)
  BOTTOM w0.102: U39.13 168.29,110.75 168.75,110.28 v1(169.03,110.28) ; v1(61.45,160.46) 61.2,160.72 51.72,160.72 49.94,158.94 49.64,158.94 48.92,158.21 48.74,158.21 47.84,157.31 47.84,156.75 46.19,155.1 43.46,155.1 42.4,154.04 41.91,154.04 40.85,152.98 40.85,150.29 41.46,149.68 43.11,149.68 43.37,149.42 43.37,149.02 40.71,146.37 v2(36.15,146.37) 33.84,146.37 31.77,144.3 31.77,142.93 31.77,142.93 31.77,139.25 29.12,136.59 29.12,134.46 30.16,133.41 30.16,128.28 32.09,126.35 32.09,120.8 30.02,118.73 26.61,118.73 25.07,117.18 23.26,117.18 20.07,113.99 20.07,110.5 20.07,110.1 19.41,109.44 19.41,107.07 CH80.1 20.1,106.39 22.26,106.39 RH161.1
JTAG_CLK: length 104.4
  TOP w0.102: v1(165.86,116.24) 166.35,116.74 JDEG2.7 v2(170.32,116.74) 170.65,116.74 171.04,117.13 RP9.3
  IN1 w0.109: v1(101.66,160.44) 101.66,161.03 101.54,161.14 101.54,163.75 103.37,165.57 105.35,165.57 106.63,164.29 111.41,164.29 111.8,163.89 116.77,163.89 117.44,163.22 117.44,157.35 120.67,154.12 127.17,154.12 129.38,151.91 129.38,151.61 132.04,148.95 137.78,148.95 138.08,149.25 140.44,149.25 144.85,144.84 144.85,139.76 154.08,130.52 154.33,130.52 155.71,129.14 155.71,127.39 161.05,122.05 161.05,121.54 163.8,118.8 163.8,118.3 165.85,116.24 v1(165.86,116.24)
  BOTTOM w0.102: v1(101.66,160.44) 101.75,160.52 U51.B56
JTAG_RST#: length 10.5
  BOTTOM w0.102: v2(101.88,168.44) 102.21,168.77 R1981.2 ; JTAG1.1 103.29,169.56 R1981.2 ; R1981.2 102.8,168.29 102.8,164.78 C735.1 103.64,164.3 104.12,163.82 104.12,162.42 104,162.29 U51.A57
JTAG_TDI: length 104.1
  TOP w0.102: v2(100.33,161.77) 100.67,162.11 v1(100.67,162.71) ; v1(166.35,118.26) 166.88,117.74 JDEG2.9 170.53,117.74 170.93,118.13 RP9.1
  IN1 w0.109: v1(100.67,162.71) 101.07,163.11 101.07,163.96 103.15,166.04 105.55,166.04 106.17,165.43 110.94,165.43 112,164.37 116.97,164.37 117.92,163.41 117.92,157.8 119.63,156.08 124.68,156.08 126.17,154.6 128.2,154.6 132.72,150.08 140.28,150.08 145.32,145.04 145.32,139.95 147.58,137.69 148.54,137.69 150.17,136.06 150.17,135.11 154.28,131 154.53,131 156.18,129.34 156.18,127.59 161.52,122.25 161.52,121.74 164.27,118.99 164.27,118.49 165.04,117.73 166.01,117.73 166.35,118.07 v1(166.35,118.26)
  BOTTOM w0.102: U51.A51 101,162.38 v1(100.67,162.71)
JTAG_TDO: length 106.9
  TOP w0.102: v1(166.48,116.19) 166.53,116.24 JDEG2.6 170.68,116.24 171.08,116.63 RP9.4 ; v2(101.81,159.21) 101.66,159.36 v1(101.66,159.85)
  IN1 w0.109: v1(166.48,116.19) 166.48,116.29 166.11,116.66 165.77,116.66 164.03,118.39 164.03,118.89 161.29,121.64 161.29,122.15 155.95,127.49 155.95,129.24 154.43,130.76 154.18,130.76 145.09,139.85 145.09,144.94 140.54,149.49 137.9,149.49 137.65,149.24 132.09,149.24 129.68,151.65 129.68,151.95 127.27,154.36 120.77,154.36 117.68,157.45 117.68,163.32 116.87,164.13 111.9,164.13 110.84,165.19 106.07,165.19 105.45,165.81 103.27,165.81 101.3,163.84 101.3,161.1 101.25,161.05 101.25,160.27 101.28,160.24 101.28,160.23 v1(101.66,159.85)
  BOTTOM w0.102: v1(101.66,159.85) 101.25,160.27 U51.B55
JTAG_TMS: length 104.3
  TOP w0.102: RP9.2 170.9,117.63 170.5,117.24 JDEG2.8 166.08,117.24 165.43,116.58 165.43,115.75 v1(165.82,115.35) ; v1(102,162.7) 102.15,162.7 102.5,163.04 102.5,163.6 v2(102.42,163.68)
  IN1 w0.109: v1(165.82,115.35) 165.61,115.56 165.61,115.57 165.21,115.97 165.21,116.21 163.33,118.1 163.33,118.6 160.58,121.35 160.58,121.85 155.24,127.2 155.24,128.95 154.13,130.05 153.89,130.05 144.38,139.56 144.38,144.09 139.49,148.97 138.14,148.97 137.88,148.71 131.95,148.71 129.09,151.57 129.09,151.87 127.07,153.89 120.57,153.89 117.21,157.25 117.21,163.12 116.91,163.41 116.11,163.41 115.69,162.99 112.37,162.99 111.31,164.05 106.52,164.05 105.96,164.61 103.15,164.61 102.36,163.82 102.36,163.06 v1(102,162.7)
  BOTTOM w0.102: U51.A53 v1(102,162.7)
KB_DET#: length 177.9
  TOP w0.102: UH1.U12 31.39,94.7 v1(31.12,94.43) ; JKB1.1 JKB1.2 v1(175.55,109.5)
  IN2 w0.127: v1(175.55,109.5) 175.16,109.1 157.93,109.1 157.01,108.18 119.66,108.18 118.8,109.04 117.97,109.04 117.06,108.12 84.14,108.12 82.97,106.96 80.39,106.96 80.04,107.31 71.57,107.31 64.8,100.54 61.25,100.54 59.9,101.89 55.28,101.89 54.64,101.26 54.64,99.25 53.32,97.93 53.04,97.93 52.16,97.04 52.16,96.19 50.83,94.85 45.4,94.85 43.06,92.51 43.06,90.94 42.47,90.35 41.02,90.35 40.8,90.56 39.79,90.56 38.79,91.55 38.45,91.55 38.12,91.88 38.12,93.85 37.88,94.09 37.42,94.09 37.22,94.3 37.22,94.57 36.61,95.18 35.57,95.18 35.16,94.78 35.16,94.24 34.98,94.07 34.37,94.07 33.49,94.96 31.64,94.96 v1(31.12,94.43)
  BOTTOM w0.102: v1(31.12,94.43) 31.53,94.02 31.53,93.06 31.5,93.04 31.5,91.89 31.38,91.76 31.38,90.36 31.63,90.1 31.63,87.26 32.32,86.57 v2(32.32,86.29) 32.32,84.64 RH212.1
LAN_ACTLED_YEL#: length 5.9
  TOP w0.102: v1(132.8,141.08) 132.8,141.64 v2(131.24,143.2) 130.97,143.47 Q325.1
  BOTTOM w0.102: U32.17 132.43,140.71 v1(132.8,141.08)
LAN_ACTLED_YEL#_Q: length 34.7
  TOP w0.102: Q325.6 130.97,147.43 129.37,149.03 129.37,151.72 130.74,153.1 133.61,153.1 145.14,164.63 v2(151.65,164.63) v1(152.48,163.79)
  BOTTOM w0.102: R1171.1 v1(152.48,163.79)
LAN_DISABLE#_R: length 155.4
  TOP w0.102: v1(120.84,155.15) 118.3,155.15 117.18,154.04 v2(117.18,147.19) 118.06,146.31 118.06,142.98 120.18,140.87 v1(120.18,139.25)
  IN3 w0.127: v1(220.3,84.62) 219.67,85.25 219.67,85.56 218.86,86.37 212.78,86.37 211.34,87.82 199.91,87.82 193.05,94.68 180.45,94.68 174.64,100.49 171.62,100.49 156.94,115.17 156.94,117.06 156.03,117.97 156.03,120.56 152.71,123.89 150.4,123.89 148.29,125.99 148.29,128.26 142.36,134.2 140.56,134.2 139.67,135.09 135.84,135.09 134.95,134.2 123.02,134.2 120.18,137.04 v1(120.18,139.25)
  BOTTOM w0.102: R555.2 R549.2 120.68,156.6 120.68,155.31 v1(120.84,155.15) 120.94,155.06 U31.3 ; U46.B47 219.92,84.95 220.25,84.62 v1(220.3,84.62)
LAN_SMBCLK: length 160.8
  TOP w0.102: UH1.U8 31.39,92.91 v1(31.12,92.65)
  IN3 w0.127: v1(63.76,89.52) 63.55,89.74 63.55,90.01 63.17,90.38 58.88,90.38 51.36,82.86 46.92,82.86 44.99,80.94 38.36,80.94 38.01,80.58 35.66,80.58 34.69,81.54 32.55,81.54 32.14,81.14 32.14,80.65 31.5,80 28.98,80 28.42,80.56 28.42,80.72 v1(28.56,80.86)
  BOTTOM w0.076: v1(31.12,92.65) 30.73,92.25 30.73,91.72 30.52,91.51 30.52,91.44
  BOTTOM w0.102: v1(28.56,80.86) 28.38,81.04 28.38,81.32 28.02,81.67 28.02,82.46 RH174.2 28.02,83.37 28.02,85.1 28.51,85.58 28.51,86.85 29.59,87.93 29.59,88.69 30.31,89.42 30.31,91.23 30.52,91.44 ; U31.28 123.34,147.64 123.17,147.48 123.17,147.05 122.46,146.34 122.46,145.97 121.88,145.39 121.88,137.49 122.67,136.71 122.67,132.47 121.17,130.97 121.17,117.44 116.14,112.41 101.48,112.41 98.84,109.77 98.84,109.51 98.18,108.85 87.56,108.85 84.06,105.34 81.99,105.34 77.09,100.44 75.4,100.44 74.58,99.63 74.58,95.36 72.34,93.11 71.08,93.11 68.84,90.87 64.01,90.87 63.56,90.42 63.56,89.72 v1(63.76,89.52)
LAN_SMBDATA: length 160.6
  TOP w0.102: v1(30.2,92.6) 30.42,92.6 UH1.R7
  IN3 w0.127: v1(27.97,80.86) 28.16,80.67 28.16,80.46 28.87,79.75 31.6,79.75 32.39,80.54 32.39,81.03 32.65,81.29 34.59,81.29 35.55,80.33 38.11,80.33 38.47,80.68 45.1,80.68 47.03,82.61 51.47,82.61 58.99,90.13 63.06,90.13 63.29,89.9 63.29,89.69 v1(63.13,89.52)
  BOTTOM w0.076: 30.36,91.6 30.37,91.62 30.39,91.62 30.52,91.75 30.56,91.79 30.56,92.25 30.22,92.6 v1(30.2,92.6)
  BOTTOM w0.102: v1(27.97,80.86) 28.15,81.04 28.15,81.22 27.8,81.58 27.8,82.46 RH175.2 27.8,83.37 27.8,85.2 28.28,85.68 28.28,86.95 28.8,87.47 29.36,88.03 29.36,88.79 30.08,89.51 30.08,91.32 30.36,91.6 ; U31.31 122.14,147.51 121.93,147.31 121.93,146.62 122.23,146.31 122.23,146.07 121.65,145.48 121.65,137.4 122.44,136.61 122.44,132.57 120.94,131.07 120.94,117.54 116.04,112.64 101.39,112.64 98.61,109.87 98.61,109.6 98.08,109.08 87.47,109.08 83.96,105.57 81.9,105.57 77,100.67 75.3,100.67 74.35,99.72 74.35,95.46 72.24,93.34 70.99,93.34 68.74,91.1 63.92,91.1 63.33,90.51 63.33,89.72 v1(63.13,89.52)
LAN_TEST_EN: length 4
  TOP w0.102: v2(120.82,147.6) 121.14,147.91 R561.1 122.21,146.92 v1(122.34,146.8)
  BOTTOM w0.102: v1(122.34,146.8) 122.34,147.41 122.54,147.61 U31.30
LAN_TX0+: length 13.1
  BOTTOM w0.089: L70.1 131.73,144.86 131.73,149.06 v3(130.51,150.28) 127.54,153.25 126.01,153.25 125.97,153.21 125.84,153.21 125.81,153.24 U31.13
LAN_TX0+R: length 4.4
  BOTTOM w0.089: L70.2 131.73,142.58 131.73,142.13 131.35,141.76 v3(130.88,141.76) 130.37,141.76 129.84,141.22 129.84,140.96 129.93,140.86 U32.12
LAN_TX0-: length 12.8
  BOTTOM w0.089: U31.14 125.79,152.84 125.81,152.87 126.12,152.87 126.15,152.91 127.4,152.91 131.39,148.92 v3(131.39,147.48) 131.39,144.49 131.21,144.31 130.93,144.31 L69.1
LAN_TX0-R: length 4.5
  BOTTOM w0.089: L69.2 131.08,143.08 131.39,142.78 131.39,142.28 131.21,142.1 130.23,142.1 129.5,141.36 129.5,140.9 129.43,140.84 U32.11
LAN_TX1+: length 10.3
  BOTTOM w0.089: L68.1 129.29,144.58 129.29,146.85 129.46,147.01 129.46,148.58 129.29,148.74 v3(129.29,149.39) 129.29,149.64 127.3,151.64 125.82,151.64 125.81,151.64 U31.17
LAN_TX1+R: length 3.1
  BOTTOM w0.089: L68.2 129.04,142.61 129.04,142.17 128.85,141.98 v3(128.85,141.65) 128.85,140.93 128.93,140.85 U32.10
LAN_TX1-: length 10.1
  BOTTOM w0.089: U31.18 125.84,151.24 125.89,151.29 127.16,151.29 128.95,149.5 128.95,148.6 129.12,148.43 v3(129.12,147.42) 129.12,147.16 128.95,146.99 128.95,144.97 128.34,144.36 L67.1
LAN_TX1-R: length 3.1
  BOTTOM w0.089: L67.2 128.7,142.54 128.7,142.31 128.51,142.13 128.51,140.93 128.43,140.85 U32.9
LAN_TX2+: length 8.9
  BOTTOM w0.089: L66.1 126.44,144.71 126.44,145.5 v3(127.21,146.28) 128.04,147.1 128.04,149.28 126.9,150.42 125.89,150.42 125.87,150.44 U31.20
LAN_TX2+R: length 3.4
  BOTTOM w0.089: U32.7 127.43,140.85 127.34,140.94 127.34,141.3 v3(126.79,141.85) 126.34,142.3 126.34,142.64 L66.2
LAN_TX2-: length 8.8
  BOTTOM w0.089: L65.1 125.86,144.36 126.09,144.6 126.09,145.64 127.69,147.24 127.69,149.13 v3(127.12,149.71) 126.75,150.07 125.88,150.07 125.84,150.04 U31.21
LAN_TX2-R: length 3.4
  BOTTOM w0.089: L65.2 125.99,142.51 125.99,142.16 127,141.16 127,140.92 126.93,140.85 U32.6
LAN_TX3+: length 7.7
  BOTTOM w0.089: L64.1 123.73,144.71 123.73,145.17 123.91,145.35 124.6,145.35 126.64,147.39 v3(126.64,148) 126.64,148.84 126.27,149.21 125.89,149.21 125.86,149.24 U31.23
LAN_TX3+R: length 4.3
  BOTTOM w0.089: U32.3 125.43,140.85 125.35,140.93 125.35,141.34 124.66,142.03 v3(124.24,142.03) 123.74,142.03 123.57,142.21 123.57,142.58 L64.2
LAN_TX3-: length 7.7
  BOTTOM w0.089: U31.24 125.8,148.84 125.83,148.87 126.13,148.87 126.3,148.7 126.3,147.54 v3(125.1,146.33) 124.45,145.69 123.77,145.69 123.39,145.31 123.39,144.51 123.12,144.24 122.85,144.24 L63.1
LAN_TX3-R: length 4.3
  BOTTOM w0.089: U32.2 124.93,140.85 125.01,140.93 125.01,141.2 124.52,141.69 123.6,141.69 123.22,142.07 123.22,142.59 L63.2
LAN_WAKE#: length 18.4
  IN3 w0.127: v1(115.86,153.78) 115.76,153.88 113.7,153.88 112.86,154.72 109.51,154.72 109.4,154.84 104.89,154.84 103.64,153.59 103.64,153.21 v1(103.25,152.82)
  BOTTOM w0.102: R556.1 115.86,156.93 v2(115.86,155.33) v1(115.86,153.78) ; U51.B27 v1(103.25,152.82)
LAN_WAKE#_R: length 8.7
  BOTTOM w0.102: U31.2 120.54,154.82 120.34,155.01 120.34,157.47 119.5,158.3 v2(117.92,158.3) 116.85,158.3 R563.2 R556.2
LANCLK_REQ#: length 224.4
  TOP w0.102: RH20.1 15.89,113.75 15.43,113.29 v1(15.41,113.29) ; v1(36.86,85.86) 36.74,85.74 RH140.1 36.67,85.08 36.19,85.55 36.19,86.56 35.49,87.26 35.49,88 35.19,88.3 35.19,89.76 UH1.AF1
  IN1 w0.109: v1(15.41,113.29) 16.04,113.29 18.14,115.4 18.14,117.71 16.83,119.03 16.83,121.39 19.12,123.68 24.99,123.68 26.53,125.22 26.53,128.44 28.76,130.67 28.76,142.36 27.67,143.45 27.67,145.35 27.06,145.96 27.06,153.4 26.21,154.25 26.21,158.66 27.2,159.64 27.2,160.2 27.88,160.88 29.66,160.88 30.28,161.51 30.72,161.51 33.47,164.26 44.73,164.26 46.47,166 49.22,166 51.11,164.11 51.11,162.49 53.94,159.66 56.96,159.66 57.68,158.93 63.11,158.93 64.82,160.64 76.6,160.64 78.46,162.49 85.36,162.49 85.9,161.95 95.86,161.95 99.6,165.69 101.94,165.69 102.82,166.58 111.69,166.58 112.61,165.66 116,165.66 118.16,163.51 118.16,158.19 v1(118.45,157.9)
  IN4 w0.109: v1(15.41,113.29) 15.41,107.53 13.89,106.02 13.89,102.03 14.88,101.05 14.88,100.72 18.24,97.36 18.24,96.32 18.56,96 19.42,96 22.55,92.87 22.68,92.87 23.38,92.17 23.38,89.62 24.47,88.53 24.78,88.53 26,87.31 28.77,87.31 29.35,86.72 35.94,86.72 36.71,85.95 36.71,85.94 36.74,85.91 36.81,85.91 v1(36.86,85.86)
  BOTTOM w0.102: v1(118.45,157.9) 117.51,156.96 117.51,154.95 v2(117.84,154.62) 118.78,153.68 118.78,153.34 118.88,153.24 U31.48
LAT_ON_SW#: length 4.3
  TOP w0.102: R870.2 104.3,160.61 104.3,160.21 v1(104.73,159.78) v2(104.73,158.84)
  BOTTOM w0.102: v1(104.73,159.78) 104.81,159.78 105.25,160.21 U51.B63
LCD_CBL_DET#: length 109
  TOP w0.102: JEDP1.20 48.37,145.95 47.76,145.34 47.76,136.45 49.81,134.4 54.64,134.4 55.95,135.71 57.62,135.71 58.28,135.05 58.28,130.93 57.82,130.48 v2(57.82,119.7) 57.82,119.39 53.19,114.77 49.22,114.77 48.7,114.25 48.7,112.94 49.56,112.08 v1(49.56,110.04) ; UH1.G17 27.16,96.54 v1(27.45,96.24)
  IN1 w0.109: v1(27.45,96.24) 27.45,96.49 27.06,96.89 26.53,96.89 26.27,97.14 26.27,97.88 27.26,98.87 27.67,98.87 28.23,99.43 28.23,99.93 28.86,100.57 28.86,101.13 28.23,101.76 28.23,101.97 27.69,102.5 26.68,102.5 26.42,102.75 26.42,103.16 26.64,103.38 29.64,103.38 29.75,103.49 29.75,104.23 29.59,104.39 28.91,104.39 28.66,104.65 28.66,106.41 28.99,106.74 29.27,106.74 31.4,108.88 35.92,108.88 37.81,110.76 42.58,110.76 43.55,109.79 49.31,109.79 v1(49.56,110.04)
  BOTTOM w0.102: v1(27.45,96.24) 27.06,96.63 25.36,96.63 24.28,97.71 22.48,97.71 21.38,98.82 20.1,98.82 18.47,100.44 17.94,100.44 RH77.2
LCD_EDP_AUX: length 13
  TOP w0.102: R337.2 55.49,142.71 55.37,142.71 v1(55.19,142.89) 55,142.71 54.4,142.71 C371.1 ; v1(61.15,143.65) 61.31,143.81 61.46,143.81 61.7,143.57 61.9,143.57 62,143.47 U630.32
  IN1 w0.117: v1(55.19,142.89) 55.26,142.82 56.85,142.82 59.04,145.01 61.45,145.01 61.87,144.59 61.87,143.98 61.62,143.74 61.23,143.74 v1(61.15,143.65)
LCD_EDP_AUX#: length 12.9
  TOP w0.102: C373.1 54.42,142.49 55,142.49 v1(55.19,142.31) 55.35,142.47 55.48,142.47 R340.2 ; U630.31 61.98,143.87 61.9,143.79 61.79,143.79 61.55,144.03 61.36,144.03 v1(61.15,144.24)
  IN1 w0.117: v1(61.15,144.24) 61.42,143.97 61.52,143.97 61.63,144.08 61.63,144.49 61.35,144.77 61,144.77 60.87,144.64 60.48,144.64 60.35,144.77 59.98,144.77 59.85,144.64 59.51,144.64 59.38,144.77 59.14,144.77 58.92,144.56 58.92,144.45 58.61,144.13 58.5,144.13 58.24,143.87 58.24,143.74 57.94,143.44 57.8,143.44 57.58,143.21 57.58,143.08 57.25,142.75 57.11,142.75 56.95,142.58 56.67,142.58 56.56,142.48 56.19,142.48 56.09,142.58 55.46,142.58 v1(55.19,142.31)
LCD_EDP_AUX#_C: length 3.4
  TOP w0.102: JEDP1.29 51.1,141.45 51.24,141.59 51.56,141.59 51.79,141.82 51.81,141.82 52.18,142.19 52.18,142.21 52.45,142.49 52.82,142.49 C373.2
LCD_EDP_AUX_C: length 3.4
  TOP w0.102: C371.2 52.82,142.7 52.36,142.7 v3(51.83,142.17) 51.47,141.81 51.24,141.81 51.1,141.95 JEDP1.28
LCD_EDP_HPD: length 17.1
  TOP w0.102: v1(51.51,143.93) 51.51,143.85 51.11,143.45 JEDP1.25 ; U630.44 v1(61.54,138.67)
  IN1 w0.109: v1(51.51,143.93) 51.51,142.48 54.17,139.81 57.03,139.81 57.77,139.08 61.13,139.08 v1(61.54,138.67)
  BOTTOM w0.102: v1(51.51,143.93) 51.38,144.05 R223.2 50.86,143.12 R103.2
LCD_EDP_LANE_N0: length 9.7
  TOP w0.102: U630.45 61.82,138.27 61.73,138.18 57.29,138.18 v3(56.8,137.69) 55.72,136.61 55.71,136.61 55.33,136.24 55.33,136.22 54.71,135.6 54.42,135.6 C380.1
LCD_EDP_LANE_N0_C: length 3.6
  TOP w0.102: C380.2 52.84,135.6 52.66,135.6 52.27,135.99 52.27,136.01 51.89,136.39 51.87,136.39 51.45,136.81 51.18,136.81 51.04,136.95 JEDP1.38
LCD_EDP_LANE_N1: length 9.6
  TOP w0.102: C378.1 54.43,137.36 55.04,137.36 55.51,137.83 55.51,138.17 55.84,138.5 56.18,138.5 56.59,138.91 58.1,138.91 58.11,138.92 58.64,138.92 58.66,138.91 v3(60.27,138.91) 60.87,138.91 61.33,139.38 61.83,139.38 61.92,139.47 U630.42
LCD_EDP_LANE_N1_C: length 3.3
  TOP w0.102: JEDP1.36 51.1,137.95 51.24,137.81 51.5,137.81 51.51,137.82 52.13,137.82 52.6,137.35 52.82,137.35 C378.2
LCD_EDP_LANE_N2: length 9.3
  TOP w0.102: U630.39 61.82,140.67 61.73,140.58 61.39,140.58 60.92,140.1 60.92,139.97 60.57,139.62 56.99,139.62 56.98,139.63 56.44,139.63 56.42,139.62 55.82,139.62 55.33,139.13 v3(55.09,139.13) 54.44,139.13 C376.1
LCD_EDP_LANE_N2_C: length 3.2
  TOP w0.102: JEDP1.34 51.1,138.95 51.24,138.81 51.48,138.81 51.86,139.19 52.88,139.19 C376.2
LCD_EDP_LANE_N3: length 8.9
  TOP w0.102: C374.1 54.43,140.92 54.85,140.92 54.86,140.93 55.39,140.93 55.41,140.92 v3(56.98,140.92) 57.32,140.92 58.18,141.78 61.73,141.78 61.82,141.87 U630.36
LCD_EDP_LANE_N3_C: length 3.5
  TOP w0.102: JEDP1.32 50.9,139.95 51.04,139.81 51.44,139.81 v3(52.04,140.41) 52.55,140.92 52.83,140.92 C374.2
LCD_EDP_LANE_P0: length 9.7
  TOP w0.102: U630.46 61.82,137.87 61.73,137.96 57.38,137.96 57.15,137.74 57.15,137.72 56.78,137.34 56.76,137.34 v3(55.68,136.26) 54.8,135.38 54.43,135.38 C379.1
LCD_EDP_LANE_P0_C: length 3.6
  TOP w0.102: C379.2 52.83,135.38 52.57,135.38 v3(51.91,136.04) 51.36,136.59 51.13,136.59 50.99,136.45 JEDP1.39
LCD_EDP_LANE_P1: length 9.6
  TOP w0.102: C377.1 54.42,137.15 55.13,137.15 55.72,137.74 55.72,138.09 55.93,138.29 56.27,138.29 56.68,138.69 v3(58.38,138.69) 59.99,138.69 60,138.68 60.54,138.68 60.55,138.69 60.96,138.69 61.42,139.16 61.86,139.16 61.95,139.07 U630.43
LCD_EDP_LANE_P1_C: length 3.3
  TOP w0.102: C377.2 52.85,137.13 52.51,137.13 52.05,137.59 v3(51.77,137.59) 51.24,137.59 51.1,137.45 JEDP1.37
LCD_EDP_LANE_P2: length 9.3
  TOP w0.102: U630.40 61.82,140.27 61.73,140.36 61.48,140.36 61.13,140.01 61.13,139.88 60.66,139.41 v3(56.7,139.41) 55.91,139.41 55.41,138.9 54.82,138.9 54.81,138.91 54.4,138.91 C375.1
LCD_EDP_LANE_P2_C: length 3.2
  TOP w0.102: JEDP1.35 51.1,138.45 51.24,138.59 51.57,138.59 51.94,138.96 v3(52.19,138.96) 52.8,138.96 C375.2
LCD_EDP_LANE_P3: length 8.9
  TOP w0.102: U630.37 61.82,141.47 61.73,141.56 58.27,141.56 57.41,140.7 57.26,140.7 57.25,140.69 56.72,140.69 56.7,140.7 v3(55.13,140.7) 54.42,140.7 C372.1
LCD_EDP_LANE_P3_C: length 3.5
  TOP w0.102: C372.2 52.83,140.71 52.64,140.71 52.39,140.45 52.39,140.44 52.01,140.06 52,140.06 51.53,139.6 51.04,139.6 50.89,139.45 JEDP1.33
LCD_SMBCLK: length 79.2
  TOP w0.102: R839.2 110.96,159.29 110.52,159.29 110.04,158.81 109.54,158.81 109.25,158.52 v2(108.61,158.52) v1(107.68,158.52) ; v1(58.25,145.71) 58.25,145.18 57.95,144.88 57.11,144.88 56.93,144.7 Q6.6
  IN4 w0.109: v1(58.25,145.71) 58.25,145.43 58.71,144.97 70.81,144.97 77.76,138.02 77.76,137.13 78.06,136.83 82,136.83 84.27,139.1 89.85,139.1 91.07,137.88 93.93,137.88 98.57,142.52 98.57,152.49 99.5,153.41 100.9,153.41 101.11,153.62 101.11,155.27 103.09,157.24 105.48,157.24 106.07,157.83 108.17,157.83 108.33,157.99 108.33,158.3 108.11,158.52 v1(107.68,158.52)
  BOTTOM w0.102: U51.B5 v1(107.68,158.52)
LCD_SMBCLK_Q: length 8.3
  TOP w0.102: JEDP1.26 51.1,142.95 51.23,142.81 51.33,142.81 v3(52.92,144.4) 53.54,145.02 54.64,145.02 55.16,145.54 56.74,145.54 56.93,145.73 Q6.1
LCD_SMBDAT: length 81.3
  TOP w0.102: v1(110.5,158.35) 110.5,158.95 110.62,159.07 110.8,159.07 R840.2 ; Q6.3 55.63,146.98 55.99,147.34 56.76,147.34 57.55,146.56 57.55,145.57 v1(57.79,145.32)
  IN4 w0.109: v1(110.5,158.35) 110.5,158.29 110.14,157.94 108.61,157.94 108.27,157.6 106.16,157.6 105.58,157.01 103.18,157.01 101.35,155.18 101.35,153.52 101,153.18 99.59,153.18 98.81,152.39 98.81,142.42 94.03,137.64 90.97,137.64 89.75,138.86 84.37,138.86 82.1,136.59 77.96,136.59 77.52,137.03 77.52,137.92 70.71,144.73 58.61,144.73 58.02,145.32 v1(57.79,145.32)
  BOTTOM w0.102: v1(110.5,158.35) 110.08,158.77 U51.A4
LCD_SMBDAT_Q: length 7.5
  TOP w0.102: JEDP1.27 51.1,142.45 51.23,142.59 51.43,142.59 53.63,144.79 v3(54.43,144.79) 54.74,144.79 55.26,145.31 55.54,145.31 55.63,145.22 Q6.4
LCD_TST: length 243.6
  TOP w0.102: v1(51.93,144.57) 51.52,144.57 50.89,143.95 JEDP1.24 ; v1(217.84,90.33) 217.84,90.36 217.03,91.17 215.76,91.17 215.17,90.59 v1(215.17,88.12)
  IN3 w0.127: v1(47.7,149.73) 47.7,150.09 47.51,150.28 47.51,151.26 50.73,154.48 50.73,155.59 51.24,156.09 56.05,156.09 56.89,156.93 58.02,156.93 59.79,158.7 62.34,158.7 64.41,160.77 77.51,160.77 78.05,161.3 79.18,161.3 80.64,162.76 80.64,162.8 85.58,162.8 86.78,161.61 103.31,161.61 105.11,163.41 110.99,163.41 112.18,162.22 115.15,162.22 115.81,161.55 116.77,161.55 117.9,162.68 124.3,162.68 125.34,161.64 128.17,161.64 128.5,161.31 131.95,161.31 135.27,158 139.09,158 140.22,156.87 143.07,156.87 144.66,155.28 144.66,153.63 148.17,150.12 149.65,150.12 151.37,148.41 151.37,147.4 153.32,145.44 153.32,144.47 155.02,142.77 155.02,141.93 157.79,139.16 157.79,132.75 160.99,129.55 164.1,129.55 166.25,127.4 166.25,124.66 173.58,117.33 173.58,108.67 175.37,106.88 175.37,105.96 181.32,100.01 197.01,100.01 203.06,93.97 208.26,93.97 210.98,91.25 216.98,91.25 217.84,90.38 v1(217.84,90.33)
  BOTTOM w0.102: v2(215.27,88.75) 215.17,88.64 v1(215.17,88.12) 215.17,88.1 215.58,87.69 215.58,87.23 215.67,87.14 U46.A36 ; v1(51.93,144.57) 50.91,145.59 47.39,145.59 47.16,145.82 47.16,149.2 v1(47.7,149.73) ; v1(217.84,90.33) 218.09,90.58 RP8.2
LCD_VCC_TEST_EN: length 213.9
  IN3 w0.127: v1(45.83,143.75) 45.83,144.6 50.88,149.66 50.88,152.1 52.25,153.46 59,153.46 61.48,150.99 77.73,150.99 79.27,149.45 87.42,149.45 88.89,147.98 92.46,147.98 93.39,147.05 96.44,147.05 97.01,146.48 97.01,146.15 97.73,145.44 97.87,145.44 100.33,142.99 117.23,142.99 118.05,142.16 135,142.16 135.7,141.46 135.7,141.17 138.18,138.68 138.18,137.78 139.58,136.38 141.25,136.38 149.65,127.98 149.65,126.9 151.1,125.45 152.3,125.45 156.8,120.95 156.8,118.28 157.75,117.33 157.75,115.44 171.94,101.26 174.98,101.26 180.77,95.46 190.23,95.46 191.07,96.3 191.63,96.3 192.49,95.44 193.41,95.44 195.88,92.97 196.78,92.97 197.18,92.58 197.18,91.67 199.66,89.19 203.08,89.19 203.64,88.63 215.5,88.63 216.02,88.11 v1(216.98,88.11)
  BOTTOM w0.102: U46.A40 217.67,87.42 v1(216.98,88.11) ; v2(47.35,143.89) 47.02,143.56 46.06,143.56 45.87,143.75 v1(45.83,143.75) 45.43,144.15 D6.2
LED_10_GRN#: length 18
  TOP w0.102: Q327.3 130.96,151.33 130.31,150.68 130.31,150.02 v2(130.2,149.92) v1(129.8,149.52)
  IN4 w0.109: v1(129.8,149.52) 129.8,149.21 122.92,142.33 122.92,140.04 v1(122.46,139.58)
  BOTTOM w0.102: U32.41 123.2,138.84 v1(122.46,139.58)
LED_10_GRN#_Q: length 29.5
  TOP w0.102: Q327.1 132.57,150.4 133.96,151.79 133.96,153.12 145.21,164.37 149.56,164.37 v2(151.32,162.62) v1(151.93,162.01)
  BOTTOM w0.102: v1(151.93,162.01) 152.79,161.15 R1170.1
LED_100_ORG#: length 10.1
  TOP w0.102: v1(132.57,146.44) 132.27,146.74 Q325.4 133.1,147.22 v2(133.5,147.62)
  BOTTOM w0.102: v1(132.57,146.44) 133,146.01 133,142.2 133.46,141.74 133.46,139.71 133.09,139.34 U32.18
LED_100_ORG#_Q: length 32.9
  TOP w0.102: Q325.3 135.31,148.37 135.31,153.45 v2(142.2,160.34) 145.98,164.12 149.13,164.12 151.67,161.58 152.13,161.58 v1(152.56,162.01)
  BOTTOM w0.102: R1167.1 v1(152.56,162.01)
LED_SATA_DIAG_OUT#: length 295.7
  TOP w0.102: v1(14.31,146.9) 14.16,146.75 13.57,146.75 v2(13.08,147.24) 12.71,147.61 D62.1
  IN1 w0.109: v1(38.64,165.72) 38.64,165.85 37.65,166.84 28.06,166.84 26.08,164.85 18.86,164.85 14.94,160.94 14.94,155.73 13.44,154.22 13.44,149.59 14.31,148.72 v1(14.31,146.9)
  IN3 w0.127: v1(204.1,90.13) 203.77,90.46 202.73,90.46 202.37,90.1 199.82,90.1 198.05,91.88 198.05,92.82 194.37,96.51 192.5,96.51 191.87,97.14 185.47,97.14 184.74,96.4 180.91,96.4 175.3,102.02 172.32,102.02 159.33,115 159.33,116.83 157.56,118.6 157.56,121.27 152.62,126.21 151.42,126.21 150.41,127.22 150.41,129.54 135.2,144.75 133.77,144.75 131.95,142.92 120.17,142.92 118.79,144.31 116.44,144.31 115.88,143.75 101.32,143.75 98.16,146.91 97.65,146.91 96.75,147.81 93.71,147.81 92.78,148.74 89.21,148.74 87.74,150.21 79.58,150.21 78.05,151.75 61.8,151.75 59.31,154.24 51.94,154.24 50.1,152.39 50.1,150.24 48.59,148.73 47.09,148.73 41.61,154.21 41.61,163.47 39.37,165.72 v1(38.64,165.72)
  BOTTOM w0.102: v1(204.1,90.13) 204.1,88.32 203.77,87.99 203.77,82.67 204.02,82.42 204.02,73.8 207.68,70.14 212.63,70.14 213.96,71.47 215.6,71.47 215.94,71.81 216.38,71.81 217.15,72.58 217.15,74.03 217.44,74.31 217.44,75.21 217.17,75.48 U46.A10
