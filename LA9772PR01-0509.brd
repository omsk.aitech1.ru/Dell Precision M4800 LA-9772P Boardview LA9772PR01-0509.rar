# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CRX_GTX_N14: length 95.3
  TOP w0.102: JCPU1.K28 79.13,48.82 79.13,48.76 v1(79.13,48.75)
  TOP w0.109: CC2.2 112.22,108.97 112.22,109.51 v1(112.4,109.69)
  IN3 w0.089: 75.73,54.95 75.73,54.93 75.7,54.9 75.7,51.98 75.81,51.87 75.94,51.87 76.13,51.68 76.13,51.55 76.32,51.36 76.45,51.36 76.63,51.17 76.63,51.05 76.73,50.95 76.73,50.6 76.98,50.35 77.33,50.35 77.69,49.99 77.69,48.64 77.98,48.34 79.35,48.34 79.54,48.53 79.54,49.09 79.24,49.39 79.03,49.39 78.93,49.29 78.93,48.96 v1(79.13,48.75)
  IN3 w0.14: 75.73,54.95 75.73,55.3 74.53,56.5 72.65,56.5 70.63,58.52 70.63,75.55 72.87,77.79 73.77,77.79 74.96,78.97 80.67,78.97 89.06,87.36 91,87.36 96.19,92.55 96.19,93.47 97.52,94.8 98.87,94.8 101.84,97.77 101.84,98 103.37,99.53 104.66,99.53 110.65,105.52 110.65,106.33 112.24,107.92 112.24,109.53 v1(112.4,109.69)
PEG_CRX_GTX_N15: length 91
  TOP w0.102: JCPU1.M29 78.59,51.25 v1(78.11,50.76)
  TOP w0.109: v1(114.19,109.71) 113.99,109.51 113.99,108.97 CC1.2
  IN3 w0.089: 77.73,55.03 77.73,55 77.7,54.97 77.7,50.6 78,50.3 78.14,50.3 78.22,50.38 78.22,50.65 v1(78.11,50.76)
  IN3 w0.14: 77.73,55.03 77.73,55.38 75.78,57.34 73.85,57.34 72.84,58.35 71.95,58.35 71.43,58.86 71.43,75.22 73.19,76.97 74.1,76.97 75.3,78.17 81.01,78.17 89.38,86.55 91.32,86.55 97.04,92.26 97.04,93.18 97.85,93.99 99.53,93.99 103.29,97.75 103.29,98 103.84,98.56 105.24,98.56 112.02,105.34 112.02,106.28 114.03,108.29 114.03,109.55 v1(114.19,109.71)
PEG_CRX_GTX_P0: length 102.6
  TOP w0.102: JCPU1.D32 75.59,43.25 75.11,42.76 v1(75.12,42.76)
  TOP w0.109: v1(86.75,109.58) 86.89,109.58 87.05,109.42 87.05,108.97 CC32.2
  IN3 w0.089: 71.89,41.15 71.92,41.17 74.44,41.17 74.73,41.47 74.73,42.96 74.92,43.14 75.04,43.14 75.12,43.06 v1(75.12,42.76)
  IN3 w0.14: 71.89,41.15 66.37,41.15 62.54,44.98 62.54,46.9 58.2,51.24 58.2,70.37 57.29,71.28 57.29,73.82 57.74,74.28 57.74,74.72 57.19,75.27 57.19,77.14 57.55,77.51 57.55,80.16 63.04,85.64 63.47,85.64 67.66,89.83 67.66,91.07 70.94,94.35 71.35,94.35 72.03,95.02 72.03,95.44 72.9,96.3 73.18,96.3 74.31,97.43 74.31,98.4 74.9,99 78.09,99 80.49,101.4 82.76,101.4 84.62,103.26 85.31,103.26 87.57,105.52 87.57,108.3 86.89,108.98 86.89,109.44 v1(86.75,109.58)
PEG_CRX_GTX_P1: length 100.4
  TOP w0.102: v1(75.1,44.76) 74.59,45.27 JCPU1.F33
  TOP w0.109: CC31.2 88.83,108.97 88.83,109.42 88.67,109.58 v1(88.53,109.58)
  IN3 w0.089: 71.87,42.13 71.89,42.13 71.92,42.17 72.99,42.17 73.96,43.13 74.32,43.13 74.73,43.54 74.73,44.02 74.86,44.16 74.86,44.52 v1(75.1,44.76)
  IN3 w0.14: 71.87,42.13 66.53,42.13 63.46,45.21 63.46,47.33 59.01,51.78 59.01,77.61 58.49,78.13 58.49,79.95 63.14,84.6 63.58,84.6 68.69,89.71 68.69,90.96 71.21,93.48 71.67,93.48 75.66,97.48 78.76,97.48 79.15,97.87 79.15,98.91 80.84,100.6 83.1,100.6 84.77,102.27 86.26,102.27 87.23,103.24 87.23,104.05 89.07,105.89 89.07,108.45 88.67,108.85 88.67,109.44 v1(88.53,109.58)
PEG_CRX_GTX_P2: length 97.8
  TOP w0.102: JCPU1.E34 73.59,44.28 v1(74.11,43.76)
  TOP w0.109: CC30.2 90.61,108.97 90.61,110.19 90.45,110.35 v1(90.31,110.35)
  IN3 w0.089: 71.87,43.1 71.89,43.1 71.92,43.13 73.33,43.13 73.96,43.76 v1(74.11,43.76)
  IN3 w0.14: v1(90.31,110.35) 90.45,110.21 90.45,104.76 88.77,103.08 88.3,103.08 86.64,101.43 85.11,101.43 83.08,99.41 82.39,99.41 79.64,96.66 75.98,96.66 69.73,90.41 69.73,89.44 61.08,80.79 60.47,80.79 59.29,79.62 59.29,78.59 59.81,78.07 59.81,52.12 64.27,47.66 64.27,45.53 66.7,43.1 71.87,43.1
PEG_CRX_GTX_P3: length 94
  TOP w0.102: JCPU1.F35 72.59,45.25 v1(73.07,44.77)
  TOP w0.109: v1(92.15,109.58) 92.29,109.58 92.45,109.42 92.45,108.97 CC29.2
  IN3 w0.089: v1(73.07,44.77) 73.02,44.77 72.84,44.58 72.84,44.27 72.6,44.04 71.27,44.04 71.24,44 71.23,44
  IN3 w0.14: 71.23,44 66.94,44 65.34,45.6 65.34,47.89 60.61,52.61 60.61,79.19 70.72,89.3 70.72,90.26 76.2,95.73 79.86,95.73 82.73,98.61 83.41,98.61 84.25,99.44 86.28,99.44 88.18,101.34 88.57,101.34 92.29,105.06 92.29,109.44 v1(92.15,109.58)
PEG_CRX_GTX_P4: length 102
  TOP w0.102: JCPU1.E30 77.59,44.25 v1(77.11,43.76)
  TOP w0.109: CC28.2 94.23,108.97 94.23,110.34 94.07,110.5 v1(93.93,110.5)
  IN3 w0.089: v1(77.11,43.76) 77.11,43.6 77.71,43 77.71,42.5 77.37,42.16 75.88,42.16 75.52,42.52 75.52,44.88 75.23,45.17 72.02,45.17 71.99,45.14 71.97,45.14
  IN3 w0.14: 71.97,45.14 69.28,45.14 61.46,52.96 61.46,78.9 71.81,89.26 71.81,90.22 75.79,94.19 80.5,94.19 83.98,97.68 83.98,97.98 84.63,98.63 86.6,98.63 88.51,100.54 88.9,100.54 94.06,105.7 94.06,110.36 v1(93.93,110.5)
PEG_CRX_GTX_P5: length 97
  TOP w0.102: v1(76.11,44.76) 76.59,45.25 JCPU1.F31
  TOP w0.109: CC27.2 96,108.97 96,109.42 95.84,109.58 v1(95.7,109.58)
  IN3 w0.089: 71.92,46.13 71.94,46.13 71.97,46.16 75.28,46.16 75.49,45.95 75.49,45.52 75.85,45.17 76.28,45.17 76.49,44.96 76.49,44.25 76.39,44.16 76.08,44.16 75.98,44.26 75.98,44.63 v1(76.11,44.76)
  IN3 w0.14: v1(95.7,109.58) 95.84,109.44 95.84,107.5 95.53,107.19 95.53,104.9 92.05,101.43 90.99,101.43 89.06,99.5 88.61,99.5 87.32,98.21 87.32,97.77 86.73,97.18 84.7,97.18 80.81,93.28 76.01,93.28 72.81,90.08 72.81,89.05 62.27,78.52 62.27,53.28 69.42,46.13 71.92,46.13
PEG_CRX_GTX_P6: length 101.4
  TOP w0.102: JCPU1.E28 79.59,44.25 v1(79.11,43.76)
  TOP w0.109: CC26.2 97.7,108.89 97.7,109.08 97.44,109.34 97.44,109.86 97.69,110.1 97.91,110.1 v1(98.08,110.27)
  IN3 w0.089: 71.97,47.39 72,47.36 75.34,47.36 75.71,46.98 75.71,46.62 75.96,46.38 76.31,46.38 76.68,46.01 76.68,45.63 76.96,45.34 77.36,45.34 77.69,45.01 77.69,43.64 77.98,43.36 78.94,43.36 79.11,43.52 v1(79.11,43.76)
  IN3 w0.14: v1(98.08,110.27) 98.24,110.11 98.54,110.11 98.84,109.8 98.84,108.82 97.11,107.1 97.11,104.68 92.54,100.11 91.47,100.11 89.82,98.46 89.43,98.46 88.86,97.9 88.86,97.47 87.51,96.12 85.15,96.12 81.11,92.09 76.31,92.09 73.9,89.68 73.9,88.65 63.34,78.09 63.34,53.73 69.67,47.39 71.97,47.39
PEG_CRX_GTX_P7: length 99.6
  TOP w0.102: v1(78.11,44.76) 78.59,45.25 JCPU1.F29
  TOP w0.109: CC25.2 99.57,108.98 99.57,109.27 99.71,109.41 99.71,109.55 99.55,109.71 v1(99.41,109.71)
  IN3 w0.089: v1(78.11,44.76) 78.01,44.67 78.01,44.23 78.1,44.14 78.43,44.14 78.54,44.26 78.54,45.87 78.24,46.16 77.89,46.16 77.55,46.49 77.55,46.87 77.25,47.18 76.87,47.18 76.54,47.51 76.54,47.88 76.25,48.17 72.01,48.17 71.98,48.14 71.95,48.14
  IN3 w0.14: 71.95,48.14 69.9,48.14 63.89,54.15 63.89,77.87 71.55,85.53 78.95,85.53 82.71,89.3 82.71,91.71 85.65,94.65 86.88,94.65 91.68,99.45 92.82,99.45 98.41,105.04 98.41,106.51 99.55,107.66 99.55,109.57 v1(99.41,109.71)
PEG_CRX_GTX_P8: length 89.9
  TOP w0.102: JCPU1.K34 73.59,49.25 v1(73.11,48.76)
  TOP w0.109: v1(100.78,109.31) 100.99,109.51 101.21,109.51 101.41,109.31 101.41,108.72 101.32,108.63 CC24.2
  IN3 w0.089: v1(73.11,48.76) 73.11,49.06 73,49.17 71.94,49.17 71.91,49.13 71.89,49.13
  IN3 w0.14: v1(100.78,109.31) 100.94,109.46 101.2,109.46 101.38,109.28 101.38,107.99 99.96,106.56 99.96,105.37 93.15,98.56 91.94,98.56 87.23,93.85 86.01,93.85 83.68,91.52 83.68,89.12 79.25,84.69 71.92,84.69 64.69,77.47 64.69,54.63 70.19,49.13 71.89,49.13
PEG_CRX_GTX_P9: length 87.9
  TOP w0.102: JCPU1.L35 72.59,50.24 v1(72.11,49.77)
  TOP w0.109: CC23.2 103.09,108.63 103.18,108.72 103.18,109.31 102.99,109.51 102.77,109.51 v1(102.56,109.31)
  IN3 w0.14: v1(102.56,109.31) 102.72,109.46 102.98,109.46 103.16,109.28 103.16,108.02 101.33,106.19 101.33,105.6 94.04,98.31 94.04,97.83 93.35,97.14 91.94,97.14 87.85,93.05 86.35,93.05 84.74,91.43 84.74,89.06 79.56,83.88 72.93,83.88 66.99,77.94 66.33,77.94 65.5,77.11 65.5,56.33 68.2,53.63 68.2,52.26 70.32,50.14 71.74,50.14 v1(72.11,49.77)
PEG_CRX_GTX_P10: length 89.7
  TOP w0.102: JCPU1.K32 75.59,49.25 v1(75.11,48.76)
  TOP w0.109: CC22.2 104.87,108.63 104.96,108.72 104.96,109.36 104.79,109.54 104.62,109.54 v1(104.42,109.33)
  IN3 w0.089: 71.34,50.94 71.36,50.94 71.39,50.97 71.77,50.97 71.94,51.14 72.27,51.14 72.52,50.89 72.52,50.52 72.87,50.16 73.25,50.16 73.51,49.9 73.51,49.52 73.87,49.17 75,49.17 75.11,49.06 v1(75.11,48.76)
  IN3 w0.14: v1(104.42,109.33) 104.57,109.48 104.83,109.48 104.94,109.38 104.94,108.44 102.88,106.39 102.88,105.98 95.46,98.56 95.46,97.68 93.78,96 91.95,96 87.87,91.91 87.87,91.29 87.18,90.6 87.18,90.37 79.88,83.07 73.26,83.07 67.17,76.98 67.17,57.05 69.02,55.2 69.02,52.58 70.66,50.94 71.34,50.94
PEG_CRX_GTX_P11: length 87.5
  TOP w0.102: v1(74.11,49.76) 74.59,50.25 JCPU1.L33
  TOP w0.109: CC21.2 106.65,108.63 106.74,108.72 106.74,109.31 106.54,109.51 106.32,109.51 v1(106.12,109.31)
  IN3 w0.089: v1(74.11,49.76) 74.11,50.14 74.02,50.23 73.8,50.23 73.51,50.51 73.51,51.06 72.89,51.68 71.11,51.68 70.7,52.09 70.66,52.09 70.64,52.1
  IN3 w0.14: v1(106.12,109.31) 106.27,109.46 106.54,109.46 106.71,109.28 106.71,108.95 104.43,106.67 104.43,106.1 97.06,98.73 97.06,97.88 96.68,97.5 96.42,97.5 93.93,95.01 92.85,95.01 89.73,91.88 89.73,91.32 88.68,90.27 88.22,90.27 80.2,82.25 73.57,82.25 67.97,76.65 67.97,57.39 69.83,55.53 69.83,52.92 70.64,52.1
PEG_CRX_GTX_P12: length 92
  TOP w0.102: JCPU1.K30 77.59,49.25 v1(77.11,48.76)
  TOP w0.109: CC20.2 108.43,108.63 108.52,108.72 108.52,109.31 108.32,109.51 108.1,109.51 v1(107.9,109.31)
  IN3 w0.089: v1(77.11,48.76) 77.11,49.1 77.02,49.19 75.85,49.19 75.51,49.53 75.51,49.9 75.25,50.16 74.87,50.16 74.86,50.17 74.51,50.53 74.51,50.93 74.18,51.25 74.05,51.25 73.4,51.9 73.18,52.12 71.81,52.12 71.34,52.6 71.29,52.6 71.28,52.61
  IN3 w0.14: 71.28,52.61 70.65,53.25 70.65,55.86 68.78,57.73 68.78,76.32 72.12,79.67 73,79.67 74.78,81.45 80.52,81.45 88.45,89.37 90.11,89.37 91.65,90.91 91.65,92.67 93.18,94.19 94.27,94.19 96.76,96.68 97.37,96.68 98.66,97.98 98.66,98.49 104.71,104.53 105.75,104.53 107.48,106.26 107.48,107.48 108.49,108.49 108.49,109.28 108.31,109.46 108.05,109.46 v1(107.9,109.31)
PEG_CRX_GTX_P13: length 90.1
  TOP w0.102: v1(76.11,49.76) 76.59,50.25 JCPU1.L31
  TOP w0.109: v1(109.67,109.31) 109.92,109.55 110.06,109.55 110.3,109.31 110.3,108.72 110.21,108.63 CC19.2
  IN3 w0.089: 71.46,53.93 71.46,53.91 71.49,53.88 71.49,53.56 71.9,53.16 73.33,53.16 73.53,52.95 73.53,52.52 74.31,51.74 74.69,51.74 75.51,50.92 75.51,50.53 75.88,50.16 76.02,50.16 76.11,50.07 v1(76.11,49.76)
  IN3 w0.14: 71.46,53.93 71.46,56.19 69.58,58.07 69.58,75.99 72.44,78.85 73.33,78.85 74.51,80.03 80.24,80.03 88.69,88.48 90.51,88.48 93.56,91.53 93.56,92.6 93.84,92.88 93.84,93 94.21,93.38 94.6,93.38 97.09,95.87 98.05,95.87 100.11,97.93 100.11,98.23 105.47,103.59 106.81,103.59 108.82,105.6 108.82,106.56 110.27,108.01 110.27,109.36 110.12,109.51 109.88,109.51 v1(109.67,109.31)
PEG_CRX_GTX_P14: length 95.3
  TOP w0.102: v1(79.13,49.77) 79.13,49.82 JCPU1.L28
  TOP w0.109: v1(111.82,109.69) 112.01,109.51 112.01,108.97 CC18.2
  IN3 w0.089: 75.48,54.95 75.48,54.93 75.51,54.9 75.51,51.9 76.54,50.87 76.54,50.52 76.9,50.16 77.25,50.16 77.5,49.91 77.5,48.56 77.9,48.15 79.43,48.15 79.73,48.45 79.73,49.17 v1(79.13,49.77)
  IN3 w0.14: 75.48,54.95 75.48,55.19 74.43,56.25 72.55,56.25 70.38,58.42 70.38,75.66 72.76,78.04 73.66,78.04 74.85,79.23 80.57,79.23 88.96,87.62 90.89,87.62 95.93,92.65 95.93,93.58 97.41,95.06 98.76,95.06 101.58,97.88 101.58,98.11 103.26,99.78 104.55,99.78 110.4,105.63 110.4,106.44 111.98,108.02 111.98,109.53 v1(111.82,109.69)
PEG_CRX_GTX_P15: length 91
  TOP w0.102: v1(78.11,49.76) 78.59,50.25 JCPU1.L29
  TOP w0.109: CC17.2 113.78,108.97 113.78,109.54 v1(113.61,109.71)
  IN3 w0.089: 77.48,55.03 77.48,55 77.51,54.97 77.51,50.52 77.69,50.35 77.98,50.06 78.11,49.93 v1(78.11,49.76)
  IN3 w0.14: v1(113.61,109.71) 113.78,109.55 113.78,108.39 111.77,106.39 111.77,105.45 105.14,98.82 103.74,98.82 103.03,98.11 103.03,97.85 99.42,94.24 97.74,94.24 96.78,93.28 96.78,92.37 91.22,86.8 89.28,86.8 80.9,78.43 75.2,78.43 74,77.23 73.08,77.23 71.18,75.32 71.18,58.76 71.84,58.09 72.73,58.09 73.74,57.08 75.67,57.08 77.48,55.28 77.48,55.03
PEG_CTX_GRX_C_N0: length 120.9
  TOP w0.102: v1(83.11,39.76) 83.59,40.25 JCPU1.A24
  TOP w0.109: v1(87.28,92.37) 87.06,92.59 87.06,92.73 87.19,92.87 87.45,92.87 87.71,93.12 87.71,93.35 CC50.2
  IN4 w0.089: v1(83.11,39.76) 82.93,39.93 82.38,39.93 82.22,39.77 82.22,39.31 82.32,39.2 82.32,38.96 82.33,38.95 82.33,38.88 82.35,38.86 82.35,38.85
  IN4 w0.135: 82.35,38.85 82.35,37.09 79.59,34.33 79.59,29.69 76.55,26.66 72.37,26.66 69.33,29.7 69.33,31.1 59.01,41.41 59.01,52.76 58.17,53.6 58.17,72.07 58.43,72.33 58.43,73.62 59.01,74.21 59.01,77.9 58.5,78.41 58.5,80.84 70.95,93.28 71.92,93.28 74.16,95.52 80.45,95.52 82.03,93.94 86.71,93.94 87.26,93.39 87.26,92.39 v1(87.28,92.37)
PEG_CTX_GRX_C_N1: length 123.2
  TOP w0.102: JCPU1.B25 82.59,41.25 v1(82.11,40.76)
  TOP w0.109: CC77.2 89.48,93.35 89.48,93.1 88.97,92.58 88.97,91.82 v1(89.19,91.6)
  IN4 w0.089: v1(82.11,40.76) 82.11,41.21 82,41.32 81.79,41.32 81.68,41.21 81.68,39.49 81.52,39.33 81.52,39.1 81.55,39.07 81.55,39.05
  IN4 w0.135: v1(89.19,91.6) 88.98,91.81 88.98,92.03 89.18,92.23 89.57,92.23 89.77,92.02 89.77,91.37 89.01,90.61 84.16,90.61 80.06,94.71 74.51,94.71 70.97,91.17 70.45,91.17 59.3,80.02 59.3,78.8 59.81,78.29 59.81,73.86 59.24,73.29 59.24,72 58.99,71.74 58.99,53.96 59.83,53.12 59.83,41.74 70.14,31.43 70.14,30.03 72.7,27.47 76.22,27.47 78.77,30.02 78.77,34.66 81.55,37.43 81.55,39.05
PEG_CTX_GRX_C_N2: length 121.1
  TOP w0.102: JCPU1.A26 81.59,40.25 v1(81.11,39.76)
  TOP w0.109: CC62.2 91.39,93.35 91.39,93.1 91,92.71 91,91.82 v1(91.22,91.6)
  IN4 w0.089: v1(81.11,39.76) 81.11,40.24 81,40.34 80.79,40.34 80.7,40.26 80.7,39.46 80.74,39.43 80.74,39.41
  IN4 w0.135: v1(91.22,91.6) 91.04,91.78 91.04,92.01 91.2,92.16 91.65,92.16 91.91,91.9 91.91,90.31 90.95,89.36 84.28,89.36 79.72,93.91 75.04,93.91 71.26,90.13 70.55,90.13 60.61,80.19 60.61,73.52 60.05,72.96 60.05,71.64 59.8,71.39 59.8,54.31 60.64,53.47 60.64,42.07 70.95,31.76 70.95,30.36 73.03,28.28 75.89,28.28 77.96,30.35 77.96,35.77 80.74,38.55 80.74,39.41
PEG_CTX_GRX_C_N3: length 109.9
  TOP w0.102: v1(80.11,40.76) 80.59,41.25 JCPU1.B27
  TOP w0.109: CC49.2 93.18,93.36 93.18,93.09 92.91,92.82 92.91,92.7 v1(93.13,92.49)
  IN4 w0.089: 79.74,39.62 79.74,39.64 79.7,39.68 79.7,41.26 79.79,41.34 80,41.34 80.11,41.24 v1(80.11,40.76)
  IN4 w0.135: v1(93.13,92.49) 92.95,92.67 92.95,92.89 93.15,93.1 93.53,93.1 93.68,92.95 93.68,90.95 91.29,88.56 83.94,88.56 79.39,93.11 75.57,93.11 71.49,89.04 70.59,89.04 61.43,79.87 61.43,73.19 60.87,72.63 60.87,71.31 60.61,71.06 60.61,54.64 61.45,53.8 61.45,42.87 64.22,40.1 68.55,35.77 76.82,35.77 79.74,38.68 79.74,39.62
PEG_CTX_GRX_C_N4: length 107
  TOP w0.102: v1(79.11,39.76) 79.59,40.25 JCPU1.A28
  TOP w0.109: v1(95.18,92.64) 94.94,92.88 94.94,93.35 CC76.2
  IN4 w0.089: 78.71,39.41 78.71,39.43 78.68,39.46 78.68,40.23 78.79,40.34 79,40.34 79.11,40.24 v1(79.11,39.76)
  IN4 w0.135: v1(95.18,92.64) 94.97,92.86 94.97,93.19 95.13,93.36 95.67,93.36 95.89,93.13 95.89,92.01 91.63,87.74 83.62,87.74 79.06,92.3 76.09,92.3 71.94,88.15 70.84,88.15 62.24,79.55 62.24,72.86 61.68,72.3 61.68,70.98 61.43,70.73 61.43,54.97 62.26,54.13 62.26,43.19 68.88,36.58 76.49,36.58 78.71,38.81 78.71,39.41
PEG_CTX_GRX_C_N5: length 100.9
  TOP w0.102: JCPU1.B29 78.59,41.25 v1(78.11,40.76)
  TOP w0.109: v1(96.43,90.41) 96.21,90.62 96.21,91.07 96.46,91.31 96.46,91.56 CC59.2
  IN4 w0.089: v1(78.11,40.76) 78.11,41.24 78,41.34 77.79,41.34 77.68,41.23 77.68,39.31 77.71,39.28 77.71,39.25
  IN4 w0.135: v1(96.43,90.41) 96.27,90.56 96.27,90.84 96.38,90.94 96.99,90.94 97.21,90.71 97.21,90.13 92.63,85.55 69.38,85.55 63.05,79.22 63.05,72.53 62.49,71.97 62.49,70.63 62.24,70.37 62.24,55.3 63.08,54.46 63.08,43.52 69.21,37.39 76.12,37.39 77.71,38.98 77.71,39.25
PEG_CTX_GRX_C_N6: length 97.8
  TOP w0.102: JCPU1.A30 77.59,40.25 v1(77.11,39.76)
  TOP w0.109: CC48.2 97.99,93.35 97.99,93.23 98.21,93.02 98.21,92.45 97.99,92.23 97.69,92.23 v1(97.47,92.01)
  IN4 w0.089: v1(77.11,39.76) 77.11,40.01 77,40.12 76.79,40.12 76.68,40 76.68,39.49 76.71,39.46 76.71,39.43
  IN4 w0.135: v1(97.47,92.01) 97.72,92.26 97.9,92.26 98.03,92.13 98.03,89.8 92.97,84.75 69.72,84.75 63.86,78.9 63.86,72.2 63.36,71.69 63.36,70.28 63.05,69.97 63.05,55.63 63.89,54.79 63.89,43.84 69.54,38.19 75.78,38.19 76.71,39.12 76.71,39.43
PEG_CTX_GRX_C_N7: length 96.4
  TOP w0.102: JCPU1.B31 76.59,41.25 v1(76.11,40.76)
  TOP w0.109: v1(99.25,92.01) 99.47,92.23 99.77,92.23 99.98,92.45 99.98,93.02 99.77,93.23 99.77,93.35 CC75.2
  IN4 w0.089: 74.91,38.99 74.94,38.99 74.96,39.01 75.35,39.01 75.73,39.39 75.73,41.08 75.81,41.17 75.97,41.17 76.11,41.03 v1(76.11,40.76)
  IN4 w0.135: v1(99.25,92.01) 99.5,92.26 99.67,92.26 99.81,92.13 99.81,90.44 93.31,83.94 70.05,83.94 64.68,78.57 64.68,71.87 64.16,71.35 64.16,69.95 63.86,69.66 63.86,55.99 64.7,55.15 64.7,44.27 69.98,38.99 74.91,38.99
PEG_CTX_GRX_C_N8: length 91.2
  TOP w0.102: JCPU1.B32 75.59,41.25 v1(75.11,40.76)
  TOP w0.109: CC56.2 101.55,93.35 101.55,92.86 101.66,92.75 v1(101.86,92.75)
  IN4 w0.089: 71.94,40.37 71.97,40.35 74.99,40.35 75.11,40.46 v1(75.11,40.76)
  IN4 w0.135: 71.94,40.37 71.1,40.37 71,40.47 70.56,40.47 70.46,40.37 70.09,40.37 69.82,40.65 69.82,40.79 69.5,41.11 69.36,41.11 65.77,44.7 65.77,55.61 64.93,56.45 64.93,69.23 65.21,69.51 65.21,70.9 65.74,71.44 65.74,78.15 70.47,82.88 93.74,82.88 101.46,90.59 101.46,92.59 101.61,92.75 v1(101.86,92.75)
PEG_CTX_GRX_C_N9: length 88.8
  TOP w0.102: v1(74.11,41.76) 74.59,42.25 JCPU1.C33
  TOP w0.109: v1(103.64,92.75) 103.44,92.75 103.33,92.86 103.33,93.35 CC47.2
  IN4 w0.089: v1(74.11,41.76) 74.11,41.52 73.94,41.35 71.93,41.35 71.89,41.39
  IN4 w0.135: v1(103.64,92.75) 103.39,92.75 103.23,92.59 103.23,91.2 94.1,82.06 71.22,82.06 66.91,77.76 66.91,71.46 66.01,70.56 66.01,69.18 65.74,68.92 65.74,56.78 66.91,55.62 66.91,44.84 69.63,42.12 69.78,42.12 70.08,41.82 70.08,41.67 70.37,41.39 70.75,41.39 70.85,41.49 71.27,41.49 71.37,41.39 71.89,41.39
PEG_CTX_GRX_C_N10: length 95.2
  TOP w0.102: v1(77.11,45.76) 77.59,46.25 JCPU1.G30
  TOP w0.109: v1(104.58,92.01) 104.8,92.23 105.1,92.23 105.32,92.45 105.32,93.02 105.1,93.23 105.1,93.35 CC74.2
  IN4 w0.089: 71.92,42.14 71.93,42.14 71.95,42.16 72.01,42.16 72.01,42.16 76.39,42.16 76.72,42.49 76.72,46.07 76.8,46.15 77.02,46.15 77.11,46.06 v1(77.11,45.76)
  IN4 w0.135: 71.92,42.14 71.16,42.14 67.45,45.84 67.45,56.17 67.16,56.47 67.16,70.92 67.45,71.22 67.45,77.53 71.42,81.49 94.32,81.49 101.94,89.11 102.85,89.11 105.14,91.4 105.14,92.13 105.01,92.26 104.83,92.26 v1(104.58,92.01)
PEG_CTX_GRX_C_N11: length 97.8
  TOP w0.102: v1(76.11,47.76) 76.59,48.25 JCPU1.J31
  TOP w0.109: CC46.2 106.88,93.35 106.88,92.68 106.99,92.57 107.37,92.57 107.45,92.64 107.45,92.82 v1(107.37,92.9)
  IN4 w0.089: 72.78,43.41 72.79,43.41 72.85,43.36 75.29,43.36 75.49,43.55 75.49,47.15 75.71,47.37 76.01,47.37 76.11,47.46 v1(76.11,47.76)
  IN4 w0.135: v1(107.37,92.9) 107.68,92.59 107.86,92.59 108.14,92.32 108.14,85.38 102.8,80.05 71.45,80.05 68.51,77.1 68.51,70.77 68.21,70.47 68.21,56.91 68.51,56.61 68.51,46.28 71.38,43.41 72.78,43.41
PEG_CTX_GRX_C_N12: length 93.7
  TOP w0.102: v1(75.11,46.76) 75.59,47.25 JCPU1.H32
  TOP w0.109: CC73.2 108.66,93.33 108.66,92.68 108.77,92.57 109.15,92.57 109.23,92.64 109.23,92.82 v1(109.15,92.9)
  IN4 w0.089: v1(75.11,46.76) 75.11,46.45 75.02,46.36 74.76,46.36 74.5,46.11 74.5,44.52 74.34,44.36 72,44.36 71.98,44.38 71.97,44.38
  IN4 w0.135: 71.97,44.38 71.54,44.38 69.31,46.61 69.31,56.95 69,57.26 69,70.13 69.31,70.44 69.31,76.78 71.78,79.24 103.14,79.24 109.86,85.96 109.86,92.37 109.64,92.59 109.46,92.59 v1(109.15,92.9)
PEG_CTX_GRX_C_N13: length 92.7
  TOP w0.102: JCPU1.J33 74.59,48.25 v1(74.11,47.76)
  TOP w0.109: v1(110.69,92.54) 110.77,92.47 110.77,92.29 110.69,92.21 110.42,92.21 110.22,92.41 110.22,92.91 110.44,93.12 110.44,93.35 CC53.2
  IN4 w0.089: v1(74.11,47.76) 74.11,47.49 73.97,47.36 73.73,47.36 73.51,47.14 73.51,45.62 73.24,45.36 72,45.36 71.97,45.39 71.95,45.39
  IN4 w0.135: 71.95,45.39 71.67,45.39 70.11,46.95 70.11,57.32 69.8,57.63 69.8,69.8 70.11,70.11 70.11,76.45 72.1,78.44 105.31,78.44 107.73,80.86 107.73,82.18 111.41,85.86 111.41,92.06 111.24,92.24 110.99,92.24 v1(110.69,92.54)
PEG_CTX_GRX_C_N14: length 87.9
  TOP w0.102: v1(73.11,46.76) 73.59,47.25 JCPU1.H34
  TOP w0.109: v1(112.43,92.62) 112.22,92.83 112.22,93.35 CC45.2
  IN4 w0.089: 71.56,46.65 71.58,46.63 71.58,46.59 71.8,46.37 72.36,46.37 72.53,46.2 73.02,46.2 73.11,46.29 v1(73.11,46.76)
  IN4 w0.135: 71.56,46.65 70.91,47.3 70.91,57.66 70.59,57.98 70.59,69.46 70.91,69.78 70.91,76.13 72.41,77.63 105.92,77.63 112.61,84.31 112.61,91.94 112.23,92.32 112.23,92.42 v1(112.43,92.62)
PEG_CTX_GRX_C_N15: length 86.3
  TOP w0.102: JCPU1.H35 72.13,46.81 v1(72.13,46.76)
  TOP w0.109: CC44.2 113.99,93.35 113.99,92.83 v1(114.21,92.62)
  IN4 w0.089: v1(72.13,46.76) 72.13,46.91 72.24,47.02 72.48,47.02 72.72,47.25 72.72,50.93 72.75,50.96 72.75,50.99
  IN4 w0.135: v1(114.21,92.62) 114.02,92.43 114.02,84.4 106.44,76.83 72.73,76.83 71.71,75.8 71.71,69.43 71.41,69.12 71.41,58.31 71.71,58 71.71,52.56 72.75,51.53 72.75,50.99
PEG_CTX_GRX_C_P0: length 120.8
  TOP w0.102: JCPU1.B24 83.59,41.25 v1(83.11,40.76)
  TOP w0.109: v1(86.65,92.37) 86.85,92.57 86.85,92.82 87.11,93.08 87.37,93.08 87.5,93.21 87.5,93.35 CC64.2
  IN4 w0.089: 82.1,38.85 82.1,38.86 82.11,38.88 82.11,39.11 82.01,39.22 82.01,39.86 82.29,40.14 83.35,40.14 83.5,40.3 83.5,40.64 83.37,40.76 v1(83.11,40.76)
  IN4 w0.135: v1(86.65,92.37) 87,92.72 87,93.29 86.61,93.69 81.92,93.69 80.34,95.27 74.27,95.27 72.02,93.03 71.05,93.03 58.76,80.73 58.76,78.52 59.27,78.01 59.27,74.1 58.68,73.52 58.68,72.22 58.43,71.97 58.43,53.71 59.27,52.87 59.27,41.51 69.58,31.2 69.58,29.8 72.47,26.91 76.45,26.91 79.33,29.79 79.33,34.43 82.1,37.2 82.1,38.85
PEG_CTX_GRX_C_P1: length 123.2
  TOP w0.102: v1(82.11,41.76) 82.59,42.25 JCPU1.C25
  TOP w0.109: v1(88.55,91.6) 88.76,91.81 88.76,92.67 89.27,93.19 89.27,93.35 CC63.2
  IN4 w0.089: v1(82.11,41.76) 82.11,41.63 81.98,41.51 81.71,41.51 81.49,41.29 81.49,39.57 81.33,39.41 81.33,39.1 81.29,39.07 81.29,39.05
  IN4 w0.135: 81.29,39.05 81.29,37.54 78.52,34.76 78.52,30.12 76.12,27.72 72.81,27.72 70.39,30.14 70.39,31.53 60.08,41.84 60.08,53.22 59.24,54.06 59.24,71.64 59.5,71.89 59.5,73.19 60.06,73.75 60.06,78.4 59.55,78.91 59.55,79.91 70.56,90.92 71.08,90.92 74.62,94.46 79.95,94.46 84.05,90.36 89.12,90.36 90.03,91.27 90.03,92.12 89.67,92.48 89.07,92.48 88.73,92.14 88.73,91.78 v1(88.55,91.6)
PEG_CTX_GRX_C_P2: length 121.1
  TOP w0.102: v1(81.11,40.76) 81.59,41.25 JCPU1.B26
  TOP w0.109: CC72.2 91.18,93.35 91.18,93.19 90.79,92.8 90.79,91.81 v1(90.59,91.6)
  IN4 w0.089: 80.48,39.41 80.48,39.43 80.51,39.46 80.51,40.34 80.71,40.53 80.98,40.53 81.11,40.66 v1(81.11,40.76)
  IN4 w0.135: v1(90.59,91.6) 90.79,91.81 90.79,92.11 91.09,92.42 91.75,92.42 92.16,92.01 92.16,90.21 91.05,89.1 84.17,89.1 79.62,93.66 75.14,93.66 71.36,89.88 70.65,89.88 60.87,80.09 60.87,73.42 60.31,72.86 60.31,71.54 60.05,71.28 60.05,54.42 60.89,53.58 60.89,42.17 71.2,31.86 71.2,30.47 73.14,28.53 75.78,28.53 77.71,30.46 77.71,35.88 80.48,38.65 80.48,39.41
PEG_CTX_GRX_C_P3: length 109.9
  TOP w0.102: JCPU1.C27 80.59,42.25 v1(80.11,41.76)
  TOP w0.109: CC61.2 92.97,93.33 92.97,93.18 92.7,92.91 92.7,92.7 v1(92.49,92.49)
  IN4 w0.089: 79.48,39.62 79.48,39.64 79.51,39.68 79.51,41.34 79.71,41.53 79.98,41.53 80.11,41.66 v1(80.11,41.76)
  IN4 w0.135: 79.48,39.62 79.48,38.79 76.72,36.02 68.66,36.02 61.71,42.97 61.71,53.91 60.87,54.75 60.87,70.95 61.12,71.21 61.12,72.53 61.68,73.09 61.68,79.77 70.7,88.78 71.6,88.78 75.67,92.85 79.29,92.85 83.84,88.3 91.4,88.3 93.94,90.84 93.94,93.05 93.63,93.36 93.05,93.36 92.69,93 92.69,92.7 v1(92.49,92.49)
PEG_CTX_GRX_C_P4: length 107
  TOP w0.102: JCPU1.B28 79.59,41.25 v1(79.11,40.76)
  TOP w0.109: v1(94.5,92.64) 94.73,92.88 94.73,93.35 CC60.2
  IN4 w0.089: 78.46,39.41 78.46,39.43 78.49,39.46 78.49,40.31 78.71,40.53 78.98,40.53 79.11,40.66 v1(79.11,40.76)
  IN4 w0.135: 78.46,39.41 78.46,38.91 76.38,36.84 68.98,36.84 62.52,43.3 62.52,54.24 61.68,55.08 61.68,70.62 61.93,70.88 61.93,72.2 62.49,72.76 62.49,79.45 70.94,87.89 72.04,87.89 76.2,92.05 78.96,92.05 83.52,87.49 91.73,87.49 96.15,91.9 96.15,93.23 95.77,93.61 95.03,93.61 94.71,93.3 94.71,92.86 v1(94.5,92.64)
PEG_CTX_GRX_C_P5: length 100.8
  TOP w0.102: v1(78.11,41.76) 78.59,42.25 JCPU1.C29
  TOP w0.109: CC71.2 96.25,91.58 96.25,91.4 96,91.15 96,90.62 v1(95.79,90.41)
  IN4 w0.089: 77.46,39.25 77.46,39.28 77.49,39.31 77.49,41.31 77.71,41.53 77.98,41.53 78.11,41.66 v1(78.11,41.76)
  IN4 w0.135: 77.46,39.25 77.46,39.08 76.01,37.64 69.32,37.64 63.33,43.63 63.33,54.57 62.49,55.41 62.49,70.27 62.75,70.52 62.75,71.87 63.31,72.43 63.31,79.12 69.49,85.3 92.74,85.3 97.47,90.03 97.47,90.82 97.09,91.2 96.27,91.2 96.02,90.94 96.02,90.64 v1(95.79,90.41)
PEG_CTX_GRX_C_P6: length 97.7
  TOP w0.102: v1(77.11,40.76) 77.59,41.25 JCPU1.B30
  TOP w0.109: v1(97.47,92.77) 97.37,92.67 97.37,92.54 97.47,92.44 97.9,92.44 97.99,92.54 97.99,92.93 97.78,93.14 97.78,93.35 CC58.2
  IN4 w0.089: v1(77.11,40.76) 77.11,40.43 76.98,40.31 76.71,40.31 76.49,40.08 76.49,39.49 76.46,39.46 76.46,39.43
  IN4 w0.135: 76.46,39.43 76.46,39.23 75.68,38.44 69.65,38.44 64.14,43.95 64.14,54.9 63.31,55.74 63.31,69.87 63.61,70.17 63.61,71.59 64.12,72.1 64.12,78.79 69.82,84.49 93.08,84.49 98.28,89.7 98.28,92.24 98,92.52 97.72,92.52 v1(97.47,92.77)
PEG_CTX_GRX_C_P7: length 96.3
  TOP w0.102: v1(76.11,41.76) 76.59,42.25 JCPU1.C31
  TOP w0.109: v1(99.25,92.77) 99.14,92.67 99.14,92.54 99.25,92.44 99.68,92.44 99.77,92.54 99.77,92.93 99.56,93.14 99.56,93.35 CC57.2
  IN4 w0.089: v1(76.11,41.76) 76.11,41.51 75.95,41.36 75.74,41.36 75.54,41.16 75.54,39.47 75.27,39.2 74.95,39.2 74.91,39.24
  IN4 w0.135: 74.91,39.24 70.09,39.24 64.96,44.37 64.96,55.26 64.12,56.09 64.12,69.55 64.41,69.84 64.41,71.24 64.93,71.77 64.93,78.46 70.15,83.68 93.41,83.68 100.06,90.33 100.06,92.24 99.78,92.52 99.5,92.52 v1(99.25,92.77)
PEG_CTX_GRX_C_P8: length 91.1
  TOP w0.102: v1(75.11,39.76) 75.59,40.25 JCPU1.A32
  TOP w0.109: v1(101.05,92.75) 101.23,92.75 101.34,92.86 101.34,93.35 CC70.2
  IN4 w0.089: v1(75.11,39.76) 75.11,40.05 75.01,40.14 71.97,40.14 71.94,40.12
  IN4 w0.135: v1(101.05,92.75) 101.2,92.59 101.2,90.69 93.64,83.13 70.36,83.13 65.49,78.26 65.49,71.54 64.96,71.01 64.96,69.62 64.68,69.34 64.68,56.34 65.52,55.51 65.52,44.59 69.99,40.12 71.94,40.12
PEG_CTX_GRX_C_P9: length 88.8
  TOP w0.102: JCPU1.B33 74.59,41.25 74.11,40.76 v1(74.11,40.75)
  TOP w0.109: CC55.2 103.12,93.35 103.12,92.86 103.01,92.75 v1(102.83,92.75)
  IN4 w0.089: 71.89,41.13 71.9,41.13 71.93,41.16 73.95,41.16 74.11,41 v1(74.11,40.75)
  IN4 w0.135: v1(102.83,92.75) 102.98,92.59 102.98,91.3 93.99,82.32 71.11,82.32 66.66,77.86 66.66,71.56 65.76,70.66 65.76,69.29 65.49,69.02 65.49,56.68 66.66,55.51 66.66,44.74 70.26,41.13 71.89,41.13
PEG_CTX_GRX_C_P10: length 95.2
  TOP w0.102: v1(77.11,46.76) 77.59,47.25 JCPU1.H30
  TOP w0.109: CC54.2 104.89,93.35 104.89,93.14 105.11,92.93 105.11,92.54 105.01,92.44 104.58,92.44 104.48,92.54 104.48,92.67 v1(104.58,92.77)
  IN4 w0.089: 71.92,42.39 71.93,42.39 71.95,42.37 76.3,42.37 76.51,42.58 76.51,46.16 76.71,46.36 76.98,46.36 77.11,46.48 v1(77.11,46.76)
  IN4 w0.135: 71.92,42.39 71.26,42.39 67.71,45.95 67.71,56.28 67.41,56.57 67.41,70.81 67.71,71.11 67.71,77.43 71.52,81.24 94.42,81.24 102.04,88.86 102.96,88.86 105.39,91.29 105.39,92.24 105.11,92.52 104.83,92.52 v1(104.58,92.77)
PEG_CTX_GRX_C_P11: length 97.8
  TOP w0.102: JCPU1.H31 76.59,47.25 v1(76.11,46.76)
  TOP w0.109: CC69.2 106.67,93.35 106.67,92.59 106.91,92.36 107.15,92.36 v1(107.37,92.14)
  IN4 w0.089: 72.75,43.16 72.76,43.16 72.77,43.15 75.38,43.15 75.7,43.47 75.7,47.06 75.79,47.16 76.03,47.16 76.11,47.08 v1(76.11,46.76)
  IN4 w0.135: v1(107.37,92.14) 107.58,92.34 107.76,92.34 107.88,92.21 107.88,85.49 102.7,80.3 71.35,80.3 68.25,77.21 68.25,70.87 67.95,70.57 67.95,56.8 68.25,56.5 68.25,46.18 71.28,43.16 72.75,43.16
PEG_CTX_GRX_C_P12: length 93.8
  TOP w0.102: v1(75.11,45.76) 75.59,46.25 JCPU1.G32
  TOP w0.109: v1(109.15,92.14) 108.93,92.36 108.68,92.36 108.45,92.59 108.45,93.35 CC52.2
  IN4 w0.089: 71.97,44.12 71.98,44.12 72,44.15 72.07,44.15 72.07,44.15 74.43,44.15 74.71,44.43 74.71,46.02 74.84,46.15 75.03,46.15 75.11,46.08 v1(75.11,45.76)
  IN4 w0.135: v1(109.15,92.14) 109.36,92.34 109.53,92.34 109.61,92.26 109.61,86.07 103.04,79.5 71.67,79.5 69.06,76.88 69.06,70.55 68.75,70.24 68.75,57.15 69.06,56.84 69.06,46.5 71.44,44.12 71.97,44.12
PEG_CTX_GRX_C_P13: length 92.7
  TOP w0.102: JCPU1.H33 74.59,47.25 v1(74.11,46.76)
  TOP w0.109: CC51.2 110.23,93.35 110.23,93.21 110.01,92.99 110.01,92.32 110.33,92 110.47,92 v1(110.69,91.78)
  IN4 w0.089: v1(74.11,46.76) 74.11,47.05 73.99,47.17 73.81,47.17 73.7,47.06 73.7,45.54 73.32,45.17 72,45.17 71.97,45.14 71.95,45.14
  IN4 w0.135: v1(110.69,91.78) 110.89,91.98 111.03,91.98 111.16,91.85 111.16,85.97 107.48,82.29 107.48,80.96 105.2,78.69 71.99,78.69 69.86,76.56 69.86,70.21 69.55,69.9 69.55,57.52 69.86,57.21 69.86,46.85 71.57,45.14 71.95,45.14
PEG_CTX_GRX_C_P14: length 88
  TOP w0.102: JCPU1.G34 73.59,46.25 v1(73.11,45.76)
  TOP w0.109: v1(111.79,92.62) 112.01,92.83 112.01,93.35 CC68.2
  IN4 w0.089: 71.38,46.47 71.4,46.45 71.44,46.45 71.61,46.29 71.72,46.17 72.28,46.17 72.45,46.01 73.01,46.01 73.11,45.91 v1(73.11,45.76)
  IN4 w0.135: 71.38,46.47 70.66,47.19 70.66,57.56 70.34,57.87 70.34,69.57 70.66,69.89 70.66,76.23 72.31,77.89 105.82,77.89 112.35,84.42 112.35,91.83 111.97,92.21 111.97,92.44 v1(111.79,92.62)
PEG_CTX_GRX_C_P15: length 86.3
  TOP w0.102: JCPU1.J35 72.13,47.81 v1(72.13,47.76)
  TOP w0.109: v1(113.57,92.62) 113.78,92.83 113.78,93.35 CC67.2
  IN4 w0.089: 72.49,50.99 72.49,50.96 72.53,50.93 72.53,47.33 72.4,47.21 72.19,47.21 72.13,47.27 v1(72.13,47.76)
  IN4 w0.135: 72.49,50.99 72.49,51.42 71.46,52.46 71.46,57.9 71.15,58.2 71.15,69.23 71.46,69.53 71.46,75.91 72.63,77.08 106.33,77.08 113.76,84.51 113.76,92.43 v1(113.57,92.62)
PEG_CTX_GRX_N0: length 2.6
  TOP w0.109: CC50.1 87.69,94.96 87.69,95.38 87.35,95.72 87.35,95.93 87.5,96.09 JMXM1.176
PEG_CTX_GRX_N1: length 2.8
  TOP w0.109: JMXM1.170 89,96.06 88.83,95.9 88.83,95.72 89.01,95.54 89.21,95.54 89.49,95.26 89.49,94.93 CC77.1
PEG_CTX_GRX_N2: length 3.2
  TOP w0.109: CC62.1 91.4,94.93 91.4,95.34 91.12,95.62 90.48,95.62 90.36,95.74 90.36,95.92 90.5,96.07 JMXM1.164
PEG_CTX_GRX_N3: length 3.2
  TOP w0.109: CC49.1 93.18,94.93 93.18,95.14 93.44,95.41 94.06,95.41 94.36,95.7 94.36,95.93 94.5,96.08 JMXM1.156
PEG_CTX_GRX_N4: length 3
  TOP w0.109: CC76.1 94.95,94.93 94.95,95.11 95.22,95.38 95.6,95.38 95.86,95.64 95.86,95.88 96,96.03 JMXM1.150
PEG_CTX_GRX_N5: length 4.6
  TOP w0.109: JMXM1.144 97.5,96.08 97.36,95.94 97.36,95.68 96.46,94.79 96.46,94.64 96.47,94.63 v3(96.47,94.19) 96.47,93.17 CC59.1
PEG_CTX_GRX_N6: length 3
  TOP w0.109: CC48.1 97.98,94.96 97.98,95.11 98.15,95.29 98.52,95.29 98.86,95.63 98.86,95.89 99,96.03 JMXM1.138
PEG_CTX_GRX_N7: length 2.6
  TOP w0.109: JMXM1.132 100.5,96.06 100.36,95.91 100.36,95.68 99.78,95.11 99.78,94.93 CC75.1
PEG_CTX_GRX_N8: length 2.5
  TOP w0.109: CC56.1 101.55,94.94 101.55,95.22 101.87,95.54 101.87,95.9 102,96.03 JMXM1.126
PEG_CTX_GRX_N9: length 2.4
  TOP w0.109: JMXM1.120 103.5,96.05 103.36,95.9 103.36,94.91 CC47.1
PEG_CTX_GRX_N10: length 2.5
  TOP w0.109: JMXM1.114 105,96.05 104.86,95.9 104.86,95.57 105.11,95.31 105.11,94.93 CC74.1
PEG_CTX_GRX_N11: length 2.6
  TOP w0.109: CC46.1 106.87,94.95 106.87,95.19 106.36,95.71 106.36,95.89 106.5,96.04 JMXM1.108
PEG_CTX_GRX_N12: length 2.9
  TOP w0.109: CC73.1 108.64,94.94 108.64,95.24 108.29,95.59 107.98,95.59 107.86,95.72 107.86,95.89 108,96.04 JMXM1.102
PEG_CTX_GRX_N13: length 3.1
  TOP w0.109: JMXM1.96 109.5,96.04 109.38,95.92 109.38,95.67 109.51,95.54 110.04,95.54 110.43,95.15 110.43,94.95 CC53.1
PEG_CTX_GRX_N14: length 3.3
  TOP w0.109: CC45.1 112.2,94.96 112.2,95.13 111.89,95.45 111.32,95.45 110.86,95.91 110.86,96.03 111,96.17 JMXM1.90
PEG_CTX_GRX_N15: length 3.3
  TOP w0.109: JMXM1.84 112.5,96.03 113.22,95.31 113.67,95.31 113.94,95.05 113.94,94.9 114.23,94.6 CC44.1
PEG_CTX_GRX_P0: length 2.5
  TOP w0.109: JMXM1.178 87,96.08 87.14,95.94 87.14,95.64 87.48,95.29 87.48,94.92 CC64.1
PEG_CTX_GRX_P1: length 2.8
  TOP w0.109: JMXM1.172 88.5,96.05 88.62,95.93 88.62,95.63 88.92,95.33 89.13,95.33 89.28,95.17 89.28,94.95 CC63.1
PEG_CTX_GRX_P2: length 3.2
  TOP w0.109: CC72.1 91.19,94.95 91.19,95.25 91.03,95.41 90.4,95.41 90.14,95.66 90.14,95.92 90,96.07 JMXM1.166
PEG_CTX_GRX_P3: length 3.3
  TOP w0.109: JMXM1.158 94,96.06 94.14,95.92 94.14,95.79 93.97,95.62 93.35,95.62 92.97,95.23 92.97,94.95 CC61.1
PEG_CTX_GRX_P4: length 3
  TOP w0.109: JMXM1.152 95.5,96.04 95.64,95.89 95.64,95.73 95.51,95.59 95.13,95.59 94.74,95.2 94.74,94.95 CC60.1
PEG_CTX_GRX_P5: length 4.6
  TOP w0.109: CC71.1 96.25,93.15 96.25,93.9 96.22,93.93 96.22,94.47 96.25,94.5 96.25,94.87 97.14,95.77 97.14,95.94 97,96.08 JMXM1.146
PEG_CTX_GRX_P6: length 3
  TOP w0.109: JMXM1.140 98.5,96.04 98.64,95.9 98.64,95.71 98.43,95.5 98.07,95.5 97.77,95.2 97.77,94.92 CC58.1
PEG_CTX_GRX_P7: length 2.6
  TOP w0.109: CC57.1 99.57,94.95 99.57,95.2 100.14,95.77 100.14,95.92 100,96.07 JMXM1.134
PEG_CTX_GRX_P8: length 2.5
  TOP w0.109: JMXM1.128 101.5,96.05 101.66,95.9 101.66,95.63 101.33,95.3 101.33,94.94 CC70.1
PEG_CTX_GRX_P9: length 2.4
  TOP w0.109: JMXM1.122 103,96.05 103.14,95.91 103.14,94.97 CC55.1
PEG_CTX_GRX_P10: length 2.5
  TOP w0.109: JMXM1.116 104.5,96.05 104.64,95.91 104.64,95.48 104.9,95.22 104.9,94.95 CC54.1
PEG_CTX_GRX_P11: length 2.6
  TOP w0.109: JMXM1.110 106,96.05 106.14,95.91 106.14,95.62 106.66,95.1 106.66,94.93 CC69.1
PEG_CTX_GRX_P12: length 2.9
  TOP w0.109: CC52.1 108.43,94.92 108.43,95.15 108.2,95.38 107.9,95.38 107.64,95.63 107.64,95.9 107.5,96.05 JMXM1.104
PEG_CTX_GRX_P13: length 3.2
  TOP w0.109: CC51.1 110.22,94.93 110.22,95.06 109.95,95.33 109.42,95.33 109.17,95.58 109.17,95.93 109,96.1 JMXM1.98
PEG_CTX_GRX_P14: length 3.3
  TOP w0.109: CC68.1 111.99,94.92 111.99,95.05 111.8,95.24 111.24,95.24 110.65,95.82 110.65,96.02 110.5,96.17 JMXM1.92
PEG_CTX_GRX_P15: length 3.3
  TOP w0.109: JMXM1.86 112,96.23 113.13,95.1 113.59,95.1 113.72,94.96 113.72,94.88 CC67.1
PEQ: length 4.1
  TOP w0.102: U9.8 v1(22.06,161.5)
  BOTTOM w0.102: R69.2 22.56,160.69 R70.2 ; R69.2 22.64,160.92 v1(22.06,161.5) ; R69.2 v2(23.87,160.77)
PHASE1: length 24.4
  IN3 w1.016: 45.37,51.98 45.37,48.12 50.15,43.34 50.15,36.02 53.37,32.79 53.37,30.9
  vias: v2(43.54,53.07) v3(44.23,53.25) v3(44.23,52.49) v3(53.13,29.88) v3(53.13,29.25)
PHASE2: length 15
  TOP w0.102: v3(44.58,38.39) v2(43.65,38.39)
  TOP w0.762: PQ502.3 v3(44.58,39.15)
  IN4 w0.762: 49.01,29.35 48.78,29.58 48.78,36.89 47.28,38.39 v3(44.58,38.39) v3(44.58,39.15)
  vias: v3(49.6,28.74) v3(50.16,28.18)
PHASE3: length 6.1
  TOP w0.635: v3(42.2,69.35) 42.48,69.63 PQ500.3
  IN4 w0.762: 39.4,70.27 40.32,69.35 v3(42.2,69.35)
  BOTTOM w0.102: v2(36.89,70.58) 38.07,71.77 PC501.2
  vias: v3(38.9,71.54) v3(38.9,70.9)
PM_APWROK: length 128.2
  TOP w0.102: v1(14.64,130.57) 14.56,130.57 RH87.1 13.88,129.69 v2(12.9,128.71) 12.81,128.62 11.65,128.62 11.21,129.07 UH2.2
  IN2 w0.127: v1(109.91,156.17) 109.23,156.86 109.23,159.15 107.55,160.83 104.73,160.83 104.34,161.22 98.64,161.22 98.03,160.61 97.31,160.61 96.57,159.88 96.57,159.75 91.8,154.98 88.56,154.98 87.95,155.59 82.08,155.59 81.09,154.6 78.42,154.6 77.2,155.81 69.04,155.81 61.87,148.64 60.22,148.64 57.02,145.44 55,145.44 49.74,140.18 49.13,140.18 44.5,135.54 v1(44.5,130.66)
  IN3 w0.127: v1(14.64,130.57) 15.76,129.45 15.76,127.15 18.56,124.34 20.8,124.34 27.2,130.74 44.41,130.74 v1(44.5,130.66)
  BOTTOM w0.102: v1(109.91,156.17) 109.81,156.27 U51.A9
PM_APWROK_R: length 109.8
  TOP w0.102: v1(33.2,92.61) 33.49,92.31 UH1.AB7 ; RH87.2 13.88,131.53 13.19,132.22 12.25,132.22 11.86,131.83 UH2.4 11.5,131.32 10.8,132.01 10.37,132.01 10.07,131.71 v1(10.07,130.67)
  IN1 w0.109: v1(33.77,78.01) 33.77,78.03 32.36,79.43 29.37,79.43 28.88,79.93 24.53,79.93 24.29,80.17 21.56,80.17 15.92,85.81 6.34,85.81 5.54,85.01 3.98,85.01 3.39,85.6 3.39,89.96 3.97,90.54 3.97,91.37 6.1,93.51 6.1,97.27 8.67,99.83 8.67,111.03 9.23,111.59 9.23,113.13 13.1,117 13.1,122 9.33,125.77 9.33,127.65 10.66,128.97 10.66,130.08 v1(10.07,130.67)
  BOTTOM w0.102: v1(33.2,92.61) 33.2,92.6 33.54,92.26 33.54,91.73 33,91.2 33,88.57 v4(34.42,87.16) 35.39,86.19 35.39,79.64 v1(33.77,78.01)
PM_DRAM_PWRGD: length 9.3
  TOP w0.102: 27.85,90.69 27.85,90.22 27.54,89.91 27.54,89.75 27.31,89.52 27.31,88.68 26.91,88.28 24.78,88.28 24.05,87.55 24.05,86.81 23.81,86.57 23.21,86.57 22.82,86.18 T104.1
PM_DRAM_PWRGD_A: length 3.5
  BOTTOM w0.102: v2(114,82) 113.76,82.24 112.7,82.24 RC18.2 112.18,82.66 UC2.2
PM_DRAM_PWRGD_CPU: length 36.5
  TOP w0.102: JCPU1.AC10 v1(98.12,62.75)
  IN4 w0.109: v1(115.27,78.67) 115.27,71.03 107.45,63.21 98.58,63.21 v1(98.12,62.75)
  BOTTOM w0.102: RC14.1 RC16.2 113.04,77.4 113.04,78.34 112.83,78.56 UC2.4 112.83,80.01 112.98,80.16 v4(114.16,80.16) 115.27,79.04 v1(115.27,78.67)
PM_LANPHY_ENABLE: length 181.5
  TOP w0.102: UH1.K13 27.95,94.47 v1(27.95,94.35)
  IN2 w0.127: v1(124.24,159.9) 118.47,165.67 116.11,165.67 113.52,168.26 107.2,168.26 106.99,168.06 105.88,168.06 105.65,168.29 103.5,168.29 102.86,167.65 101.51,167.65 101.05,167.19 101.05,166.71 100.52,166.18 99.68,166.18 98.54,165.04 96.31,165.04 93.82,162.55 87.82,162.55 86.7,163.66 82.05,163.66 81.32,164.39 78.78,164.39 78.05,165.11 74.8,165.11 74.51,164.81 74.51,163.44 70.54,159.48 69.24,159.48 65.82,156.06 58.43,156.06 52.66,150.29 51.04,150.29 50.8,150.05 50.8,143.92 49.23,142.35 48.81,142.35 47.02,140.57 47.02,139.87 46.7,139.55 44.2,139.55 43.45,138.8 42.69,138.8 41.9,138 41.9,136.4 36.04,130.54 29.42,130.54 26.86,127.98 26.86,124.3 25.83,123.27 25.83,119.17 23.17,116.51 22.78,116.51 21.03,114.76 21.03,114.47 20.44,113.87 20.44,111.53 17.72,108.82 17.72,106.61 17.59,106.47 17.59,102.48 19.08,100.98 19.08,97.15 19.52,96.71 19.52,95.45 19.85,95.12 19.85,94.93 20.86,93.91 22.56,93.91 22.59,93.94 24.93,93.94 25.78,94.79 27.53,94.79 27.95,94.37 v1(27.95,94.35)
  BOTTOM w0.102: v1(27.95,94.35) 27.38,94.92 26.65,94.92 26.35,95.21 24.62,95.21 24.04,95.79 RH217.1 ; R555.1 122.46,158.79 v2(123.58,159.9) v1(124.24,159.9)
POWER_SW#: length 16.2
  TOP w0.102: v4(163.89,141.02) 164.09,140.82 164.09,140.4 164.36,140.13 U10.4 164.92,139.66 v1(164.82,139.56) ; U29.20 168.82,130.13 v1(168.44,129.75)
  BOTTOM w0.102: v1(168.44,129.75) 168.32,129.63 167.09,129.63 165.95,130.77 165.12,130.77 164.82,131.07 v1(164.82,139.56)
POWER_SW#_MB: length 382.6
  TOP w0.102: JPB1.1 252.8,103.3 252.89,103.21 252.89,100.92 251.84,99.87 242.03,99.87 236.94,94.78 230.6,94.78 229.46,93.64 225.41,93.64 225.24,93.47 208.81,93.47 v1(206.89,95.39) ; JAPS1.11 87.48,27.45 87.66,27.26 89.23,27.26 91.74,29.78 v1(91.74,31.54) ; R811.2 109.86,164.55 112.33,164.55 PWRSW1.1 v1(113.29,164.78)
  IN1 w0.109: v1(99.02,163.31) 99.69,163.98 100.71,163.98 103.01,166.28 105.65,166.28 106.26,165.66 111.03,165.66 111.92,164.78 v1(113.29,164.78) ; v1(91.74,31.54) 91.47,31.81 91.47,33.18 92.62,34.33 92.62,44.97 92.11,45.48 91.55,45.48 86.5,50.53 86.5,68.74 87.54,69.78 87.54,79.44 91.22,83.12 91.22,88.81 93.94,91.52 93.94,93.19 94.58,93.83 94.58,104.54 95.67,105.63 95.67,106.95 97.32,108.6 97.32,109.99 97.05,110.26 97.05,112.08 97.87,112.9 97.87,115 98.61,115.73 v1(98.61,116.55)
  IN2 w0.127: v1(98.61,116.55) 98.19,116.13 96.56,116.13 94.76,117.92 94.76,123.75 94.23,124.28 94.23,126.44 94.09,126.58 94.09,131.66 94.67,132.24 94.67,134.08 100.26,139.67 100.26,146.64 101.38,147.76 103.12,147.76 106.29,150.94 109.58,150.94 111.5,152.86 111.5,159.9 110.04,161.36 107.73,161.36 107.22,161.87 100.45,161.87 v1(99.02,163.31)
  IN3 w0.127: v1(113.29,164.78) 113.39,164.88 123.65,164.88 125.82,162.71 128.71,162.71 129.04,162.38 136.15,162.38 140.65,157.88 143.55,157.88 150.13,151.31 151.16,151.31 154.12,148.35 154.12,146.8 155.93,144.99 155.93,143.52 156.05,143.39 156.05,142.34 158.81,139.58 158.81,133.18 161.41,130.58 164.52,130.58 167.28,127.82 167.28,125.08 174.63,117.72 174.63,109.06 181.24,102.46 181.24,101.67 181.83,101.08 197.45,101.08 203.14,95.39 v1(206.89,95.39)
  BOTTOM w0.102: v1(91.74,31.54) v4(91.74,32.1)
POWER_SW_IN#: length 78.4
  TOP w0.102: v1(153.97,139.19) 154.31,139.53 160.82,139.53 v2(161.13,139.84) 162.68,141.4 164.42,141.4 165.62,140.21 165.62,139.84 165.97,139.48 U10.2 ; v1(107.17,160.41) 107.2,160.41 107.63,160.84 107.63,162.37 108.67,163.41 C1352.1 R811.1 109.84,163.61 R810.2
  IN3 w0.127: v1(153.97,139.19) 153.97,139.41 150.01,143.37 150.01,144.86 138.77,156.11 126.39,156.11 124.04,158.46 114.33,158.46 113.69,159.1 112.44,159.1 111.82,159.73 109.46,159.73 108.66,160.53 107.29,160.53 v1(107.17,160.41)
  BOTTOM w0.102: v1(107.17,160.41) 107.25,160.49 U51.B67
PROCHOT_GATE: length 47.7
  IN3 w0.127: v1(237.96,63.05) 235.39,63.05 233.71,64.73 230.21,64.73 225.89,69.05 225.89,76.62 228.33,79.06 228.33,83.65 226.22,85.76 v1(224.65,85.76)
  BOTTOM w0.102: U46.A50 224.02,84.52 224.54,85.05 224.54,85.66 v1(224.65,85.76) 224.85,85.96 226.63,85.96 227.52,85.08 227.52,82.59 227.24,82.31 226.04,82.31 225.69,82.66 225.69,82.97 225.43,83.23 RP1.6 ; v1(237.96,63.05) 238.01,63.11 PU704.2 239.77,63.11 v2(239.86,63.02)
PS2_CLK_TS: length 200.5
  TOP w0.102: JKB1.3 JKB1.4 v1(175.55,110.5) ; JIO1.118 v1(14.36,76.2)
  IN2 w0.127: v1(14.36,76.2) 14.05,75.9 14.05,75.42 14.33,75.14 14.72,75.14 16.14,76.57 19.45,76.57 20.09,77.2 29.25,77.2 29.62,76.83 36.11,76.83 36.51,77.23 44.65,77.23 44.83,77.05 46.48,77.05 47.24,76.29 50.56,76.29 52.23,77.96 53.01,77.96 53.65,78.6 57.35,78.6 58.74,79.98 69.92,79.98 71.79,81.85 83.75,81.85 89.26,87.36 96.17,87.36 99.15,90.35 116.34,90.35 117.75,91.76 131.36,91.76 135.66,96.05 144.46,96.05 145.38,95.13 158.68,95.13 161.65,92.16 172.63,92.16 173.11,91.68 v1(173.11,91.68)
  BOTTOM w0.102: v1(175.55,110.5) 175.97,110.08 175.97,109.12 169.49,102.64 v2(169.49,102.27) 169.49,96.85 172.7,93.64 172.7,92.09 173.11,91.68 v1(173.11,91.68)
PS2_DAT_TS: length 199.5
  TOP w0.102: JKB1.5 JKB1.6 175.5,111.5 v1(175.42,111.42) ; v1(14.97,76.21) 14.38,76.8 JIO1.116
  IN2 w0.127: v1(14.97,76.21) 15.58,76.82 19.35,76.82 19.98,77.46 29.35,77.46 29.72,77.09 35.92,77.09 36.31,77.48 44.76,77.48 44.94,77.3 46.58,77.3 47.35,76.54 50.45,76.54 52.12,78.21 52.91,78.21 53.55,78.85 57.25,78.85 58.64,80.25 69.07,80.25 71.26,82.43 83.6,82.43 88.78,87.62 96.06,87.62 99.07,90.63 116.26,90.63 117.64,92.01 131.26,92.01 135.55,96.3 144.57,96.3 145.48,95.39 158.78,95.39 161.73,92.44 172.98,92.44 v1(173.16,92.26)
  BOTTOM w0.102: v1(173.16,92.26) 173.16,93.5 169.82,96.84 v2(169.82,99.86) 169.82,102.65 176.21,109.03 176.21,110.75 175.55,111.42 v1(175.42,111.42)
PS_ID: length 240.3
  TOP w0.102: v2(104.45,163.89) 103.82,163.26 v1(103.72,163.26) ; PU1.4 3.81,83.88 v1(3.48,83.54)
  IN1 w0.109: v1(103.72,163.26) 104.89,162.09 107.33,162.09 108.07,162.82 110.86,162.82 111.88,161.81 114.67,161.81 115.99,160.49 115.99,156.8 118.91,153.88 118.91,149.9 117.76,148.75 117.76,144.78 115.22,142.23 115.22,139.78 118.7,136.29 118.7,133.21 124.16,127.75 124.16,123.35 123.21,122.4 123.21,112.15 125.3,110.06 125.3,101.49 127.64,99.15 128.43,99.15 130.26,97.32 135.37,97.32 v1(135.47,97.22)
  IN2 w0.127: v1(135.47,97.22) 135.39,97.14 135.39,96.78 130.87,92.26 117.54,92.26 116.15,90.88 98.97,90.88 95.96,87.87 88.68,87.87 83.49,82.69 70.29,82.69 68.1,80.5 58.54,80.5 57.14,79.11 53.44,79.11 52.8,78.46 50.77,78.46 49.28,76.97 48.38,76.97 47.8,77.56 45.04,77.56 44.87,77.73 36.21,77.73 35.81,77.34 29.83,77.34 29.46,77.71 19.88,77.71 19.24,77.07 12.88,77.07 6.4,83.55 3.49,83.55 v1(3.48,83.54)
  BOTTOM w0.102: U51.A55 103,162.54 v1(103.72,163.26)
PSATA_PRX_DTX_N0: length 6.9
  TOP w0.102: C385.1 167.38,54.11 167.38,54.54 167.56,54.72 167.83,54.72 167.84,54.71 168.37,54.71 168.38,54.72 168.61,54.72 168.91,54.43 v3(168.91,53.4) 168.91,53.08 169.25,52.74 169.77,52.74 170.33,52.18 JSATA1.5
PSATA_PRX_DTX_N0_C: length 169.8
  TOP w0.102: v1(44.89,90.48) 45.08,90.67 45.08,91.36 43.95,92.49 43.33,92.49 42.92,92.9 42.45,92.9 UH1.BC8 ; v1(167.56,52.12) 167.48,52.2 167.48,52.61 C385.2
  IN4 w0.117: v1(167.56,52.12) 167.48,52.2 167.48,54.47 166.82,55.13 166.82,70.17 167.25,70.61 167.25,73.21 166.82,73.65 166.82,86.01 158.55,94.28 130.07,94.28 129.29,95.06 117.72,95.06 116.13,96.64 107.37,96.64 106.51,97.5 82.23,97.5 82.03,97.7 70.41,97.7 69.15,96.44 65.7,96.44 65.03,95.77 57.69,95.77 55.57,93.64 52.77,93.64 51.22,92.09 47.81,92.09 47.08,91.36 45.36,91.36 45.05,91.05 45.05,90.64 v1(44.89,90.48)
PSATA_PRX_DTX_P0: length 7.2
  TOP w0.102: JSATA1.6 170.3,53.45 169.81,52.96 169.34,52.96 169.13,53.16 169.13,53.67 169.12,53.68 169.12,54.52 168.7,54.94 v3(168.11,54.94) 167.47,54.94 167.17,54.63 167.17,54.09 C386.1
PSATA_PRX_DTX_P0_C: length 169.5
  TOP w0.102: v1(45.53,90.48) 45.4,90.48 45.3,90.59 45.3,91.45 44.79,91.96 44.79,91.96 44.04,92.71 43.66,92.71 43.61,92.76 43.61,93.03 43.54,93.09 43.34,93.09 UH1.BE8 ; v1(166.98,52.12) 167.27,52.41 167.27,53 167.22,53.05 167.03,53.05 C386.2
  IN4 w0.117: v1(45.53,90.48) 45.43,90.48 45.28,90.63 45.28,90.95 45.45,91.12 47.18,91.12 47.91,91.85 51.31,91.85 52.87,93.41 55.66,93.41 57.79,95.53 65.13,95.53 65.8,96.2 69.25,96.2 70.51,97.46 81.93,97.46 82.13,97.26 106.42,97.26 107.27,96.4 116.04,96.4 117.62,94.82 129.2,94.82 129.98,94.04 158.45,94.04 166.58,85.91 166.58,73.55 167.02,73.12 167.02,70.71 166.58,70.27 166.58,55.04 167.25,54.37 167.25,52.39 v1(166.98,52.12)
PSATA_PTX_DRX_N0: length 5.4
  TOP w0.102: JSATA1.3 169.98,49.64 169.48,49.13 168.94,49.13 168.86,49.22 v3(168.86,50.11) 168.86,50.39 168.45,50.8 168.17,50.8 C384.1
PSATA_PTX_DRX_N0_C: length 180
  TOP w0.102: v1(166.54,48.89) 166.14,49.29 166.14,49.45 166.05,49.54 166.05,50.51 166.45,50.91 166.66,50.91 C384.2 ; UH1.AW8 40.72,92.26 v1(40.64,92.18)
  IN4 w0.117: v1(40.64,92.18) 40.7,92.24 40.7,92.62 41.08,93.01 41.36,93.01 42.58,94.23 48.01,94.23 48.65,93.58 50.61,93.58 51.74,94.72 51.74,95.36 52.13,95.75 52.68,95.75 53.3,95.13 55.81,95.13 57.31,96.63 64.62,96.63 65.29,97.3 68.54,97.3 70.14,98.9 73.9,98.9 73.97,98.97 106.87,98.97 108.34,97.5 116.92,97.5 118.45,95.97 130.89,95.97 131.73,95.14 159.61,95.14 167.68,87.07 167.68,79 168.37,78.32 168.37,55.1 168.49,54.98 168.49,49.98 167.4,48.89 v1(166.54,48.89)
PSATA_PTX_DRX_P0: length 5.4
  TOP w0.102: JSATA1.2 169.99,48.37 169.46,48.89 v3(169.22,48.89) 168.88,48.89 168.64,49.13 168.64,49.83 168.63,49.85 168.63,50.31 168.36,50.58 168.13,50.58 C383.1
PSATA_PTX_DRX_P0_C: length 179.8
  TOP w0.102: v1(41.23,92.19) 41.17,92.19 40.94,92.42 40.94,92.56 41,92.62 41.52,92.62 41.61,92.71 41.61,92.83 41.64,92.86 41.64,92.95 41.56,93.03 41.42,93.03 UH1.AY8 ; v1(166.54,49.51) 166.38,49.51 166.26,49.63 166.26,50.42 166.54,50.7 167.03,50.7 167.09,50.63 167.09,50.46 C383.2
  IN4 w0.117: v1(41.23,92.19) 41.18,92.19 40.94,92.43 40.94,92.53 41.18,92.77 41.46,92.77 42.68,93.99 47.91,93.99 48.56,93.35 50.7,93.35 51.98,94.62 51.98,95.26 52.23,95.51 52.58,95.51 53.2,94.9 55.91,94.9 57.41,96.4 64.72,96.4 65.39,97.06 68.64,97.06 70.24,98.66 74,98.66 74.06,98.73 106.77,98.73 108.24,97.27 116.82,97.27 118.35,95.74 130.8,95.74 131.63,94.91 159.52,94.91 167.45,86.98 167.45,78.9 168.13,78.22 168.13,55.01 168.26,54.88 168.26,50.08 167.3,49.12 166.93,49.12 v1(166.54,49.51)
PSID_DISABLE#: length 235.2
  TOP w0.102: PR13.2 v1(4.89,80.4)
  IN2 w0.127: v1(4.89,80.4) 8.72,80.4 14.23,74.89 14.82,74.89 16.24,76.31 19.56,76.31 20.19,76.95 29.14,76.95 29.51,76.58 36.22,76.58 36.61,76.97 44.55,76.97 44.73,76.79 46.37,76.79 47.14,76.03 50.66,76.03 52.33,77.7 53.12,77.7 53.76,78.34 57.46,78.34 58.84,79.73 70.68,79.73 72.55,81.6 83.85,81.6 89.37,87.11 96.27,87.11 99.26,90.09 116.44,90.09 117.85,91.5 131.56,91.5 135.85,95.79 144.36,95.79 145.27,94.88 158.57,94.88 161.54,91.91 171.71,91.91 172.37,91.25 175.01,91.25 175.7,90.56 177.3,90.56 v1(177.41,90.66)
  BOTTOM w0.102: U46.A37 216.17,87.05 215.83,87.39 215.83,89.22 214.23,90.82 v2(213.05,90.82) 209.15,90.82 204.61,95.36 193.4,95.36 191.78,96.99 182.63,96.99 182.04,96.39 181.56,96.39 177.41,92.24 v1(177.41,90.66)
PWM3: length 85.5
  TOP w0.203: PR523.2 51.9,31.33 51.9,30.58 51.57,30.25 51.57,29.7 52.05,29.22 52.05,29.04 52.33,28.77 PU500.22
  TOP w0.254: v1(49.51,32.73) 50.87,32.73 51.37,32.23 PR523.2
  IN1 w0.109: v1(49.51,32.73) 47.1,30.31 47.1,24.89 v1(46.66,24.45)
  IN4 w0.109: v1(38.57,79.18) 35.98,76.59 35.98,68.32 38.52,65.78 38.52,56.31 40.89,53.94 40.89,50.99 38.85,48.95 38.85,46.62 38.16,45.94 38.16,43.88 39.28,42.76 39.28,39.13 40.61,37.8 40.61,33.66 41.6,32.67 41.6,29.33 46.48,24.45 v1(46.66,24.45)
  BOTTOM w0.102: v1(38.57,79.18) v2(38.57,77.73) 38.57,76.06 40.47,74.16 PU501.3
PWR_SRC_ON: length 1.2
  BOTTOM w0.102: R422.2 53.01,158.98 v2(52.39,159.59)
PWRSHARE_EN#: length 4.3
  BOTTOM w0.102: U45.5 255.83,98.52 255.63,98.32 255.63,97.81 R816.1 ; R816.1 256.33,97.6 v2(256.41,97.69) ; R816.1 254.42,96.59 Q55.1
QHD_DET#: length 235.4
  TOP w0.102: v1(46.19,150.51) 46.96,151.28 48.47,151.28 48.8,150.95 JEDP1.10
  IN3 w0.127: v1(46.19,150.51) 46.55,150.87 46.76,150.87 50.48,154.59 50.48,155.69 51.13,156.35 55.95,156.35 56.79,157.19 57.92,157.19 59.68,158.95 62.23,158.95 64.48,161.2 76.97,161.2 78.83,163.05 85.69,163.05 86.88,161.86 102.4,161.86 103.21,162.67 103.21,163.43 103.47,163.69 111.12,163.69 112.31,162.51 115.54,162.51 117.15,164.12 123.33,164.12 125.5,161.95 128.39,161.95 128.72,161.62 135.84,161.62 140.33,157.12 143.18,157.12 144.92,155.39 144.92,153.74 148.27,150.38 149.76,150.38 151.62,148.51 151.62,147.5 153.58,145.55 153.58,144.58 155.28,142.88 155.28,142.03 158.05,139.26 158.05,132.86 161.1,129.8 164.21,129.8 166.51,127.5 166.51,124.77 173.83,117.44 173.83,108.77 175.62,106.98 175.62,106.07 181.43,100.26 197.12,100.26 203.16,94.22 208.37,94.22 211.09,91.5 219.19,91.5 v1(220.28,90.41)
  BOTTOM w0.102: v1(220.28,90.41) 220.15,90.28 R19.2 219.67,88.7 U46.A44
RED_CRT: length 17.3
  TOP w0.102: v1(75.09,162.55) 74.49,162.55 73.3,163.74 73.3,164.02 C20.1 R53.1 71.65,165.28 L1.1
  BOTTOM w0.102: U19.33 82.6,163.58 81.96,164.22 76.37,164.22 v2(75.71,163.55) 75.09,162.94 v1(75.09,162.55)
RED_CRT_L: length 7.1
  TOP w0.102: L1.2 v2(72.09,167.4) 72.09,171.66 72.01,171.74 JCRT1.1
RED_DOCK: length 52.5
  TOP w0.102: v1(79.61,156.98) 79.64,156.98 80.25,157.59 83.32,157.59 85.71,155.2 v2(85.71,153.78) 85.71,153.35 86.14,152.92 86.14,142.07 88.18,140.02 88.18,136.99 89.3,135.88 89.64,135.88 90.89,134.62 90.89,132.36 92.85,130.41 92.85,124.37 89.39,120.92 89.39,120.81 87.82,119.24 87.36,119.24 v1(87.05,119.54)
  BOTTOM w0.102: v1(87.05,119.54) 87.2,119.4 JDOCK1.53 ; U19.24 80.21,157.55 79.64,156.98 v1(79.61,156.98)
