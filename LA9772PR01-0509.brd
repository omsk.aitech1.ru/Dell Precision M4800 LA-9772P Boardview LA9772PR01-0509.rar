# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 14.9
  BOTTOM w0.508: R574.2 R572.2 R573.2 R571.2
  BOTTOM w1.016: v1(173.52,151.42) v1(173.52,152.31) 173.52,156.63 172.09,158.05 167.06,158.05
V1N: length 5.3
  TOP w0.102: PR516.1 58.62,33.2 v2(58.62,33.13)
  TOP w0.254: PR516.1 57.13,33.56 54.82,33.56 PR546.2
V2N: length 1.1
  TOP w0.254: PR518.1 PR556.2
V3N: length 3.2
  BOTTOM w0.102: v2(57.43,33.92) 57.22,34.12 PR557.2
  BOTTOM w0.254: PR547.2 PR557.2
VCC_PGOOD: length 4.8
  TOP w0.102: PR522.2 49.49,20.94 v2(50.35,21.8) 50.35,22.15 51.23,23.02 51.85,23.02 52.33,23.5 PU500.3
VCCSENSE: length 89.9
  TOP w0.254: JCPU1.AL35 72.21,69.9 71.52,69.9 66.56,74.85 64.28,74.85 v2(63.56,74.13) 62.91,74.13 62.45,74.59 RC66.2 61.96,73.59 61.38,73.01 58.15,73.01 v1(58,73.16) ; PR536.1 63.28,22.69 PC520.1 64.02,22.64 v1(64.22,22.85) ; v1(58.96,25.55) 57.91,24.5 PC542.2 PC544.1
  IN2 w0.254: v1(58,73.16) 58.15,73.01 60.42,73.01 61.25,72.18 61.25,71.38 60.66,70.79 60.66,70.34 61.25,69.76 61.25,68.9 60.66,68.31 60.66,67.63 61.25,67.04 61.25,66.03 60.51,65.29 60.51,64.68 61.25,63.94 61.25,62.59 60.54,61.88 60.54,61.38 61.25,60.67 61.25,59.47 60.56,58.78 60.56,57.9 61.25,57.21 61.25,56.53 60.54,55.81 60.54,55.15 61.27,54.42 61.27,45.57 66.23,40.61 66.23,23.99 65.19,22.95 64.32,22.95 v1(64.22,22.85) 64.12,22.95 62.95,22.95 60.23,25.66 59.07,25.66 v1(58.96,25.55)
VDD_1.35V: length 6.7
  BOTTOM w0.102: PR201.1 183.12,80.17 v2(183.42,80.48)
  BOTTOM w0.203: PR201.1 182.6,79.68 PC210.1 182.57,78.99 PR203.2 180.62,78.99 180.02,78.4 180.02,78.09 179.83,77.9 PU200.11
VDD_PWRGD: length 4.6
  TOP w0.102: R402.2 164.17,132.73 162.68,132.73 v2(162.42,132.99)
  TOP w0.254: U29.13 164.95,133.01 R402.2
VIN: length 2.5
  TOP w0.102: T137.1 106.74,153.63 107.13,153.63 v1(107.52,153.24)
  BOTTOM w0.102: v1(107.52,153.24) 107.82,153.24 108.1,153.52 U51.B15
VSSSENSE: length 91.5
  TOP w0.203: 55.76,26.4 PU500.13
  TOP w0.254: JCPU1.AK35 72.35,69.52 71.36,69.52 66.41,74.47 64.58,74.47 v2(63.04,72.93) 62.73,72.63 58.09,72.63 v1(57.99,72.53) ; v1(57.44,27.21) 58,27.21 RC70.1 58.05,27.14 PC544.2 56.64,26.27 56.33,26.58 55.94,26.58 55.76,26.4
  IN2 w0.254: v1(57.99,72.53) 58.09,72.63 60.26,72.63 60.87,72.02 60.87,71.54 60.28,70.95 60.28,70.19 60.87,69.6 60.87,69.05 60.28,68.47 60.28,67.47 60.87,66.88 60.87,66.18 60.13,65.45 60.13,64.52 60.87,63.78 60.87,62.75 60.16,62.04 60.16,61.22 60.87,60.51 60.87,59.62 60.18,58.94 60.18,57.74 60.87,57.05 60.87,56.68 60.16,55.97 60.16,55 60.89,54.26 60.89,45.41 65.85,40.45 65.85,24.15 65.03,23.33 63.11,23.33 60.39,26.04 58.61,26.04 v1(57.44,27.21)
  BOTTOM w0.254: v1(57.44,27.21) 56.57,27.21 55.3,25.94 PC546.2
3301_ACAV_IN_NB: length 2.8
  BOTTOM w0.254: PR1019.1 152.82,124.86 v2(152.58,124.63) 152.58,124.59 152.2,124.22 PU1001.24
3301_DC_IN_SS: length 2.5
  BOTTOM w0.254: PU1001.34 155.23,119.28 v2(155.87,118.65) 155.99,118.53 PR1010.2
3301_PWRSRC: length 2.6
  BOTTOM w0.254: PR1029.1 146.97,120.24 147.49,120.76 v2(147.49,120.76) 147.52,120.78 PU1001.15
24737_BST_CHG_MODE#: length 75
  IN3 w0.127: v1(205.09,66.66) 205.14,66.61 205.14,58.84 201.79,55.48 192.01,55.48 190.92,54.39 186.47,54.39 185.76,53.68 180.37,53.68 178.7,55.36 175.45,55.36 v1(174.23,56.58)
  BOTTOM w0.254: PU700.11 177.23,50.68 176.06,51.85 176.06,52.49 174.53,54.01 PR757.2 v1(174.23,56.58) v2(173.7,57.1) 173.24,57.57 169.96,57.57 169.05,56.65 169.05,55.51 169.41,55.14 169.41,53.29 169.58,53.12 PQ710.2 ; PR718.1 213.62,57.26 212.99,56.63 211.87,56.63 205.09,63.41 v1(205.09,66.66)
+ADDR_XEN: length 2.6
  TOP w0.254: U29.32 171.96,135.01 172.37,135.42
  TOP w0.508: R394.1 v2(172.78,135.6) 172.55,135.6 172.37,135.42
+BL_PWR_SRC:
  vias: v2(52,155) v3(51.43,154.75) v3(51.55,155.38)
+CAMERA_VDD:
  vias: v1(56.28,152.64) v1(56.92,152.64) v2(52.19,151.67)
+CAP_LDO: length 3.6
  BOTTOM w0.102: v1(216.52,90.33) 216.52,89.66 v2(216.66,89.52)
  BOTTOM w0.318: v1(218.8,84.57) 219.17,84.57 219.42,84.83 U46.B46
  BOTTOM w0.508: C714.1 215.95,90.9 v1(216.52,90.33)
+CHAGER_SRC: length 1.2
  BOTTOM w0.102: PC705.1 v2(183.93,44.77)
+CHG_VCC: length 4
  BOTTOM w0.102: PD701.1 175.55,39.88 v2(176.03,39.39)
  BOTTOM w0.635: PR775.2 175.61,41.31 174.92,40.62 PD701.1
+COINCELL: length 2.8
  BOTTOM w0.102: v2(40.7,154.61) 41.23,155.14 PR1.1
  BOTTOM w0.508: JRTC1.1 39.78,155.74 PR1.1
+CRT_VCC: length 8.6
  TOP w1.016: U6.3 79.97,165.08 C14.1 v2(78.91,167.33) 78.15,168.1 78.15,171.65 77.35,172.45 JCRT1.9
+DC1_PWR_SRC: length 11.5
  IN1 w0.508: v3(244.51,46.52) 244.51,46.82 246.67,48.98 246.67,54.27 247.33,54.93 v3(247.33,56.88)
  vias: v4(251.98,43.95)
+DC_IN: length 445.3
  TOP w0.508: v1(170.18,109.85) 170.18,109.79 181.87,98.09 190.9,98.09 192.2,96.8 194.69,96.8 197.52,93.97 197.52,93.23 199.63,91.12 199.63,90.76 202.43,87.96 202.43,83.49 206.03,79.89 206.03,77.23 208.21,75.04 208.21,73.26 211.82,69.66 215.31,69.66 216.94,68.02 216.94,67.52 218.13,66.33 219.99,66.33 224.75,61.57 225.87,61.57 228.63,58.8 v3(228.63,55.74) ; PQ8.3 17.12,66.49 16.73,66.1 v1(16.62,66.1)
  IN2 w0.508: v3(228.63,55.74) 229.42,54.95 229.42,42.33 217.56,30.47 195.84,30.47 194.8,31.51 189.87,31.51 187.64,29.27 185.67,29.27 185.31,29.63 184.54,29.63 183.27,28.36 173.2,28.36 168.93,24.09 151.14,24.09 148.13,21.08 136.43,21.08 132.55,24.97 126.89,24.97 126.22,25.64 v3(126.22,25.92) ; v1(16.62,66.1) 16.84,66.1 18.41,67.68 27.72,67.68 28.99,68.95 36.22,68.95 39.35,65.81 39.35,56.65 41.59,54.42 41.59,50.63 39.1,48.15 39.1,35.14 41.54,32.7 41.54,28.84 44.94,25.43 44.94,9.92 50.91,3.95 59.98,3.95 62.47,6.44 68.08,6.44 69.2,7.55 73.11,7.55 75.04,9.48 75.04,11.85 76.2,13 76.2,16.77 75.57,17.39 75.57,19.82 76.36,20.61 77.63,20.61 83.16,26.13 85.01,26.13 85.33,26.45 88.42,26.45 89.49,27.52 90.03,27.52 90.51,27.04 v1(90.51,26.81)
  IN3 w0.508: v1(16.25,74.62) 16.8,74.08 16.8,66.33 16.62,66.15 v1(16.62,66.1)
  BOTTOM w0.508: PR1011.1 156.99,113.12 157.34,112.77 157.34,111.9 v4(159.24,109.99) 160.71,108.52 168.84,108.52 v1(170.18,109.85) ; PL4.2 16.8,75.17 v1(16.25,74.62) ; PR736.1 v3(228.63,55.74) ; v3(126.22,25.92) 124.67,25.92 v4(120.8,29.79) 119.38,31.21 106.12,31.21 100.24,37.09 95.89,37.09 92.69,33.89 92.69,28.99 v4(91.85,28.15) 91.11,28.15 90.51,27.56 v1(90.51,26.81)
+DC_IN_SS: length 383
  IN1 w0.508: v3(23.43,72.22) 26.78,72.22 29.02,74.46 29.68,74.46 30.26,75.04 v1(30.26,75.27) ; v1(155.61,117.08) 155.61,115.36 157.2,113.78 157.2,111.14 158.19,110.15 158.19,107.63 160.45,105.37 161.53,105.37 172.41,94.49 174.49,94.49 178.37,90.61 178.37,90.1 v1(178.32,90.05)
  IN2 w0.508: v1(173.91,40.56) 173.2,40.56 171.03,42.73 171.03,46.92 170.77,47.18 170.77,52.07 167.65,55.19 167.65,58.25 168.31,58.91 168.31,72.07 166.18,74.2 166.18,82.31 168,84.14 170.7,84.14 172.53,85.96 173.54,85.96 176.61,89.04 177.3,89.04 v1(178.32,90.05) ; v1(144.2,111.39) 144.99,112.18 146.85,112.18 147.13,111.9 151.04,111.9 151.6,111.34 153.74,111.34 154.28,111.87 154.28,112.65 155.61,113.98 v1(155.61,117.08)
  IN3 w0.508: v3(93.24,27.54) 93.24,26.92 92.52,26.2 84.3,26.2 76.54,18.44 76.54,14.54 75.07,13.07 75.07,10.35 69.43,4.71 50.58,4.71 44.97,10.32 44.97,25.41 41.64,28.74 41.64,32.57 39.1,35.11 39.1,48.07 41.31,50.28 41.31,54.72 39.2,56.83 39.2,66.07 33.12,72.16 31.97,72.16 30.26,73.87 v1(30.26,75.27)
  IN4 w0.508: v3(93.24,27.54) 93.24,28.31 94.19,29.26 94.19,32.83 96.64,35.28 107.32,35.28 114.56,42.51 114.56,67.25 120.08,72.77 120.08,86.32 v3(123.96,90.21)
  BOTTOM w0.508: v1(155.61,117.08) 155.61,117.31 156.17,117.87 157.31,117.87 157.72,118.27 PR1010.1 ; v3(123.96,90.21) 123.96,92.4 127.63,96.07 137.09,96.07 142.81,101.79 142.81,104.66 144.2,106.06 v4(144.2,107.78) v1(144.2,111.39) ; v1(173.91,40.56) 173.87,40.53 PD701.3
+DCIN_JACK:
  vias: v4(17.65,86.22) v4(18.77,87.6) v4(20.28,82.64)
+DOCK_PWR_BAR: length 78.2
  IN1 w0.635: v3(228.76,40.17) 216.57,27.98 200.1,27.98 199.14,27.02 198.19,27.02 193.63,31.58 185.5,31.58 182.23,28.31 174.84,28.31 172.86,30.29 172.86,31.86 173.92,32.93 v3(173.92,39.26)
  BOTTOM w0.102: PR1001.1 229.73,39.48 v4(230.01,39.2)
  BOTTOM w0.508: PR1007.1 157.87,119.54 158.45,118.96 v1(158.45,118.81) ; v3(173.92,39.26) 173.11,39.26 PD701.2
  vias: v3(228,48.68) v3(228,48.04) v3(228,47.41) v3(228,46.77) v3(228,46.14) v3(228,43.72) v3(228.63,48.68) v3(228.63,48.04) v3(228.63,47.41) v3(228.63,46.77) v3(228.63,46.14) v3(228.63,45.5) v3(228.63,44.87) v3(228.63,44.23) v3(228.63,43.6)
+DP_VCC:
  vias: v2(262.82,148.38)
+LCDVDD: length 30.4
  TOP w0.381: Q6.2 v1(56.28,146.82)
  TOP w0.432: Q6.5 56.28,144 v1(55.95,143.67)
  IN1 w0.508: v1(56.28,146.82) 56.25,146.8 56.25,143.98 v1(55.95,143.67) 54.81,143.67 53.25,145.24 51.43,145.24 49.31,143.11 v1(49.26,143.11)
  IN2 w0.762: v3(45.04,145.15) 45.04,146.19 46.31,147.46 46.31,149.24 45.35,150.2 45.35,151.46 46.2,152.31 47.28,152.31
  IN3 w0.508: v1(49.26,143.11) 45.49,143.11 45.04,143.56 v3(45.04,145.15)
  BOTTOM w0.102: v4(46.12,153.85) 46.14,153.83 C769.1
  BOTTOM w0.508: R103.1 v1(49.26,143.11)
  vias: v1(47.58,153.02) v1(48.19,153.02)
+LOM_VCT: length 3.4
  TOP w0.102: v1(103.92,125.08) v2(103.92,124.34)
  BOTTOM w0.254: JDOCK1.116 103.7,125.3 v1(103.92,125.08) 104.2,125.36 JDOCK1.118
+MXM_PWR_SRC: length 1.7
  BOTTOM w0.102: v4(133.28,100.26) 133.68,99.87 v1(133.68,98.74)
+NBDOCK_DC_IN_SS: length 206.4
  TOP w0.508: v1(210.9,72.2) 211.82,72.2 213.34,70.67 215.73,70.67 218.09,68.31 218.09,67.8 218.55,67.35 229.95,67.35 230.72,68.11 232.47,68.11 232.75,67.83 v1(232.75,67.57)
  IN1 w0.508: v1(147.1,126.6) 147.18,126.53 147.18,124.22 147.01,124.05 147.01,117.27 147.51,116.77 147.51,114.87 146.95,114.31 146.95,113.35 147.35,112.94 147.35,109.28 154.69,101.94 160.14,101.94 177.18,84.89 178.85,84.89 179.1,84.64 181.73,84.64 184.86,81.51 196.48,81.51 203.21,74.79 206.46,74.79 209.13,72.12 210.83,72.12 v1(210.9,72.2)
  IN2 w0.508: v1(101.23,121.35) 102.88,121.35 108.59,115.63 116.7,115.63 118.78,117.71 128.37,117.71 131.72,114.36 142.43,114.36 146.11,118.04 146.11,123.35 147.18,124.42 147.18,126.53 v1(147.1,126.6)
  BOTTOM w0.102: v2(146.43,126.63) 146.45,126.6 v1(147.1,126.6)
  BOTTOM w0.254: 83.2,119.45 JDOCK1.41
  BOTTOM w0.508: v1(232.75,67.57) 232.75,67.63 233.13,68.01 234.29,68.01 PQ1070.1 ; PR1024.2 v1(147.1,126.6) ; v1(101.23,121.35) 100.14,121.35 99.12,120.33 94.8,120.33 93.43,121.7 87.49,121.7 86.62,120.84 84.48,120.84 83.2,119.56 83.2,119.45
+PCH_DCPRTC: length 1.9
  TOP w0.305: UH1.P16 30.16,96.04 v1(30.48,95.72) 30.16,95.4 UH1.P14
  BOTTOM w0.457: CH54.1 30.51,96.12 30.51,95.75 v1(30.48,95.72)
+PCH_USB_DCPSUS1: length 4
  TOP w0.305: UH1.Y12 32.45,94.7 v1(32.21,94.46)
  BOTTOM w0.381: v1(32.21,94.46) 32.29,94.54 32.29,94.79 33.08,95.58 33.08,95.92 33.47,96.31 CH39.1 33.47,96.66 33.18,96.95 RH234.2
+PCH_USB_DCPSUS2: length 12.3
  TOP w0.254: v1(32.17,104.34) 32.3,104.34 32.55,104.09 UH1.Y35
  BOTTOM w0.254: v1(32.17,104.34) 32.17,104.92 32.67,105.42 32.67,106.7 32.85,106.88 v2(32.85,106.92) 32.85,109.09 32.41,109.54 32.41,111.86 RH239.2 31.2,114.36 CH58.1
+PCH_USB_DCPSUS3: length 15.9
  TOP w0.305: UH1.AJ26 36.1,100.24 v1(35.77,100.57) 36.1,100.9 UH1.AJ28
  IN2 w0.508: v1(35.77,100.57) 35.77,100.58 37.04,101.85 37.04,102.58 37.42,102.96 37.82,102.96 38.73,103.87 ; 38.63,108.01 38.63,110.23 37.75,111.11 35.53,111.11 35.23,111.42 v1(34.39,111.42)
  BOTTOM w0.508: CH42.1 35.92,100.41 v1(35.77,100.57) ; CH41.1 33.94,109.74 34.39,110.18 RH236.1 v1(34.39,111.42)
+PCH_VCC: length 12.3
  TOP w0.102: v2(42.81,114.36) 43.29,113.88 43.29,112.43 CH64.1
  TOP w0.254: UH1.AP45 38.41,109.55 38.57,109.7 38.57,109.95 40.93,112.32 42.22,112.32 42.57,111.97 CH64.1 43.96,111.97 CH63.1 45.32,111.99 LH2.2
+PCH_VCCCFUSE: length 28.5
  TOP w0.254: UH1.P18 30.16,97.01 v1(30.47,97.33) 30.16,97.65 UH1.P20
  IN4 w0.254: v1(20.58,100.52) 20.58,100.49 ; 20.58,100.49 20.68,100.59 21.27,100.59 22.39,99.48 24.55,99.48 26.2,97.83 29.5,97.83 29.99,97.33 v1(30.47,97.33) 30.47,97.13 30.21,96.86 26.12,96.86 25.99,96.99 25.69,96.99 24.35,98.32 22.75,98.32 20.58,100.49
  BOTTOM w0.508: RH242.2 18.14,102.45 CH66.1 18.81,102.45 v2(19.44,101.82) 19.77,101.49 19.77,101.05 20.3,100.52 v1(20.58,100.52)
+PCH_VCCCLK: length 5.6
  TOP w0.254: UH1.AD36 34.3,104.68 34.5,104.48 34.5,104.34 ; UH1.AD34 34.54,103.49 v1(34.74,103.69) ; 34.5,104.34 UH1.AD35 ; 34.5,104.34 v1(34.74,104.34)
  TOP w0.305: UH1.Y32 32.8,102.82 v1(33.15,103.17) ; UH1.AG32 35.11,102.28 v1(35.11,102.21) ; v1(35.11,102.21) 34.78,101.88 UH1.AE30 ; v1(35.11,102.21) 35.11,102.13 UH1.AG30 ; v1(35.11,102.21) 34.78,102.54 UH1.AE32 ; UH1.AA30 33.13,102.13 v1(33.13,102.21) 33.13,102.28 UH1.AA32
  vias: v2(34.08,102.86) v3(33.31,118.78) v3(33.51,117.16) v3(33.54,116.52)
+PCH_VCCCLK3_3: length 4.4
  TOP w0.305: UH1.V32 31.97,102.78 31.64,102.78 UH1.U32 31.15,102.28 v1(31.15,102.21)
  BOTTOM w0.381: CH72.1 28.89,101.33 v1(29.35,100.87) ; v1(29.25,101.9) 29.7,102.35 CH73.1
  BOTTOM w0.508: CH72.1 28.66,101.41 v1(28.66,101.94) ; v1(31.15,102.21) 31.15,102.01 30.82,101.69 CH74.1
  vias: v1(19.39,105.29) v1(19.39,104.71)
+PCH_VCCDSW: length 1.2
  TOP w0.305: UH1.U14 31.81,95.63 v1(31.81,95.71)
  BOTTOM w0.508: RH232.2 31.73,95.63 v1(31.81,95.71)
+PCH_VCCDSW3_3: length 401.4
  TOP w0.254: v1(21.7,95.74) 21.97,96.01 24.11,96.01 24.35,96.25 UH1.A16 ; v1(20.13,83.55) 20.13,81.55 21.29,80.38 23.68,80.38 24.52,81.21 v1(24.52,81.39) 24.34,81.39 23.78,81.95 RH78.1
  TOP w0.305: JAPS1.3 83.48,27.23 85.09,25.63 84.98,25.52 v1(84.98,25.39)
  TOP w0.508: v1(102.14,169.78) 99.53,172.4 92.34,172.4 88.9,168.96 88.9,159.94 90.31,158.53 90.31,154.9 90.97,154.24 90.97,145.42 93.11,143.28 93.11,141.21 94.69,139.63 94.69,139.19 96.66,137.22 96.66,132.47 98.36,130.77 98.36,127.82 99.58,126.6 99.58,124.62 v1(100.54,123.66) ; v1(90.98,31.53) 90.98,33.74 95.45,38.21 106.88,38.21 113.24,44.58 113.24,79.17 111.7,80.71 v1(110.96,80.71) 112.96,82.71 v1(115.65,82.71) 116.37,82 117.1,82 117.48,82.38 117.48,82.94 113.67,86.75 108.9,86.75 104.48,91.17 104.2,91.17 103.72,91.65 v3(103.72,91.83)
  IN1 w0.508: v1(100.54,123.66) 100.54,111.8 101.94,110.4 101.94,108.98 100.03,107.08 100.03,100.65 100.19,100.49 100.19,94.02 99.91,93.74 99.91,92.77 100.92,91.76 103.64,91.76 v3(103.72,91.83) ; v1(20.3,90.21) 20.3,94.68 21.37,95.74 v1(21.7,95.74)
  IN2 w0.508: v1(20.3,90.21) 20.3,91.82 19.12,93 18.15,93 17.66,93.48 17.66,94.54 17.24,94.97 17.24,96.79 16.73,97.29 16.73,100.45 15.45,101.74 15.45,104.53 14.87,105.12 14.87,105.88 15.43,106.44 15.49,106.44 16.26,107.22 16.26,109.43 17.13,110.29 17.13,111.28 17.7,111.85 18.06,111.85 18.95,112.74 18.95,114.46 19.57,115.07 19.57,115.36 22.17,117.97 22.56,117.97 24.19,119.6 24.19,127.38 28.89,132.08 35.14,132.08 38.16,135.1 38.16,136.21 39.07,137.12 39.07,137.25 41,139.18 41,139.46 43.91,142.36 45.57,142.36 47.03,143.83 47.03,145.74 49.31,148.02 49.31,151.22 52.43,154.34 52.43,155.2 53.56,156.32 55.21,156.32 56.83,157.95 61.78,157.95 67.86,164.03 70.76,164.03 73.94,167.21 78.92,167.21 79.64,166.48 82.23,166.48 82.28,166.53 86.11,166.53 86.34,166.3 88.2,166.3 89.76,164.74 93.01,164.74 98.05,169.78 v1(102.14,169.78)
  BOTTOM w0.254: v1(115.65,82.71) RC18.1 ; RH216.2 26.58,82.48 25.97,81.87 24.93,81.87 24.52,81.47 v1(24.52,81.39)
  BOTTOM w0.356: UC2.5 111.53,80.14 v1(110.96,80.71)
  BOTTOM w0.508: RH238.2 20.68,95.74 v1(21.7,95.74) 21.75,95.79 RH217.2 ; v1(102.14,169.78) 100.9,168.54 100.9,166.63 101.43,166.1 101.76,166.1 102.27,165.59 R835.1 ; v1(84.98,25.39) 84.98,25.68 85.81,26.5 87.54,26.5 90.98,29.94 v4(90.98,30.45) v1(90.98,31.53) ; v1(20.13,83.55) 19.41,84.26 19.41,87.83 18.35,88.9 18.35,89.42 18.75,89.83 19.52,89.83 RH80.1 19.85,89.75 v1(20.3,90.21) 20.3,90.64 19.26,91.68 CH44.1 19.08,92.11 19.01,92.19 RH112.1
+PCH_VCCDSW_R: length 1
  BOTTOM w0.508: RH232.1 30.79,95.1 CH40.1
+PCH_VCCSST: length 1.4
  TOP w0.305: v1(33.79,95.71) 33.46,95.37 UH1.AA14
  BOTTOM w0.508: CH46.1 34.12,95.18 33.79,95.52 v1(33.79,95.71)
+PECI_VREF: length 5.1
  BOTTOM w0.305: 98.79,161.1 98.79,160.77 99.04,160.52 U51.B51
  BOTTOM w0.508: R866.1 C740.1 v2(98.33,163.07) 98.33,161.55 98.79,161.1
+PWR_SRC: length 1145.7
  TOP w0.254: v1(28.72,143.93) 28.72,143.29 31.09,140.93 31.09,140.31 29.27,138.49 29.27,136.8 27.87,135.4 27.87,133.33 28.7,132.5 31.34,132.5 31.66,132.18 31.66,130.2 32.14,129.72 v3(32.14,129.25)
  TOP w3.048: 182.76,63.54 182.76,78.85 181.19,80.43 179.51,80.43 178.04,81.9 176.92,81.9 171.17,87.65 166.16,87.65 159.93,93.89
  IN1 w0.508: v3(155.86,99.2) 155.51,98.84 153.83,98.84 143.52,109.15 143.52,118.07 144.05,118.6 144.05,119.82 144.47,120.24 v1(144.88,120.24)
  IN1 w1.27: 148.62,172.4 148.62,164.78 150.53,162.88 150.53,161.45 153.07,158.91 153.07,154.72 155.61,152.18 155.61,148.5 156.37,147.74 175.92,147.74 177.2,146.45 177.2,141.39
  IN2 w1.27: 78.16,10.78 77.81,11.14 77.81,14.91 77.55,15.16 77.55,18.02 80.93,21.4 84.87,21.4
  IN2 w1.778: 79.69,11.14 79.69,15.76 82.74,18.81 82.74,19.26 84.87,21.4
  IN2 w2.54: 34.43,67.13 34.44,67.14 35.66,67.14 37.7,65.1 37.7,55.97 39.94,53.73 39.94,51.32 36.41,47.79 36.41,34.61 39.66,31.35 39.66,28.38 43.29,24.75 43.29,8.82 46.44,5.67 46.44,3.41 47.56,2.3 70.32,2.3 73.9,5.88 76.23,5.88
  IN2 w3.048: 180.25,22.39 175.68,22.39 173.95,20.66 152.32,20.66 148.96,17.3 136.57,17.3 131.86,22.01 113.57,22.01 110.42,25.16 95.09,25.16 94.27,24.33 88.13,24.33 85.2,21.4 84.87,21.4
  IN3 w1.27: 78.16,10.78 77.83,11.11 77.83,12.8 77.55,13.08 77.55,18.02 80.65,21.12 84.62,21.12 81.54,18.04 81.54,17.13 79.94,15.53 79.94,10.88 ; 177.2,141.13 177.2,146.53 175.99,147.74 157.72,147.74 156.28,149.17 156.28,151.51 153.58,154.21 153.58,156.25 153.07,156.75 153.07,159.04 150.53,161.58 150.53,163.36 151.29,164.12 151.29,167.17 147.86,170.6 v3(147.86,173.29)
  IN3 w2.54: 76.23,5.88 73.9,5.88 70.32,2.3 47.56,2.3 46.44,3.41 46.44,5.67 43.32,8.8 43.32,24.72 39.99,28.05 39.99,31.02 36.41,34.61 36.41,47.71 39.66,50.96 39.66,54.04 37.55,56.14 37.55,65.39 35.52,67.42 34.24,67.42 34.21,67.45 ; 84.62,21.12 88.03,24.53 93.9,24.53 94.29,24.93 106.21,24.93 109.38,21.75 131.68,21.75 136.32,17.12 149.12,17.12 153.42,21.42 172.8,21.42 177.71,26.33 177.71,32.04
  IN4 w0.508: v1(28.72,143.93) 28.72,145.82 24.61,149.93 19.85,149.93 16.89,152.89 13,152.89 12.85,153.05
  IN4 w1.27: 15.03,140.23 12.63,142.63 12.63,144.75 10.33,147.05 10.33,149.27 12.85,151.79 12.85,154.16 14.66,155.98 14.66,161.02 17.84,164.2 25.56,164.2 28.1,166.74 49.36,166.74 53.25,162.85 53.25,162.47
  IN4 w2.54: 54.9,161.33 58.58,161.33 61.38,164.12 61.38,165.67 65.24,169.53 94.73,169.53 98.48,173.29 144.92,173.29 144.94,173.26
  BOTTOM w0.254: v3(32.14,129.25) 33.08,128.31 R933.1
  BOTTOM w0.381: 78.29,9.69 78.29,13.37 78.01,13.65 78.01,17.89 81.24,21.12 84.77,21.12
  BOTTOM w0.508: PR1029.2 v1(144.88,120.24) ; PR15.1 26.84,146.77 PC7.1 27.35,146.26 PQ4.3 28.06,144.59 v1(28.72,143.93)
  BOTTOM w1.524: 79.79,10.07 79.79,16.04 84.77,21.02 84.77,21.12
  BOTTOM w2.032: 84.77,21.12 84.77,21.35 88.32,24.9 98.18,24.9 99.13,25.86 99.91,26.02 100.91,26.45 104.91,26.45 106.03,25.33 121.67,25.33 125.26,21.75 131.23,21.75 135.92,17.05 147.86,17.05 152.05,21.25 172.37,21.25 174.02,22.9 178.98,22.9
  BOTTOM w2.54: 76.23,5.88 v4(69.1,5.88) 61.16,5.88 56.59,10.45 53.81,10.45 52.62,11.63 47.33,11.63 44.95,14.01 44.95,25.71 42.15,28.5 41.75,28.5 39.53,30.72 39.53,31.48 36.41,34.61 36.41,47.53 39.4,50.53 39.4,53.69 37.79,55.31 37.79,65.23 35.53,67.49 ; 175.41,136.36 175.4,136.35 175.4,123.38 173.24,121.22 173.24,109.51 169.88,106.16 168.56,106.16 163.4,101 157.51,101
  vias: v3(16.07,140.56) v3(16.06,139.82) v3(16.07,139.11) v3(30.9,67.85) v3(30.9,66.97) v3(30.9,66.11) v3(31.53,67.85) v3(31.53,66.97) v3(31.53,66.11) v3(32.17,67.85) v3(32.17,66.97) v3(32.17,66.11) v3(32.8,67.85) v3(32.8,66.97) v3(32.8,66.11) v3(54.21,157.72) v3(54.52,158.28) v3(54.85,157.72) v3(77.76,8.8) v3(77.76,8.16) v3(77.76,7.53) v3(78.39,8.8) v3(78.39,8.16) v3(78.39,7.53) v3(79.03,8.8) v3(79.03,8.16) v3(79.03,7.53) v3(79.66,8.8) v3(79.66,8.16) v3(79.66,7.53) v3(80.3,8.8) v3(80.3,8.16) v3(80.3,7.53) v3(146.59,174.03) v3(146.59,172.38) v3(148.75,174.03) v3(149.51,173.29) v3(156.5,99.2) v3(157.13,99.2) v3(157.77,99.2) v3(158.4,99.2) v3(174.98,139.8) v3(175.47,140.5) v3(175.65,139.81) v3(175.64,139.14) v3(175.65,138.48) v3(175.85,62.93) v3(176.49,62.93) v3(176.56,38.77) v3(176.56,34.83) v3(176.56,33.69) v3(177.12,62.93) v3(177.45,37.37) v3(177.45,36.1) v3(177.45,34.83) v3(177.45,33.69) v3(177.76,62.93) v3(177.71,38.77) v3(178.39,62.93) v3(178.34,24.29) v3(178.98,24.29) v3(179.03,62.93) v3(179.21,38.67) v3(179.61,24.29) v3(180.25,24.29) v3(180.73,38.67) v3(180.88,24.29) v3(181.52,24.29) v3(182.18,40.7) v3(182.15,24.29) v3(182.23,38.57) v3(182.79,24.29) v3(183.42,24.29) v3(183.57,40.7) v3(184.06,24.29) v3(184.97,40.7) v3(185.71,42.58) v3(185.71,41.95) v3(185.71,41.31) v3(185.71,40.68) v3(186.34,43.22) v3(186.34,42.58) v3(186.34,41.95) v3(186.34,41.31) v3(186.34,40.68) v3(186.98,43.22) v3(186.98,42.58) v3(186.98,41.95) v3(186.98,41.31) v3(186.98,40.68) v3(218.73,51.73) v3(219.49,51.73) v3(220.38,51.73) v3(221.27,51.73) v3(222.16,51.73) v3(222.79,50.71) v3(222.79,49.82) v3(222.92,53) v3(222.92,51.85) v3(223.81,53) v3(223.81,51.85) v3(224.57,53) v3(224.57,51.85) v3(244.89,41.57) v3(244.89,40.55) v3(244.86,39.81) v3(245.63,39.81) v3(246.52,39.81) v3(247.28,39.81) v3(248.17,39.81) v3(248.95,41.57) v3(248.95,40.55) v3(248.93,39.81)
+PWR_SRC_MXM:
  vias: v2(153.64,106.74)
+PWR_SRC_S: length 4.6
  BOTTOM w0.102: v2(29.24,140.02) PC8.1
  BOTTOM w0.508: PC8.1 28,142.5 PQ4.1
+RSVD_VCC3P3_2: length 3.5
  BOTTOM w0.102: v2(117.9,156.16) 118.35,155.71 R554.2
  BOTTOM w0.254: U31.1 120.14,154.53 119.74,154.93
  BOTTOM w0.508: 119.74,154.93 119.52,154.93 118.91,155.53 R554.2
+RTC_CELL: length 321.8
  TOP w0.254: C278.1 165.07,130.71 165.55,130.71 166.36,131.51 U29.16 ; v1(18.37,91.6) 18.09,91.6 17.89,91.4 17.89,90.61 18.27,90.23 19.59,90.23 20.33,89.49 20.33,88.48 20.46,88.35 22.54,88.35 22.67,88.48 22.67,90.66 24.28,92.27 UH1.A6
  TOP w0.356: v1(14.28,93.97) 14.23,93.97 14,94.2 JIO1.58
  TOP w0.381: U10.5 163.55,138.83 C287.1
  TOP w0.508: R810.1 112.71,163.61 112.76,163.56 v1(112.76,163.48) ; RH44.1 17.76,92.21 v1(18.37,91.6) 18.5,91.73 RH67.2 RH43.1 ; v1(169.15,129.68) 169.13,129.66 R395.2 ; v1(165.64,130.11) 165.59,130.16 164.97,130.16 164.55,130.58 164.55,131.07 C278.1 ; R819.1 105.57,163.41 105.16,163 v1(105.16,162.82) 104.81,162.47 R870.1 106.36,162.04 106.66,161.73 C1353.1 106.66,161.02 105.98,160.34 v1(105.85,160.34) ; v1(162.75,138.92) 163.46,138.92 C287.1
  IN1 w0.508: v1(46.27,151.25) 46.95,151.93 46.95,156.53 v1(46.49,156.98)
  IN2 w0.508: v1(118.7,170.55) 137.78,170.55 147.06,161.27 147.06,159.65 148.81,157.9 150.29,157.9 150.91,157.28 150.91,156.25 150.28,155.61 150.28,154.98 151.8,153.45 151.8,152.56 152.43,151.93 152.94,151.93 153.83,151.04 153.83,149.11 153.04,148.32 153.04,146.53 153.3,146.28 153.3,144.18 154.24,143.24 154.82,143.24 159.14,138.92 v1(162.75,138.92) 164.42,138.92 166.18,137.17 166.18,130.9 165.64,130.36 v1(165.64,130.11) 165.64,129.98 166.51,129.12 168.72,129.12 169.15,129.55 v1(169.15,129.68) ; v1(105.16,162.82) 105.16,163.15 105.62,163.61 112.71,163.61 112.76,163.56 v1(112.76,163.48) ; v1(18.37,91.6) 17.57,91.6 16.23,92.94 16.23,94 15.4,94.83 15.4,96.99 14.94,97.45 14.94,100.39 13.69,101.65 13.69,105.71 15.05,107.07 15.22,107.07 15.63,107.48 15.63,109.69 16.49,110.55 16.49,112.53 18.31,114.35 18.31,114.72 18.93,115.34 18.93,115.63 21.09,117.78 21.09,119.11 21.83,119.85 22.44,119.85 22.87,120.28 22.87,123.38 22.69,123.56 22.69,126.78 28.63,132.71 34.87,132.71 37.52,135.36 37.52,136.6 40.04,139.11 40.04,140.98 42.76,143.7 44.92,143.7 46.34,145.12 46.34,145.94 47.09,146.69 47.09,150.73 46.57,151.25 v1(46.27,151.25)
  IN3 w0.508: v1(118.7,170.55) 118.7,169.9 118.39,169.58 115.5,169.58 115.15,169.22 115.15,167.7 112.68,165.24 112.68,163.57 112.76,163.5 v1(112.76,163.48)
  IN4 w0.457: v1(18.37,91.6) 18.37,91.98 15.99,94.37 15.25,94.37 14.85,93.97 v1(14.28,93.97)
  IN4 w0.508: v1(118.7,170.55) 118.44,170.81 99.94,170.81 95.04,165.91 91.66,165.91 91.41,166.16 82.01,166.16 81.49,165.64 73.31,165.64 68.93,161.27 64.32,161.27 61.4,158.34 56.54,158.34 55.18,156.98 51.76,156.98 51.36,157.39 48.55,157.39 48.14,156.98 v1(46.49,156.98)
  BOTTOM w0.254: v1(105.85,160.34) 105.75,160.44 U51.B64
  BOTTOM w0.356: v1(14.28,93.97) 14.3,93.99 14.99,93.99
  BOTTOM w0.508: CH57.1 15.5,91.21 16.71,91.21 CH56.1 CH55.1 17.99,91.6 v1(18.37,91.6) ; v1(112.76,163.48) 112.76,164.3 112.3,164.76 110.22,164.76 109.97,164.5 R873.1 ; PD1.1 44.17,157.52 PC2.1 46.27,157.2 v1(46.49,156.98) ; 14.99,93.99 15.32,94.32 v4(15.57,94.32) 16.52,94.32 16.72,94.52 RH5.1 RH42.1
+SA_DIMM1_VREFDQ: length 38.1
  TOP w0.356: 136.33,91.1 136.87,90.55 JDIMM1.1
  TOP w0.508: 136.33,91.1 135.31,91.1 131.35,87.13 CD2.1 130.86,87.6 CD1.1 129.56,87.6 129.07,87.11 129.07,86.19 129.04,86.17 v1(129.04,85.49) 129.04,84.85 RD43.1 RD44.2 RD41.2
  BOTTOM w0.356: 144.42,91.44 144.42,91.23 145.1,90.55 JDIMM2.1
  BOTTOM w0.508: 144.42,91.44 142.22,93.64 137.88,93.64 v2(132.44,88.2) CD2.1 130.7,87.11 CD1.1 129.42,87.6 129.04,87.22 v1(129.04,85.49)
+SA_DIMM_VREFDQ: length 92
  TOP w0.254: JCPU1.F16 91.59,45.22 v1(91.12,44.75)
  TOP w0.508: v1(127.03,83.25) RD41.1 126.56,83.91 125.73,84.75 CD89.1
  BOTTOM w0.305: v1(91.12,44.75) 91.6,44.26 91.6,39.55 91.6,39.54 91.6,39.46 91.98,39.08
  BOTTOM w0.508: 91.98,39.08 93.23,37.83 100.4,37.83 106.38,31.85 115.1,31.85 127.03,43.78 v2(127.03,63.5) v1(127.03,83.25)
+SB_DIMM1_VREFDQ: length 121.2
  TOP w0.356: 150.63,92.62 149.97,91.96 149.97,90.94 150.35,90.56 JDIMM3.1
  TOP w0.508: 150.63,92.62 v1(153.68,92.62)
  IN3 w0.508: v1(190.74,77.71) 190.13,77.1 186.32,77.1 185.07,78.34 184.31,78.34 181.57,81.09 176.8,81.09 174.84,83.04 171.56,83.04 170.98,82.46 164.6,82.46 163.84,83.22 163.84,90.25 159.82,94.27 155.33,94.27 v1(153.68,92.62)
  BOTTOM w0.356: JDIMM4.1 159.4,91.39
  BOTTOM w0.508: RD50.1 RD49.2 ; RD49.2 RD48.2 180.6,88.12 181.01,87.72 181.01,87.21 ; RD49.2 180.67,89.11 181.01,89.46 CD45.1 CD46.1 183.49,91.08 185.58,89 185.58,86.62 190.74,81.46 v1(190.74,77.71) ; CD72.1 184.04,87.35 CD71.1 182.05,87.35 181.89,87.18 181.03,87.18 181.01,87.21 ; 181.01,87.21 181.01,86.98 180.55,86.52 179.47,86.52 178.12,85.18 176.39,85.18 174.96,86.6 v2(167.27,86.6) 165.74,86.6 163.31,89.04 163.31,95.41 162.01,96.71 160.77,96.71 159.4,95.34 159.4,91.39
+SB_DIMM_VREFDQ: length 160.5
  TOP w0.254: JCPU1.F13 94.59,45.22 v1(94.12,44.75)
  BOTTOM w0.305: v1(94.12,44.75) 93.64,44.26 93.64,39.17
  BOTTOM w0.508: RD48.1 CD91.1 178.98,87.11 178.29,86.42 176.56,86.42 175.68,87.31 165.93,87.31 163.94,89.3 163.94,95.68 162.27,97.34 160.5,97.34 158.29,95.13 127.59,95.13 126.27,93.81 126.27,89.9 126.4,89.77 v2(126.4,69.85) 126.4,44.04 114.84,32.48 106.65,32.48 100.54,38.59 94.21,38.59 93.64,39.17
+SDC_IN: length 354.6
  TOP w0.254: v1(25.18,74.84) 24.04,73.7 21.31,73.7 20.8,74.2 18.99,74.2 18.51,74.67 PC700.1
  IN2 w0.508: v1(176.89,87.95) 176.51,87.95 173.77,85.2 173.21,85.2 168.82,80.81 168.82,77.43 167.42,76.03 167.42,75.14 168.94,73.62 168.94,58.65 168.28,57.99 168.28,55.46 171.53,52.21 171.53,47.38 171.87,47.05 171.87,46.14 172.53,45.48 v1(172.65,45.48) ; v1(95.06,27.44) 94.99,27.44 94,28.43 89.5,28.43 88.16,27.09 85.06,27.09 84.77,26.79 82.92,26.79 77.37,21.25 76.1,21.25 74.94,20.09 74.94,17.13 75.56,16.51 75.56,13.27 74.41,12.11 74.41,9.75 72.85,8.19 68.94,8.19 67.82,7.07 62.2,7.07 59.71,4.58 51.17,4.58 45.58,10.18 45.58,25.7 42.91,28.36 42.91,33.25 40.75,35.41 40.75,44.11 39.73,45.12 39.73,47.88 42.22,50.37 42.22,54.68 39.99,56.91 39.99,66.08 35,71.07 30.43,71.07 v3(29.33,72.16)
  IN4 w0.508: v1(95.06,27.44) 95.09,27.4 95.64,27.4 95.96,27.72 126.78,27.72 128.18,26.33 134.27,26.33 136.31,24.29 166.4,24.29 175.07,32.95 175.07,44.82 174.41,45.48 v1(172.65,45.48)
  BOTTOM w0.254: PR762.1 175.5,43.65 174.91,44.23 174.91,44.99 174.43,45.48 v1(172.65,45.48)
  BOTTOM w0.508: PR1015.1 151.1,113.82 150.45,113.17 150.45,111.85 150.96,111.34 v4(150.96,104.53) 150.96,100.59 154.64,96.92 159.18,96.92 160.24,97.98 162.54,97.98 164.58,95.94 164.58,89.56 166.19,87.95 v1(176.89,87.95)
+SIM_PWR: length 97.5
  IN3 w0.508: v3(249.84,83.35) 255.48,83.35 271.38,67.45 271.38,45.45 263.05,37.12 260.26,37.12 258.01,39.37 253.56,39.37 249.31,35.11 240.37,35.11 v1(239.73,34.48)
  BOTTOM w0.508: v1(239.73,34.48) 239.73,34.68 v4(240.07,35.02) C616.1 241.39,35.47 JSIM1.1 ; JMINI2.8 250.86,85.8 250.62,85.56 C617.1 250.1,84.3 C119.1 250.03,83.54 v3(249.84,83.35)
+SM_VREF: length 66.5
  TOP w0.254: v1(105.12,71.75) 105.06,71.75 JCPU1.AM3
  TOP w0.508: CD90.1 RD45.1 127.29,48.8 121.22,54.87 v2(121.22,58.63) v3(121.22,83.23)
  BOTTOM w0.33: v1(105.12,71.75) 104.62,71.24 104.62,70.54 104.9,70.25 107.53,70.25
  BOTTOM w0.508: 107.53,70.25 114.36,70.25 121.22,77.11 v3(121.22,83.23)
+SM_VREF_DIMM: length 111.1
  TOP w0.356: JDIMM3.126 160.99,50.66 161.45,50.2 v1(161.45,50.07) ; JDIMM1.126 147.04,50.65 147.8,51.41 v1(147.8,52.33)
  TOP w0.508: v1(130.29,46.26) 127.64,46.26 127.29,46.62 RD45.2 RD46.1 RD47.2 129.62,47.2 130.07,47.65 130.07,48.51 v1(130.34,48.78) 131,48.12 CD20.1 131.58,48.12 132.08,48.61 CD19.1
  IN1 w0.508: v1(163.1,51.6) 161.83,51.6 161.45,51.98 159.39,51.98 158.61,52.77 151.88,52.77 151.27,53.38 149.13,53.38 148.5,52.74 v1(148.5,52.33)
  IN4 w0.508: v1(164.12,44.74) 162.21,44.74 161.2,45.76 160.54,45.76 159.44,46.85 154.01,46.85 153.78,46.62 140.04,46.62 139.07,45.65 130.89,45.65 v1(130.29,46.26) ; v1(130.34,48.78) 130.34,48.68 130.84,48.17 137.58,48.17 137.83,48.42 144.15,48.42 147.8,52.07 v1(147.8,52.33)
  BOTTOM w0.356: JDIMM4.126 149.94,50.66 148.5,52.11 v1(148.5,52.33) ; JDIMM2.126 136.56,50.65 135.64,49.74 135.64,49.49 135.19,49.03 v2(133.82,49.03) 132.91,49.03 CD19.1
  BOTTOM w0.508: 162.7,49.39 163.42,48.66 CD63.1 164.37,47.41 164.96,46.82 164.96,45.58 v1(164.12,44.74) ; 162.7,49.39 162.73,49.39 CD85.1 163.8,51.59 CD86.1 v1(163.1,51.6) ; 162.7,49.39 CD64.1 161.96,49.57 v1(161.45,50.07) ; v1(130.34,48.78) 131,48.12 CD20.1 132,48.12 CD19.1
+TRM_CT1: length 4.2
  TOP w0.102: C479.1 158.43,142.59 v2(158.03,142.2)
  TOP w0.508: C479.1 159.36,142.66 T156.3
+TRM_CT2: length 4.3
  TOP w0.102: C480.1 161.26,142.59 v2(161.87,141.98)
  TOP w0.508: T156.4 160.63,142.66 C480.1
+TRM_CT3: length 4.2
  TOP w0.102: C484.1 166.21,142.72 v2(165.68,142.19)
  TOP w0.508: C484.1 166.98,142.78 T156.9
+TRM_CT4: length 4.1
  TOP w0.102: v2(169.57,142.24) 169.31,142.24 168.83,142.72 C486.1
  TOP w0.508: C486.1 168.25,142.78 T156.10
+V_DDR_REF: length 99.6
  TOP w0.508: PC209.1 127.49,86.19 128.02,85.66 v1(128.02,85.49)
  IN3 w0.508: v1(132.55,91.88) 136.77,96.1 143.75,96.1 144.82,95.03 159.95,95.03 164.47,90.51 164.47,86.08 166.57,83.98 174.8,83.98 177.01,81.77 183.14,81.77 187.18,77.73 v1(189.85,77.73)
  IN4 w0.508: v1(175.45,77.76) 175.85,78.17 175.85,79.69 176.67,80.5 179.49,80.5 182.91,77.07 186.42,77.07 187.08,77.73 v1(189.85,77.73)
  BOTTOM w0.203: PU200.4 175.73,77.5 175.47,77.76 v1(175.45,77.76)
  BOTTOM w0.508: v1(132.55,91.88) 132.55,89.78 131.58,88.81 128.94,88.81 128.05,87.92 v4(128.05,87.25) 128.05,85.51 v1(128.02,85.49)
+VCHGR: length 25.2
  BOTTOM w0.102: v4(204.49,38.45) 205.49,39.46 205.86,39.46 PQ1005.3
  BOTTOM w0.508: PQ1083.3 209.66,28.25 212.84,31.43 212.84,38.31
+VCOMP_OUT: length 5.3
  TOP w0.381: JCPU1.F22 85.65,45.28 v1(86.12,45.75)
  BOTTOM w0.381: v1(86.12,45.75) 86.12,45.8 v2(85.42,46.51) 85.07,46.85 84.79,46.85 84.18,47.46 84.18,47.74 83.78,48.14 RC2.1 83.57,48.12 RC1.1
+VDISPLAY_VCC: length 7.5
  TOP w0.102: v1(22.97,170.06) 23.34,169.7 23.34,166.25 23.25,166.16 23.25,165.9 23.39,165.76 23.39,164.36 R460.1 R461.1
  vias: v2(23.48,166.7)
+VR_CAP: length 6.9
  TOP w0.508: C779.1 111.59,154.86 107.46,154.86 v2(107.43,154.9) 107.07,155.26 v1(107.07,155.51)
  BOTTOM w0.305: v1(107.07,155.51) 107.07,155.38 107.45,155 108.06,155 108.08,155.02 U51.B12
A_ON: length 174.1
  TOP w0.102: v1(106.54,145.55) 105.32,146.77 105.32,147.51 104.96,147.86 v1(104.96,152.66) ; PR315.2 19.16,145.96 19.01,145.96 18.63,145.58 18.63,143.77 20.76,141.64 22.21,141.64 22.93,142.36 24.74,142.36 25.86,143.49 26.58,143.49 27.94,144.84 28.89,144.84 29.65,144.08 33.68,144.08 35.47,142.29 37.35,142.29 37.82,142.76 39.4,142.76 43.21,146.57 44.55,146.57 45.49,147.51 45.78,147.51 46.24,147.97 46.24,149.97 47.04,150.77 v1(48.21,150.77)
  IN1 w0.109: v1(106.54,145.55) 106.19,145.21 106.19,143.88 104.73,142.42 104.73,137.58 105.64,136.67 105.64,135.82 108.16,133.3 108.16,131.54 v1(108.15,131.53)
  IN3 w0.127: v1(108.15,131.53) 110.59,129.09 114.65,129.09 119.2,124.55 119.2,120.08 123.61,115.67 v1(124.32,115.67) ; v1(106.54,145.55) 106.4,145.69 100.88,145.69 97.5,149.07 96.25,149.07 93.12,152.19 91.93,152.19 90.03,154.1 90.03,158.58 87.89,160.72 87.13,160.72 86.52,160.11 85.81,160.11 85.28,160.64 78.24,160.64 77.81,160.21 64.57,160.21 62.55,158.19 60,158.19 56.3,154.49 51.84,154.49 49.6,152.26 49.6,151.56 48.81,150.77 v1(48.21,150.77)
  BOTTOM w0.102: U51.B24 104.75,152.17 104.91,152.33 104.91,152.61 v1(104.96,152.66) ; v1(124.32,115.67) 122.88,115.67 118.74,111.53 v2(118.74,109.75) 119.42,109.07 U35.5 ; R429.2 106.46,145.63 v1(106.54,145.55)
AC_DIS: length 530.3
  TOP w0.102: PQ8.5 18.07,68.51 17.59,68.03 16.82,68.03 16.01,67.22 v1(16.01,66.3) ; v1(237.57,72.05) 236.84,71.31 226.5,71.31 225.79,72.02 222.21,72.02 221.29,72.93 220.46,72.93 217.41,75.98 217.41,78.12 217.1,78.42 216.34,78.42 v1(215.92,78)
  IN1 w0.109: v1(237.57,78.27) 238.15,78.27 239.73,79.85 242.85,79.85 243.33,79.37 250.66,79.37 251.09,79.8 251.09,79.8 252.89,81.6 262.89,81.6 266.81,77.68 266.81,76.49 272.96,70.34 272.96,46.25 262.9,36.19 258.58,36.19 258.45,36.32 257.69,36.32 257.47,36.1 252.13,36.1 250.91,34.89 237.25,34.89 223.04,20.68 200.74,20.68 199.95,19.89 131.58,19.89 131,20.48 106.65,20.48 103.3,23.82 86.39,23.82 85.08,22.52 85.08,20.13 79.77,14.81 79.77,13.42 72.5,6.15 60.74,6.15 58.74,4.15 49.47,4.15 43.37,10.26 43.37,16.7 41.87,18.19 41.87,24.43 38.72,27.58 38.72,30.58 35.19,34.1 35.19,48.33 38.71,51.85 38.71,53.21 36.37,55.55 36.37,64.9 34.2,67.07 34.2,68.31 33.47,69.05 30.51,69.05 29.27,67.8 28.3,67.8 28,67.5 17.18,67.5 16.01,66.33 v1(16.01,66.3) ; v1(215.92,78) 215.92,78.44 216.3,78.83 216.3,83.72 215.91,84.11 215.41,84.11 214.81,84.71 212.65,84.71 211.97,85.4 210.01,85.4 208.95,86.45 202.08,86.45 197.3,91.23 197.3,94.05 192.68,98.67 185.85,98.67 177.1,107.41 175.91,107.41 171.61,111.71 v1(171.61,111.72)
  IN3 w0.127: v1(237.57,72.05) v1(237.57,78.27)
  BOTTOM w0.102: U46.B12 216.42,77.5 v1(215.92,78) ; v1(237.57,72.05) v2(238.11,72.05)
  BOTTOM w0.254: v1(171.61,111.72) 171.61,110.04 169.44,107.87 167.33,107.87 162.17,102.72 158.99,102.72 158.49,103.21 158.49,104.15 157.2,105.45 PR1030.2
AC_PRESENT: length 151
  TOP w0.102: UH1.E6 26.37,92.17 v1(26.11,91.91)
  IN2 w0.127: v1(26.11,91.91) 23.71,91.91 22.78,92.84 20.63,92.84 19.34,94.13 19.34,94.91 18.83,95.42 18.83,95.79 18.19,96.43 18.19,97.18 17.69,97.69 17.69,100.85 17.08,101.46 17.08,106.68 17.22,106.82 17.22,109.03 19.93,111.74 19.93,114.09 20.52,114.68 20.52,114.97 22.57,117.02 22.95,117.02 25.32,119.38 25.32,123.49 26.35,124.51 26.35,128.19 29.21,131.05 35.83,131.05 41.39,136.61 41.39,138.21 42.48,139.3 43.24,139.3 44.71,140.78 46.52,140.78 47.99,142.25 47.99,145.33 50.29,147.63 50.29,150.76 51.26,151.74 53.17,151.74 57.99,156.56 65.61,156.56 69.04,159.99 70.15,159.99 74,163.84 74,165.02 74.59,165.62 78.26,165.62 78.99,164.89 81.54,164.89 82.26,164.17 86.98,164.17 88.09,163.06 93.61,163.06 97.55,166.99 v1(100.29,166.99)
  BOTTOM w0.102: v1(100.29,166.99) v2(100.29,166.33) 100.97,165.64 101.61,165.64 101.81,165.44 101.81,164.76 R835.2 102.5,164.07 U51.A54
ACAV_DOCK_SRC#: length 84.7
  IN2 w0.254: v1(152.78,111.99) 152.29,112.47 147.42,112.47 146.52,113.37 131.45,113.37 128.19,116.63 121.59,116.63 119.01,114.06 101.93,114.06 98.75,117.24 96.73,117.24 95.08,118.9 95.08,122.54 v1(95.74,123.2)
  BOTTOM w0.102: v1(152.78,111.99) 152.78,111.77 v2(153.04,111.5)
  BOTTOM w0.254: JDOCK1.42 83.2,125.2 83.96,124.45 88.22,124.45 88.48,124.19 94.75,124.19 v1(95.74,123.2) ; v1(152.78,111.99) 152.78,112.05 152.13,112.7 PR1013.2 152.13,113.93 PR1017.1
ACAV_IN: length 347.2
  TOP w0.102: U29.21 169.32,130.26 169.58,130 169.58,127.79 170.28,127.09 v1(170.95,127.09)
  IN1 w0.109: v1(201.71,77.18) 196.94,81.95 185.04,81.95 181.91,85.08 179.28,85.08 179.03,85.33 177.36,85.33 160.23,102.46 155.51,102.46 148.01,109.95 v1(148.01,113.4)
  IN2 w0.127: v1(170.95,127.09) 170.87,127.16 169.96,127.16 169.33,127.8 166.15,127.8 164.42,129.53 156.77,129.53 155.07,131.23 155.07,134.73 148.55,141.25 146.9,141.25 140.67,147.48 133.33,147.48 126.9,153.91 126.6,153.91 125.78,154.73 125.78,156.31 124.96,157.12 122.93,157.12 120.21,159.85 120.21,160.27 119.43,161.05 116.36,161.05 114.65,162.75 114.65,163.28 114.05,163.88 113.48,163.88 113.22,163.61 113.22,163.18 112.78,162.75 108.52,162.75 108.03,162.27 v1(108.03,162.19)
  IN3 w0.127: v1(171.56,56.17) 171.26,56.17 170.9,55.81 170.9,53.33 177.21,47.01 177.66,47.01 179.06,45.62 195.98,45.62 197.71,43.89 212.16,43.89 215.38,47.11 215.38,51.65 211.13,55.89 207.6,55.89 205.6,57.9 v1(205.6,67.98)
  IN4 w0.109: v1(170.95,127.09) 170.07,126.21 170.07,119.71 169.57,119.2 163.02,119.2 158.59,114.78 149.4,114.78 v1(148.01,113.4)
  BOTTOM w0.102: PQ707.2 226.81,64.6 224.04,67.37 221.02,67.37 220.59,67.8 220.59,68.57 219.32,69.84 215.45,69.84 214.16,68.54 206.16,68.54 v1(205.6,67.98) 205.6,69.81 201.96,73.44 201.96,76.92 v1(201.71,77.18) ; PQ710.3 169.99,54.23 170.26,54.51 PR717.1 170.26,55.89 PR772.2 170.54,56.17 v1(171.56,56.17) ; v1(108.03,162.19) 107.82,161.97 U51.A64 ; U17.1 122.07,102.87 121.73,103.21 121.73,103.64 122.16,104.07 v2(132.42,104.07) 135.02,104.07 139.96,109.01 140.64,109.01 143.83,112.21 144.73,112.21 145.78,111.16 146.87,111.16 149.2,113.48 PR1021.1 148.59,113.4 v1(148.01,113.4)
ACAV_IN_NB: length 181.2
  IN1 w0.254: v1(153.88,128.38) 153.88,126.71 157.16,123.43 157.16,118.26 157.95,117.47 157.95,117.09 159.32,115.72 159.32,114.33 161.02,112.63 161.02,110.38 169.84,101.56 172.42,101.56 181.85,92.13 181.85,88.13 183.45,86.52 v1(183.85,86.52)
  IN2 w0.254: v1(183.85,86.52) 183.96,86.62 184.54,86.62 195.36,75.8 198.83,75.8 203.82,70.81 203.82,66.36 211.21,58.96 224.71,58.96 224.96,58.71 v1(225.9,58.71)
  IN3 w0.254: v1(106.93,153.21) 106.56,153.58 106.56,154.24 106.84,154.52 108.06,154.52 109.43,153.15 115.29,153.15 115.69,152.74 124.45,152.74 125.64,151.56 127.08,151.56 129.6,149.03 136.59,149.03 139.13,146.49 144.22,146.49 154.11,136.6 154.11,128.71 153.88,128.48 v1(153.88,128.38)
  BOTTOM w0.254: v1(153.88,128.38) 153.88,127.98 v2(153.51,127.61) 152.82,126.91 PR1019.2 ; v1(106.93,153.21) 106.61,152.89 106.61,152.32 106.75,152.19 U51.B20 ; PR742.1 v1(225.9,58.71)
ACAVDK_SRC: length 2.6
  BOTTOM w0.254: PU1001.4 152.2,116.74 152.31,116.63 v2(152.31,115.95) 152.31,115.17 PR1017.2
ACAVIN: length 5.1
  BOTTOM w0.102: PR1021.2 149.65,114.46 149.65,113.57 149.25,113.17 v2(149.25,113.04)
  BOTTOM w0.254: PR1021.2 150.2,115.93 PU1001.8
ACDET: length 5.9
  BOTTOM w0.254: PU700.6 v2(175.27,47.5) 174.26,47.5 PR732.2 PC783.1 175.8,45.07 PR762.2
ACPRN: length 17.9
  IN1 w0.254: v3(176.59,45.48) 176.59,46.09 175.83,46.85 175.83,53.2 173.74,55.28 v1(173.34,55.28)
  BOTTOM w0.254: PQ710.5 172.25,53.12 172.7,53.58 v2(172.7,54.98) 173.01,55.28 v1(173.34,55.28) ; v3(176.59,45.48) 176.59,44.64 PR771.2 177.23,45.13 PU700.5
ADP_I: length 475.5
  TOP w0.102: v1(172.32,25.77) 172.68,26.12 172.68,33.72 174.44,35.49 174.44,40.8 173.24,42.01 169.2,42.01 167.93,43.28 v1(167.93,46.47)
  IN2 w0.102: v1(52.23,15.02) 52.23,13.89 57.5,8.62 72.67,8.62 73.97,9.93 73.97,12.29 75.13,13.44 75.13,16.33 74.51,16.95 74.51,20.26 75.92,21.68 77.19,21.68 82.74,27.23 84.59,27.23 84.88,27.52 87.22,27.52 87.42,27.72 87.42,28.14 88.15,28.87 94.43,28.87 95.96,27.34 112.02,27.34 114.88,24.48 132.41,24.48 136.32,20.57 148.34,20.57 151.35,23.58 170.14,23.58 v1(172.32,25.77)
  IN3 w0.127: v1(113.14,153.78) 113.37,153.55 115.4,153.55 115.9,153.06 126.58,153.06 129.42,150.21 135.86,150.21 139.26,146.81 144.35,146.81 155.16,136 155.16,127.81 158,124.97 158,123.94 163.19,118.76 167.19,118.76 168.09,117.85 168.09,110.01 180.45,97.65 192.08,97.65 192.71,97.01 195.54,97.01 200.72,91.83 v1(200.72,90.54)
  IN3 w0.254: v3(217.71,52.49) 217.46,52.49 216.7,51.73 216.7,47.05 212.48,42.84 197.42,42.84 195.46,44.79 175.37,44.79 173.36,46.8 172.27,46.8 171.18,45.71 169.53,45.71 169.27,45.45 168.35,45.45 167.93,45.87 v1(167.93,46.47)
  BOTTOM w0.102: PR702.1 34.73,75.09 35.02,74.8 35.02,70.8 39.66,66.16 39.66,56.26 41.37,54.54 41.37,49.58 39.42,47.62 39.42,37.86 45.83,31.44 45.83,28.92 47.81,26.93 47.81,19.67 52.23,15.25 v1(52.23,15.02) ; v1(200.72,90.54) 200.72,75.27 201.43,74.56 201.43,72.99 203.87,70.55 203.87,63.7 v2(208.86,58.71) 214.91,52.66 216.39,52.66 216.82,52.23 217.46,52.23 v3(217.71,52.49) ; R1982.2 112.33,153.78 v1(113.14,153.78) 113.17,153.76 PC746.1
  BOTTOM w0.254: PR743.1 218.31,53.09 v3(217.71,52.49) ; PR704.1 168.31,46.85 v1(167.93,46.47)
ADP_I_R: length 2.8
  BOTTOM w0.102: R1982.1 110.78,153.58 110.33,154.02 110.33,154.6 v2(110.26,154.66) 110.16,154.77 U51.A12
ALERT#: length 4.1
  TOP w0.102: PR506.2 48.87,23.02 v1(48.93,23.09) 48.93,23.11 49.21,23.39 49.32,23.39 v2(49.84,23.91) 50.13,24.2 50.13,24.2 50.73,24.8 PU500.32
  BOTTOM w0.102: v1(48.93,23.09) 48.99,23.02 PR503.1
ALW_PWRGD_3V_5V: length 210.5
  IN3 w0.127: v1(251.54,63.64) 250.2,64.98 245.09,64.98 244.03,66.05 238.69,66.05 228.94,75.8 228.94,77.43 230.03,78.53 230.03,82.53 229.22,83.34 229.22,84.62 224.29,89.55 217.53,89.55 217.18,89.9 209.86,89.9 206.66,93.1 202.78,93.1 196.68,99.2 181.06,99.2 172.82,107.44 172.82,116.99 168.66,121.16 162.58,121.16 159.27,124.47 159.27,125.49 156.43,128.33 156.43,137.49 155.25,138.67 155.25,139.7 152.56,142.39 152.56,145.12 150.61,147.08 150.61,148.09 149.34,149.36 147.85,149.36 143.85,153.36 142.59,153.36 138.71,157.24 133.86,157.24 130.55,160.55 126.97,160.55 126.55,160.13 125.41,160.13 123.62,161.92 118.21,161.92 116.87,160.58 112.4,160.58 110.82,162.16 v1(110.42,162.16)
  BOTTOM w0.102: PR118.1 251.83,60.7 252.23,61.1 252.23,62.95 v1(251.54,63.64) ; v1(110.42,162.16) v2(110.42,161.54) 110.42,161.33 109.37,160.27 U51.A1
ALWON: length 200.1
  IN3 w0.127: v1(105.8,162.75) 106.18,163.13 110.91,163.13 112.08,161.96 115.05,161.96 115.71,161.3 116.87,161.3 118,162.43 124.19,162.43 125.23,161.39 128.06,161.39 128.39,161.06 131.85,161.06 135.16,157.74 138.97,157.74 142.45,154.26 143.67,154.26 148.06,149.87 149.55,149.87 151.11,148.3 151.11,147.29 153.07,145.34 153.07,142.6 156.69,138.98 156.69,128.44 159.53,125.6 159.53,124.57 162.69,121.41 168.76,121.41 173.07,117.1 173.07,107.54 181.14,99.48 196.78,99.48 202.88,93.38 206.92,93.38 209.38,90.92 216.59,90.92 217.71,89.8 224.54,89.8 227.97,86.37 228.18,86.37 230.29,84.26 230.29,78.42 229.19,77.33 229.19,76.06 238.77,66.48 v1(239,66.48)
  BOTTOM w0.102: PR112.1 241.41,64.07 v2(240.41,65.07) v1(239,66.48) ; U51.A60 105.5,162.45 v1(105.8,162.75)
AUD_HP_NB_SENSE: length 245.4
  TOP w0.102: JIO1.70 12.09,90.6 v1(11.64,90.16) ; v1(218.17,87.47) 218.3,87.6 218.3,89.57 218.25,89.62 218.25,91.2 216.47,92.97 201.3,92.97 200.82,93.46 v1(198.48,93.46)
  IN2 w0.127: v1(11.64,90.16) 10.7,89.22 9.23,89.22 8.77,88.75 8.77,85.04 14.1,79.72 16.16,79.72 16.67,80.22 16.67,80.99 17.1,81.42 17.69,81.42 19.11,80 23.25,80 24.09,80.83 24.09,81.6 24.32,81.82 28.69,81.82 29.45,82.59 34.22,82.59 35.44,81.37 36.2,81.37 36.66,81.82 42.3,81.82 42.58,81.54 42.58,81.44 42.88,81.14 46.09,81.14 47.28,82.33 51.86,82.33 53.47,83.94 66.65,83.94 71.42,88.71 72.58,88.71 76.51,92.64 81.44,92.64 83.41,94.61 87.43,94.61 89.49,96.67 113.89,96.67 114.15,96.42 117.45,96.42 118.7,95.16 130.68,95.16 132.3,96.78 132.3,98.9 135.14,101.74 137.22,101.74 140.37,98.59 154.63,98.59 155.26,97.95 161.24,97.95 164.72,94.47 179.55,94.47 180.18,93.84 198.1,93.84 v1(198.48,93.46)
  BOTTOM w0.102: U46.A41 v1(218.17,87.47) ; v1(11.64,90.16) v2(12.37,90.16)
AUD_NB_MUTE#: length 229.3
  TOP w0.102: JIO1.72 13.98,90 15.15,88.83 v1(15.15,88.71)
  IN2 w0.127: v1(182,97.11) 179.79,97.11 175.98,100.92 140.45,100.92 138.11,103.26 133.41,103.26 129.17,99.02 129.17,97.67 128.71,97.22 120.12,97.22 119.54,97.79 119.54,98.13 118.78,98.89 114.23,98.89 114.01,99.11 87.87,99.11 87.11,98.35 84.4,98.35 80.48,94.42 75.78,94.42 71.84,90.49 70.37,90.49 65.61,85.72 61.89,85.72 60.59,87.02 59.37,87.02 58.4,86.05 52,86.05 50.75,84.81 46.89,84.81 46.57,84.49 41.15,84.49 41.03,84.38 35.68,84.38 35.08,84.98 23.21,84.98 22.06,83.83 22.06,83.29 21.63,82.87 19.27,82.87 15.71,86.43 15.71,88.32 15.32,88.71 v1(15.15,88.71)
  BOTTOM w0.102: v1(182,97.11) 182.18,97.29 191.8,97.29 193.5,95.59 204.7,95.59 209.04,91.25 211.34,91.25 v2(211.65,91.56) 213.62,91.56 214.14,91.04 214.33,91.04 216.34,89.03 216.34,88.15 216.98,87.51 v1(216.98,87.47) 217.17,87.28 U46.A39
AUDIO_BACKLITE#: length 251.9
  TOP w0.102: JIO1.102 14.42,81 v1(15.02,80.4)
  IN2 w0.127: v1(15.02,80.4) 16.54,81.93 19.32,81.93 20.74,80.5 22.51,80.5 22.96,80.95 22.96,81.38 23.91,82.33 28.33,82.33 29.09,83.09 34.43,83.09 35.65,81.87 35.99,81.87 36.45,82.33 43.37,82.33 43.72,81.98 46.21,81.98 47.07,82.84 51.65,82.84 53.26,84.45 66.44,84.45 71.2,89.22 72.37,89.22 76.3,93.15 81.23,93.15 84.56,96.48 88.45,96.48 89.15,97.18 114.15,97.18 114.4,96.92 117.66,96.92 118.91,95.67 129.88,95.67 131.53,97.32 131.53,98.87 134.91,102.25 137.43,102.25 140.53,99.15 154.79,99.15 155.48,98.46 161.45,98.46 164.93,94.98 179.76,94.98 180.4,94.35 198.55,94.35 199.25,93.65 199.25,83.17 203.49,78.92 203.49,74.84 208.07,70.25 215.96,70.25 217.56,71.86 217.56,72.38 218.57,73.39 v1(222.39,73.39)
  BOTTOM w0.102: U46.B68 222.39,77.15 222.39,76.29 223.6,75.07 v2(223.6,74.84) 223.6,74.61 v1(222.39,73.39)
AUX_EN_WOWL: length 168.2
  TOP w0.102: R844.1 125.09,168.59 v1(124.89,168.79) 124.89,168.03 v2(125.22,167.7)
  IN1 w0.109: v1(221.42,77.96) 220.99,78.4 220.13,78.4 219.28,79.24 219.28,85.34 218.5,86.12 212.12,86.12 211.06,87.18 202.37,87.18 198.03,91.53 198.03,94.35 193,99.38 186.24,99.38 176.98,108.64 176.98,108.77 175.71,110.04 175.37,110.04 172.6,112.81 172.6,120.05 171.04,121.61 171.04,124.82 173.71,127.49 173.71,134.59 173.16,135.14 167.07,135.14 165.85,133.92 160.49,133.92 159.93,134.48 158.5,134.48 155.26,137.72 155.26,139.59 151.47,143.39 151.47,149.61 147.61,153.46 146.89,153.46 141.13,159.23 137.64,159.23 134.66,162.21 128.91,162.21 128.13,162.99 126.41,162.99 125.78,163.61 125.78,164.05 126.86,165.12 126.86,168.21 126.27,168.79 v1(124.89,168.79)
  BOTTOM w0.102: U46.B67 221.61,77.77 v1(221.42,77.96)
AUX_MODE_EN: length 6.6
  TOP w0.102: v1(219.13,90.74) 219.24,90.84 220.56,90.84 220.76,90.64 220.76,90.1 220.17,89.51 v1(220.17,87.47)
  BOTTOM w0.102: RP8.1 218.85,91.03 v1(219.13,90.74) ; U46.A45 v1(220.17,87.47)
BAT1_LED#: length 259.4
  TOP w0.102: JIO1.106 15.03,79.8 v1(15.63,80.4) 15.63,80.72 v2(15.87,80.96)
  IN2 w0.127: v1(15.63,80.4) 16.9,81.67 19.21,81.67 20.63,80.25 23.14,80.25 23.83,80.94 23.83,81.7 24.21,82.08 28.48,82.08 29.24,82.84 34.32,82.84 35.54,81.62 36.1,81.62 36.56,82.08 42.41,82.08 42.83,81.65 42.83,81.57 43.01,81.39 45.99,81.39 47.18,82.59 51.75,82.59 53.37,84.2 66.55,84.2 71.31,88.96 72.47,88.96 76.41,92.9 81.34,92.9 84.67,96.23 88.63,96.23 89.33,96.92 114.04,96.92 114.3,96.67 117.55,96.67 118.81,95.41 130.57,95.41 131.95,96.79 131.95,98.93 135.01,101.99 137.33,101.99 140.45,98.87 154.71,98.87 155.37,98.21 161.35,98.21 164.83,94.73 179.66,94.73 180.29,94.09 198.44,94.09 198.99,93.54 198.99,83.06 203.23,78.82 203.23,74.73 207.97,70 216.06,70 217.93,71.87 218.3,71.87 218.58,72.15 218.58,72.22 219.36,73.01 221.22,73.01 221.32,72.91 223.76,72.91 224.11,73.26 224.11,77.18 221.95,79.33 221.63,79.33 v1(221.19,79.77)
  BOTTOM w0.102: U46.B64 221.69,79.27 v1(221.19,79.77)
BAT2_LED#: length 245.4
  TOP w0.102: v1(14.38,80.4) JIO1.104
  IN2 w0.127: v1(14.38,80.4) 16.59,82.61 21.73,82.61 22.31,83.19 22.31,83.72 23.31,84.72 34.98,84.72 35.58,84.12 41.14,84.12 41.25,84.24 46.68,84.24 46.99,84.55 50.86,84.55 52.1,85.8 58.51,85.8 58.81,86.1 61.15,86.1 61.78,85.47 65.93,85.47 70.7,90.23 71.94,90.23 75.88,94.17 80.63,94.17 83.96,97.5 87.04,97.5 87.33,97.78 87.33,98.21 87.97,98.85 113.91,98.85 114.12,98.64 117.74,98.64 119.44,96.94 128.79,96.94 129.47,97.62 129.47,98.97 133.51,103.01 138,103.01 140.34,100.67 175.88,100.67 181.69,94.85 198.81,94.85 200.11,93.56 200.11,92.39 201.35,91.15 201.35,83.58 203.62,81.32 v1(203.62,80.78)
  BOTTOM w0.102: U46.A9 217.67,74.21 217.4,73.94 217.4,72.5 216.37,71.48 v2(216.1,71.48) 215.87,71.24 214.05,71.24 212.72,69.91 207.58,69.91 203.59,73.9 203.59,80.76 v1(203.62,80.78)
BBS_BIT1: length 9.5
  TOP w0.102: RH119.1 17.28,93.99 17.28,94.02 17.38,94.12 20.23,94.12 20.66,93.69 22.22,93.69 v2(22.25,93.71) 22.47,93.94 23.12,93.94 23.19,93.86 24.21,93.86 24.47,94.12 24.76,94.12 24.76,94.12 24.77,94.12 24.79,94.1 24.79,94.09 24.98,93.91 24.98,93.91 25.08,93.81 UH1.C10
BC_CLK_ECE1117: length 109.6
  TOP w0.102: JKB1.17 JKB1.18 v1(175.47,117.5) 175.17,117.5 v2(174.57,118.1)
  IN4 w0.109: v1(106.31,150) 108.06,151.75 108.06,153.41 110.25,155.6 110.75,155.6 112,156.84 123.26,156.84 125.97,159.55 126.5,159.55 126.81,159.24 130.15,159.24 132.63,156.77 133.63,156.77 140.18,150.23 148.47,150.23 150.45,148.25 150.45,146.02 150,145.57 150,140.8 156.51,134.29 164.24,134.29 166.09,132.44 170.47,132.44 172.45,130.46 173.2,130.46 174.22,129.44 174.22,118.89 175.47,117.63 v1(175.47,117.5)
  BOTTOM w0.102: U51.A20 106,150.31 v1(106.31,150)
BC_CLK_ECE5048: length 166.4
  IN1 w0.109: v1(211.16,83.53) 211.16,83.4 210.03,82.27 206.01,82.27 205.22,83.07 201.79,83.07 194.75,90.11 194.75,90.59 190.59,94.75 184.94,94.75 175.32,104.37 174.71,104.37 170,109.09 169.18,109.09 165.72,112.55 165.72,114.2 164.5,115.42 164.5,115.92 159.87,120.55 159.87,121.56 154.53,126.9 154.53,128.65 153.84,129.34 153.59,129.34 143.64,139.29 143.64,141.09 136.49,148.24 131.75,148.24 128.51,151.48 128.51,151.79 126.88,153.41 120.37,153.41 116.73,157.05 116.73,160.84 115.06,162.52 112.17,162.52 111.11,163.58 106.3,163.58 105.74,164.14 103.35,164.14 102.83,163.62 102.83,161.92 102.94,161.82 102.94,159.55 102.35,158.96 101.26,158.96 100.41,159.82 98.75,159.82 98.05,160.52 97.02,160.52 96.38,159.87 96.38,158.76 96.86,158.28 97.27,158.28 v1(97.6,157.95)
  BOTTOM w0.102: v1(97.6,157.95) 97.77,157.77 U51.A43 ; U46.A30 211.66,84.02 v1(211.16,83.53)
