# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_CS2_DIMM4#: length 72.2
  TOP w0.102: JCPU1.P4 v1(104.12,52.75)
  IN3 w0.089: 109.89,52.44 109.53,52.44 107.81,54.16 104,54.16 103.72,53.88 103.72,53.15 v1(104.12,52.75)
  IN3 w0.152: 109.89,52.44 113.22,52.44 116.68,48.98 117.23,48.98 117.38,48.83 117.38,48.32 117.54,48.17 117.84,48.17 117.99,48.32 117.99,48.83 118.15,48.98 118.45,48.98 118.6,48.83 118.6,48.29 118.73,48.16 119.09,48.16 119.21,48.29 119.21,48.83 119.37,48.98 119.67,48.98 119.82,48.83 119.82,48.32 119.97,48.17 120.28,48.17 120.43,48.32 120.43,48.83 120.58,48.98 120.89,48.98 121.04,48.83 121.04,48.32 121.19,48.17 121.5,48.17 121.65,48.32 121.65,48.83 121.8,48.98 122.11,48.98 122.26,48.83 122.26,48.32 122.41,48.17 122.72,48.17 122.87,48.32 122.87,48.83 123.02,48.98 123.33,48.98 123.48,48.83 123.48,48.32 123.63,48.17 123.94,48.17 124.09,48.32 124.09,48.83 124.24,48.98 125.04,48.98 125.17,49.11 125.17,49.54 125.29,49.67 134.31,49.67 134.79,50.14 135.66,50.14 135.78,50.02 135.78,49.32 135.91,49.19 139.07,49.19 139.2,49.32 139.2,50.19 139.32,50.31 144.75,50.31 146.32,51.88 150.28,51.88 150.69,52.29 152.23,52.29 152.55,52.62 154.82,52.62 154.95,52.49 154.95,51.94 154.82,51.81 v1(154.62,51.81)
  BOTTOM w0.102: v1(154.62,51.81) 153.29,53.15 153.17,53.15 152.56,53.76 152.56,53.93 152.24,54.26 JDIMM4.114
DDR_CS3_DIMM4#: length 69.1
  TOP w0.102: JCPU1.R2 v1(106.12,53.75)
  IN3 w0.089: 109.89,51.52 109.53,51.52 107.71,53.35 107.07,53.35 107.07,53.35 106.96,53.35 106.56,53.75 v1(106.12,53.75)
  IN3 w0.152: v1(156.14,51.81) 156.37,51.81 156.49,51.69 156.49,51.45 156.37,51.32 151.01,51.32 150.66,50.97 146.71,50.97 144.02,48.28 135.3,48.28 135.14,48.43 135.14,48.54 134.99,48.69 134.69,48.69 134.53,48.54 134.53,48.43 134.38,48.28 134.08,48.28 133.92,48.43 133.92,48.54 133.77,48.69 133.47,48.69 133.32,48.54 133.32,48.22 133.19,48.09 132.69,48.09 132.56,47.97 132.56,47.37 132.43,47.24 132.09,47.24 131.94,47.4 131.94,47.97 131.81,48.09 131.46,48.09 131.33,47.97 131.33,47.4 131.18,47.24 130.87,47.24 130.72,47.4 130.72,48.22 130.59,48.35 130.24,48.35 130.11,48.22 130.11,47.4 129.96,47.24 129.65,47.24 129.5,47.4 129.5,48.21 129.37,48.33 129.02,48.33 128.89,48.21 128.89,47.4 128.74,47.24 119.7,47.24 119.55,47.09 119.55,46.31 119.42,46.19 119.07,46.19 118.94,46.31 118.94,47.09 118.79,47.24 118.48,47.24 118.33,47.09 118.33,46.64 118.2,46.52 117.85,46.52 117.72,46.64 117.72,47.09 117.57,47.24 117.12,47.24 112.84,51.52 109.89,51.52
  BOTTOM w0.102: JDIMM4.121 158.43,52.16 158.33,52.26 156.59,52.26 v1(156.14,51.81)
DDR_CS4_DIMM1#: length 59.3
  TOP w0.102: JDIMM1.114 144.94,54.25 142.22,51.53 v1(141.15,49.72) ; JCPU1.M9 v1(99.12,50.75)
  IN1 w0.089: 108.58,48.14 108.25,48.47 107.87,48.47 107.68,48.66 107.68,48.99 107.48,49.19 102.79,49.19 102.6,49.01 102.6,48.69 102.28,48.37 99.86,48.37 99.53,48.7 99.53,49.03 99.27,49.29 98.84,49.29 98.69,49.44 98.69,50.31 v1(99.12,50.75)
  IN1 w0.178: v1(141.15,49.72) 141.36,49.72 141.49,49.59 141.49,49.28 141.36,49.15 137.52,49.15 135.93,47.56 133.77,47.56 131.93,45.71 130.37,45.71 130.19,45.54 130.19,45.25 130.02,45.07 129.66,45.07 129.48,45.25 129.48,45.54 129.3,45.71 128.95,45.71 128.77,45.54 128.77,45.25 128.59,45.07 128.24,45.07 128.06,45.25 128.06,45.54 127.88,45.71 127.53,45.71 127.35,45.54 127.35,45.25 127.17,45.07 113.4,45.07 110.45,48.01 108.71,48.01 108.58,48.14
DDR_CS5_DIMM1#: length 60.6
  TOP w0.102: v1(139.52,51.45) 139.52,51.14 139.65,51.01 140.78,51.01 140.9,50.89 140.9,50.56 140.78,50.43 139.14,50.43 139.01,50.56 139.01,51.66 138.52,52.15 JDIMM1.121 ; JCPU1.M10 v1(98.12,50.75)
  IN1 w0.089: 109.89,50.14 108.42,50.14 107.37,51.19 101.89,51.19 101.71,51.01 101.71,50.39 101.49,50.18 99.64,50.18 99.51,50.3 99.51,51.04 99.39,51.17 96.66,51.17 96.53,51.04 96.53,49.26 96.66,49.13 97.38,49.13 97.51,49.26 97.51,50.62 97.63,50.75 v1(98.12,50.75)
  IN1 w0.178: 109.89,50.14 111.34,50.14 114.28,47.2 118.28,47.2 118.92,47.85 128.98,47.85 129.44,48.31 131.51,48.31 132.89,49.69 134.32,49.69 134.67,50.05 135.4,50.05 136.8,51.45 v1(139.52,51.45)
DDR_CS6_DIMM3#: length 70.3
  TOP w0.102: v1(157.65,53.85) 158.06,54.26 JDIMM3.114 ; v1(105.12,52.75) JCPU1.P3
  IN3 w0.089: 109.89,49.24 109.86,49.24 107.9,51.19 105.89,51.19 105.52,51.57 105.52,52.35 v1(105.12,52.75)
  IN3 w0.152: v1(157.65,53.85) 158.95,53.85 159.39,53.41 159.39,50.43 159.24,50.28 159.03,50.28 158.87,50.13 158.87,49.82 159.03,49.67 159.24,49.67 159.39,49.52 159.39,49.11 159.2,48.92 152.43,48.92 152.19,48.68 147.8,48.68 144.08,44.96 138.02,44.96 138.01,44.95 134.86,44.95 133.64,43.73 117.4,43.73 111.9,49.24 109.89,49.24
DDR_CS7_DIMM3#: length 68.7
  TOP w0.102: v1(107.05,52.78) 106.59,53.25 JCPU1.P1 ; JDIMM3.121 152.01,52.16 152.77,51.4 157.06,51.4 157.62,51.81 v1(157.67,51.81)
  IN3 w0.089: v1(107.05,52.78) 107.87,52.78 109.58,51.06 109.89,51.06
  IN3 w0.152: 109.89,51.06 112.65,51.06 118.16,45.56 119.44,45.56 120.67,46.79 132.62,46.79 133.65,47.82 136.17,47.82 136.32,47.67 136.32,47.29 136.47,47.14 136.78,47.14 136.93,47.29 136.93,47.67 137.08,47.82 137.39,47.82 137.54,47.67 137.54,47.29 137.69,47.14 137.99,47.14 138.15,47.29 138.15,47.67 138.3,47.82 144.21,47.82 146.9,50.51 150.85,50.51 151.19,50.86 158.81,50.86 158.93,50.99 158.93,51.69 158.81,51.81 v1(157.67,51.81)
DDR_HVREF_RST_PCH: length 10.5
  TOP w0.102: UH1.N8 29.4,92.58 v1(29.16,92.58)
  BOTTOM w0.076: v1(29.16,92.58) 28.79,92.21 28.79,91.3
  BOTTOM w0.102: RH170.2 24.67,85.84 26.12,87.29 26.89,87.29 v2(27.4,87.81) 28.13,88.53 28.13,90.64 28.79,91.3
DDR_XDP_SMBCLK_R1: length 2.7
  TOP w0.102: RC127.2 74.56,9.91 74.56,10.66 74.7,10.79 JXDP1.53
DDR_XDP_SMBDAT_R1: length 2.6
  TOP w0.102: JXDP1.51 74.2,10.79 74.33,10.65 74.33,9.89 RC125.2
DDR_XDP_WAN_SMBCLK: length 502.9
  TOP w0.102: RC127.1 74.57,8.2 74.57,7.89 74.33,7.66 63.53,7.66 61.01,10.18 61.01,13.33 v1(60.82,13.52) ; JDIMM3.202 160.44,27.86 160.62,28.05 161.64,28.05 v1(161.83,27.85) ; JDIMM1.202 146.82,27.85 147.01,28.04 147.22,28.04 148.35,26.91 148.7,26.91 v1(148.88,26.73) ; v1(17.08,88.91) 17.31,88.68 17.31,88 18.31,87 QH4.1
  IN1 w0.109: v1(246.62,73.11) 246.79,72.94 247.05,72.94 248.14,74.03 251.39,74.03 255.43,78.07 260.35,78.07 269.3,69.12 269.3,47.48 264.45,42.63 253.73,42.63 250.08,38.97 236.3,38.97 223.47,26.14 197.85,26.14 193.27,30.72 189.9,30.72 185.76,26.58 174.35,26.58 173.19,27.74 172.2,27.74 168.99,30.94 168.99,38.97 168.42,39.55 168.05,39.55 167.67,39.17 167.67,38.75 v1(167.88,38.54) 167.68,38.35 167.68,38.06 167.35,37.73 166.96,37.73 163.76,34.53 163.76,32.72 163.14,32.09 163.14,28.64 162.54,28.05 162.03,28.05 v1(161.83,27.85) 161.64,28.04 160.2,28.04 159.08,26.92 149.06,26.92 v1(148.88,26.73) 148.68,26.93 148.54,26.93 148.43,26.82 148.43,26.66 146.16,24.39 140.91,24.39 140.07,25.23 133.61,25.23 v1(133.41,25.03) 133.21,25.23 108.09,25.23 105.04,28.27 96.67,28.27 95.68,29.27 85.06,29.27 84.66,28.87 84.02,28.87 74.35,19.21 74.35,15.89 73.41,14.95 72.27,14.95 70.04,12.71 61.3,12.71 61,13.01 61,13.34 v1(60.82,13.52) ; v1(17.08,88.91) 17.25,89.08 17.61,89.08 18.91,87.78 18.91,87.43 22.36,83.98 24.83,83.98 25.57,83.24 26.45,83.24 26.83,82.87 33.28,82.87 36.18,79.97 36.18,79.64 v1(35.98,79.44)
  IN4 w0.109: v1(35.98,79.44) 36.18,79.23 36.18,78.22 35.1,77.15 35.1,68.01 37.68,65.43 37.68,55.96 40.05,53.59 40.05,51.34 37.33,48.61 37.33,39.9 39.77,37.46 39.77,31.77 40.29,31.26 40.29,28.72 43.92,25.08 43.92,20.61 48.49,16.04 58.96,16.04 61,13.99 61,13.71 v1(60.82,13.52) ; v1(19.24,121.3) 19.43,121.1 19.43,120.91 19.28,120.76 16.98,120.76 13.93,117.71 13.93,116.14 13.84,116.06 13.84,115.17 12.4,113.73 12.4,112.64 12.05,112.28 12.05,111.92 11.1,110.98 11.1,108.72 10.24,107.87 10.24,103.59 11.05,102.79 11.05,100.75 11.76,100.04 11.76,96.86 11.02,96.12 11.02,93.77 13.53,91.27 15.25,91.27 16.18,90.34 16.18,89.52 16.62,89.08 16.91,89.08 v1(17.08,88.91)
  BOTTOM w0.102: v1(246.62,73.11) 246.82,72.91 248.83,72.91 R1159.2 249.63,72.91 250.13,72.91 250.74,73.51 251.06,73.51 251.34,73.8 JMINI2.30 ; JDIMM4.202 150.2,27.86 150.01,28.05 149.85,28.05 149.73,27.92 149.73,27.25 149.39,26.91 149.06,26.91 v1(148.88,26.73) ; v1(167.88,38.54) 167.91,38.58 R502.2 168.7,38.76 U88.4 ; v1(133.41,25.03) 133.61,25.23 134.01,25.23 135.11,26.33 135.11,26.91 136.23,28.03 136.46,28.03 136.63,27.85 JDIMM2.202 ; RH31.1 19.44,122.41 19.44,121.5 v1(19.24,121.3)
DDR_XDP_WAN_SMBCLK_R2: length 3.4
  TOP w0.102: v1(19.28,124.78) 19.44,124.61 19.44,124.09 19.3,123.95 JXDP2.53
  BOTTOM w0.102: v1(19.28,124.78) 19.47,124.59 19.47,124.06 RH31.2
DDR_XDP_WAN_SMBDAT: length 502.9
  TOP w0.102: QH4.4 19.61,89.1 19.13,89.57 17.15,89.57 v1(17.08,89.49) ; JDIMM3.200 160.44,28.46 160.62,28.27 161.62,28.27 v1(161.83,28.48) ; RC125.1 74.34,8.2 74.34,7.99 74.24,7.88 63.63,7.88 61.24,10.28 61.24,13.33 v1(61.43,13.52) ; JDIMM1.200 146.83,28.45 147.01,28.27 147.31,28.27 148.44,27.14 148.67,27.14 v1(148.88,27.34)
  IN1 w0.109: v1(17.08,89.49) 17.25,89.32 17.71,89.32 19.15,87.88 19.15,87.53 22.46,84.21 24.93,84.21 25.67,83.48 26.55,83.48 26.93,83.1 33.38,83.1 36.41,80.06 36.41,79.63 v1(36.61,79.44) ; v1(61.43,13.52) 61.24,13.34 61.24,13.1 61.4,12.95 69.94,12.95 72.17,15.18 73.32,15.18 74.12,15.98 74.12,19.31 83.92,29.11 84.57,29.11 84.96,29.5 95.78,29.5 96.77,28.51 105.14,28.51 108.19,25.46 133.21,25.46 v1(133.41,25.66) 133.61,25.47 140.17,25.47 141.01,24.62 146.06,24.62 148.19,26.76 148.19,26.91 148.44,27.16 148.7,27.16 v1(148.88,27.34) 149.06,27.15 158.98,27.15 160.1,28.28 161.63,28.28 v1(161.83,28.48) 162.03,28.28 162.44,28.28 162.9,28.74 162.9,32.19 163.53,32.82 163.53,34.63 166.86,37.97 167.25,37.97 167.45,38.16 167.45,38.36 v1(167.27,38.54) 167.44,38.71 167.44,39.27 167.95,39.79 168.52,39.79 169.23,39.07 169.23,31.04 172.3,27.98 173.29,27.98 174.45,26.82 185.66,26.82 189.8,30.96 193.37,30.96 197.95,26.38 223.37,26.38 236.21,39.21 249.98,39.21 253.64,42.87 264.35,42.87 269.06,47.58 269.06,69.03 260.25,77.84 255.53,77.84 251.49,73.79 248.24,73.79 247.15,72.7 246.79,72.7 v1(246.62,72.53)
  IN4 w0.109: v1(61.43,13.52) 61.24,13.71 61.24,14.09 59.06,16.27 48.59,16.27 44.15,20.71 44.15,25.18 40.52,28.81 40.52,31.36 40.01,31.87 40.01,37.56 37.56,40 37.56,48.51 40.29,51.24 40.29,53.69 37.92,56.06 37.92,65.53 35.34,68.11 35.34,77.05 36.41,78.12 36.41,79.24 v1(36.61,79.44) ; v1(19.87,121.3) 19.67,121.09 19.67,120.81 19.38,120.53 17.07,120.53 14.16,117.62 14.16,116.04 14.08,115.96 14.08,115.07 12.64,113.63 12.64,112.54 12.28,112.18 12.28,111.83 11.34,110.88 11.34,108.62 10.48,107.77 10.48,103.69 11.29,102.88 11.29,100.85 12,100.14 12,96.76 11.26,96.02 11.26,93.87 13.63,91.5 15.35,91.5 16.42,90.43 16.42,89.62 16.72,89.32 16.9,89.32 v1(17.08,89.49)
  BOTTOM w0.102: v1(167.27,38.54) 166.94,38.54 R501.2 166.79,39.71 166.79,40.5 167.19,40.9 U88.6 ; v1(246.62,72.53) 246.77,72.69 248.83,72.69 249.22,72.29 R1160.2 249.62,72.68 250.22,72.68 250.83,73.29 251.07,73.29 251.35,73 JMINI2.32 ; JDIMM4.200 150.19,28.46 150,28.27 149.76,28.27 149.5,28.01 149.5,27.34 149.29,27.14 149.08,27.14 v1(148.88,27.34) ; RH30.1 19.67,122.4 19.67,121.5 v1(19.87,121.3) ; v1(133.41,25.66) 133.61,25.46 133.92,25.46 134.88,26.43 134.88,27 136.13,28.26 136.46,28.26 136.65,28.45 JDIMM2.200
DDR_XDP_WAN_SMBDAT_R2: length 3.4
  TOP w0.102: JXDP2.51 19.8,123.93 19.67,124.07 19.67,124.57 v1(19.87,124.78)
  BOTTOM w0.102: RH30.2 19.69,124.03 19.69,124.6 v1(19.87,124.78)
DE_A: length 1.6
  BOTTOM w0.102: R560.2 216.87,68.01 U637.7
DE_B: length 1.4
  BOTTOM w0.102: U637.8 217.37,68.4 R550.2
DEVICE_DET#: length 255.5
  TOP w0.102: JODD1.8 v1(38.03,36.75)
  IN1 w0.109: v1(113.37,159.52) 113.37,155.89 114.44,154.82 114.44,153.22 113.63,152.42 113.63,150.93 112.78,150.08 112.78,144.9 111.62,143.73 111.62,140.21 110.09,138.68 110.09,135.05 119.56,125.59 119.56,114.27 116.25,110.96 116.25,104.26 117.49,103.01 117.49,94.52 v1(119.06,92.95)
  IN4 w0.109: v1(38.03,36.75) 38.03,31.25 38.72,30.56 38.72,27.91 42.33,24.31 42.33,16.85 52.03,7.15 71.97,7.15 75.21,10.38 75.21,11.5 89.63,25.92 92.07,25.92 92.44,26.29 92.44,28.6 93.52,29.68 93.52,33.11 96.36,35.95 107.04,35.95 113.88,42.79 113.88,67.53 119.06,72.7 v1(119.06,92.95)
  BOTTOM w0.102: v1(113.37,159.52) v2(112.54,160.35) 111.74,161.15 R1125.2 111.67,163.99 109.91,162.24 109.91,161.96 108.47,160.52 U51.B1
DGPU_ALERT#: length 129.7
  TOP w0.102: v1(209.71,91.68) 209.71,89.65 207.63,87.56 207.63,81.52 v1(206.99,80.88)
  IN3 w0.127: v1(206.99,80.88) 205.43,80.88 204.5,81.81 187.57,81.81 182.88,86.5 175.92,86.5 159.35,103.06 148.55,103.06 144.13,107.48 130.92,107.48 128.51,105.07 121.95,105.07 120.86,103.98 120.86,103.47 120.45,103.06 119.57,103.06 v1(119.11,103.52)
  BOTTOM w0.102: RP3.5 209.67,80.16 208.95,80.88 v1(206.99,80.88) ; U46.A42 218.67,87.6 218.35,87.92 218.35,88.76 218.03,89.08 216.62,89.08 214.66,91.03 214.66,91.46 v2(214.43,91.69) 214.03,92.1 210.13,92.1 v1(209.71,91.68) ; Q5.1 118.96,103.67 v1(119.11,103.52)
DGPU_HOLD_RST#: length 102.1
  TOP w0.102: UH1.A12 24.39,94.63 24.04,94.27 23.43,94.27 23.31,94.4 21.27,94.4 20.99,94.68 20.99,95.11 20.33,95.77 19.9,95.77 19.69,95.97 18.7,95.97 18.32,96.35 18.32,97.06 18.02,97.37 17.23,97.37 RH74.2 15.91,97.83 v1(15.71,97.62)
  IN2 w0.127: v1(15.71,97.62) 15.71,97.33 16.54,96.5 16.54,94.68 16.96,94.25 16.96,93.19 17.86,92.3 18.83,92.3 19.21,91.92 19.21,89.88 19.65,89.44 19.65,88.56 20.08,88.12 24.82,88.12 25.41,87.54 28.02,87.54 29.04,86.52 30.45,86.52 31.12,87.2 35.1,87.2 35.71,86.59 37.28,86.59 37.95,85.91 40.09,85.91 40.21,86.03 45.33,86.03 47.04,87.74 49.56,87.74 50.28,88.45 50.96,88.45 51.55,87.87 56.85,87.87 57.61,88.63 61.28,88.63 62.29,87.62 65.13,87.62 70.27,92.75 70.98,92.75 75.58,97.34 78.29,97.34 79.68,98.74 79.99,98.74 v1(80.65,99.4)
  BOTTOM w0.102: 82.84,103.03 83.85,103.03 83.98,103.16 R1973.2 85.96,104.07 R39.1 ; 82.84,103.03 82.84,101.51 v2(81.78,100.45) 80.73,99.4 v1(80.65,99.4) ; 82.84,103.03 82.58,103.03 82.32,103.3 U16.1
DGPU_PEX_RST#: length 22
  TOP w0.102: v1(85.38,95.69) 85.5,95.81 JMXM1.184
  BOTTOM w0.102: 85.73,97.35 v4(85.73,97.34) ; 85.73,97.35 85.38,97 v1(85.38,95.69) 84.97,95.29 84.97,94.93 85.23,94.68 86.83,94.68 90.08,97.93 90.08,99.39 89.22,100.25 Q4.2 ; 85.73,97.35 86.17,97.78 86.17,98.59 84.62,100.14 84.62,100.67 83.62,101.67 U16.4 84.03,102.14 84.16,102.27 R38.2 85.07,102.27 R1973.1
DGPU_PWR_EN: length 251.3
  TOP w0.102: JMXM1.44 122.5,97.69 v1(120.51,99.68) ; RH132.1 15.91,95.36 v1(16.11,95.16) 15.99,95.03 RH113.2 16.63,94.4 QC5.1
  IN1 w0.109: v1(214,72.78) 214,71.82 212.69,70.5 204.86,70.5 195.44,79.93 183.99,79.93 181.07,82.85 180.64,82.85 180.12,82.33 177.4,82.33 165.84,93.89 159.19,93.89 158.76,94.31 137,94.31 136.49,94.83 124.04,94.83 120.51,98.36 v1(120.51,99.68)
  IN2 w0.127: v1(16.11,95.16) 16.11,94.75 16.71,94.15 16.71,93.09 17.75,92.05 18.69,92.05 18.96,91.78 18.96,89.77 19.13,89.59 19.4,89.33 19.4,88.4 21.3,86.5 24.88,86.5 25.57,87.2 28,87.2 28.93,86.27 30.56,86.27 31.23,86.94 35,86.94 35.61,86.33 37.17,86.33 37.84,85.66 40.2,85.66 40.31,85.77 45.43,85.77 47.15,87.49 56.83,87.49 57.72,88.38 61.17,88.38 62.19,87.36 65.24,87.36 69.66,91.78 71.27,91.78 75.77,96.28 79.07,96.28 80.02,97.23 80.93,97.23 81.5,97.8 81.5,98.6 82.84,99.93 86.17,99.93 87.33,101.09 91.37,101.09 91.53,100.92 109.21,100.92 109.42,101.14 110.25,101.14 110.98,100.4 115.22,100.4 115.45,100.18 120.01,100.18 v1(120.51,99.68)
  IN4 w0.109: v1(218.8,85.2) 218.37,84.77 218.37,84.69 216.47,82.79 216.47,76.16 215.83,75.52 215.83,74.74 213.98,72.88 213.98,72.81 v1(214,72.78)
  BOTTOM w0.102: v2(119.96,100.14) 120.42,99.68 v1(120.51,99.68) ; U46.B45 218.92,85.32 v1(218.8,85.2)
DGPU_PWR_EN#: length 10.5
  TOP w0.102: UH1.C12 25.44,94.53 24.98,94.53 24.79,94.35 24.79,94.35 24.76,94.32 24.39,94.32 24.14,94.07 23.31,94.07 23.21,94.17 21.46,94.17 21.32,94.03 v2(20.94,94.03) 20.38,94.59 RH328.2 19.92,94.45 19.06,94.45 18.4,95.11 18.22,95.11 17.73,95.6 QC5.2
DGPU_PWROK: length 303.2
  TOP w0.102: v1(122.13,103.44) 122.82,102.75 122.82,99.35 122.85,99.38 122.85,96.95 JMXM1.42 ; UH1.C14 25.07,95.44 24.76,95.75 24.5,95.75 24.3,95.55 22.66,95.55 v2(22.49,95.38) 21.99,94.88 v1(21.99,94.87)
  IN1 w0.109: v1(229.35,70.65) 228.91,71.08 222.77,71.08 221.12,72.73 214.66,72.73 214.2,73.19 213.83,73.19 213.55,72.91 213.55,71.87 212.42,70.74 204.96,70.74 195.53,80.17 184.08,80.17 181.17,83.08 180.54,83.08 180.02,82.56 177.5,82.56 165.94,94.13 164.34,94.13 161.31,97.16 136.44,97.16 135.94,96.66 125.21,96.66 123.63,98.24 123.63,98.54 122.9,99.28 122.82,99.35 122.82,102.75 v1(122.13,103.44)
  IN2 w0.127: v1(122.13,103.44) 121.12,104.46 115.35,104.46 115.14,104.67 81.47,104.67 80.97,104.18 80.07,104.18 78.37,102.47 76.74,102.47 76.08,101.81 72.69,101.81 69.34,98.47 69.15,98.47 67.65,96.96 66.38,96.96 64.83,95.41 61.02,95.41 59.95,94.35 v1(59.95,94.32)
  IN4 w0.109: v1(59.95,94.32) 58.42,92.79 53.13,92.79 51.57,91.23 48.17,91.23 46.79,89.85 44.33,89.85 44.23,89.95 43.24,89.95 42.71,89.42 41.61,89.42 40.8,88.61 39.38,88.61 37.73,86.96 29.45,86.96 28.87,87.55 26.1,87.55 24.88,88.76 24.57,88.76 23.61,89.72 23.61,92.26 22.77,93.1 22.65,93.1 21.99,93.76 v1(21.99,94.87)
  BOTTOM w0.102: v1(229.35,70.65) 229.35,72.91 225.92,76.34 225.92,77.77 225.34,78.35 225.34,80.58 224.98,80.94 224.98,81.02 224.47,81.52 U46.A56 ; R1977.2 R14.1 128.18,100.16 128.74,100.72 128.74,101.28 126.17,103.85 122.54,103.85 v1(122.13,103.44) ; U27.1 56.03,102.65 56.68,103.31 57.57,103.31 58.6,102.28 U14.1 60.98,101.85 61.22,101.61 64.14,101.61 64.8,102.28 U25.1 65.3,101.62 65.7,101.21 67.79,101.21 68.23,100.77 68.23,98.82 65,95.59 62.06,95.59 61.18,94.71 61.18,94.31 60.79,93.91 60.36,93.91 v1(59.95,94.32)
DGPU_SELECT#: length 259.5
  TOP w0.102: U630.54 64.37,134.68 v1(64.4,134.66)
  IN1 w0.109: v1(52.76,152.16) 52.79,152.13 55.32,152.13 62.39,145.06 62.39,136.95 64.4,134.95 v1(64.4,134.66)
  IN3 w0.127: v1(64.4,134.66) 66.66,136.92 66.66,140.07 72.1,145.51 74.06,145.51 76.05,143.53 84.47,143.53 89.57,138.43 89.58,138.43 97.93,130.09 97.93,127.8 102.75,122.97 102.75,120.43 104.9,118.29 104.9,116.7 108.69,112.91 128.36,112.91 129.86,111.42 143.39,111.42 149.69,105.12 160.17,105.12 171.84,93.44 177.41,93.44 179.13,91.73 179.46,91.73 180,91.18 183.63,91.18 186.2,88.61 186.2,87.93 190.17,83.96 208.03,83.96 210.39,81.6 213.39,81.6 213.85,81.14 215.1,81.14 215.43,80.81 215.43,79.56 214.87,79.01 v1(214.87,78.58)
  IN4 w0.109: v1(52.76,152.16) 53.4,152.16 53.45,152.11 55,152.11 57.29,154.4 69.05,154.4 72,157.35 74.62,157.35 77.4,160.13 83.45,160.13 84.64,161.33 84.64,161.61 v1(85.02,161.99)
  BOTTOM w0.102: v1(214.87,78.58) 215.42,78.03 U46.B14 ; U19.39 85,161.96 v1(85.02,161.99) ; U3.1 49.42,152.43 49.82,152.03 50,152.03 50.23,151.8 v2(52.14,151.8) 52.41,151.8 v1(52.76,152.16)
DGPU_THERMTRIP#: length 95.3
  IN1 w0.109: v1(114.84,110.5) 115.12,110.5 119.08,114.46 119.08,125.39 109.3,135.18 109.3,138.41 107.48,140.22 107.48,140.89 109.65,143.05 109.65,145.63 110.14,146.13 110.14,146.27 112.31,148.44 112.31,150.28 113.11,151.08 113.11,152.69 113.55,153.13 113.55,153.96 113.11,154.39 113.11,155.03 112.11,156.03 112.11,159.03 111.34,159.8 110.27,159.8 109.94,160.13 v1(109.94,160.26)
  BOTTOM w0.102: U51.A2 109.45,159.77 v1(109.94,160.26) ; Q4.1 87.87,100.25 87.87,101.79 R11.2 88.43,102.42 v2(92.85,106.85) 93.46,107.45 97.37,107.45 98.66,108.75 109.94,108.75 111.82,110.63 114.72,110.63 v1(114.84,110.5)
DH_1.35V: length 18.6
  IN4 w0.762: v3(178.28,74.39) v3(179.05,74.39) 179.05,73.24 179.87,72.43 181.39,72.43 186.72,67.09 186.72,64.11 v3(187.89,62.94) v3(188.65,62.94)
  BOTTOM w0.102: v3(187.89,62.94) 187.89,62.37 v2(188.21,62.05)
DH_CHG: length 17.6
  IN1 w0.762: v3(195.87,50.71) 194.73,49.57 186.47,49.57 185.58,48.68 v3(181.14,48.68)
  BOTTOM w0.254: PU700.18 180.96,48.5 v3(181.14,48.68)
  BOTTOM w0.635: PQ704.4 v3(195.87,50.71)
DIMM1_SA0: length 7.2
  TOP w0.102: RD8.1 134.55,30.69 v2(134.91,30.34) 135.89,29.35 JDIMM1.197
DIMM1_SA1: length 9.7
  TOP w0.102: RD11.2 129.96,30.69 130.87,29.78 v2(132.19,29.78) 134.43,29.78 136.05,28.15 JDIMM1.201
DIMM2_SA0: length 28.5
  BOTTOM w0.102: JDIMM2.197 145.8,29.35 146.84,29.35 148.14,28.05 148.14,26.71 145.83,24.39 133.14,24.39 132.65,24.88 132.65,27.45 v2(130.54,29.56) 129.41,30.69 RD19.2
DIMM2_SA1: length 24.4
  BOTTOM w0.102: RD20.2 131.99,29.45 v2(132.26,29.18) 132.88,28.56 132.88,24.98 133.23,24.62 145.74,24.62 147.16,26.05 147.16,27.81 146.82,28.15 145.8,28.15 JDIMM2.201
DIMM3_SA0: length 28.1
  TOP w0.102: JDIMM3.197 151.19,29.35 149.52,29.35 149.16,28.99 149.16,27.8 149.28,27.67 149.28,26.55 148.9,26.17 v1(148.67,26.17) ; RD26.1 163.69,31.94 v1(164.3,32.55)
  IN1 w0.109: v1(164.3,32.55) 163.51,31.76 163.51,27.37 162.7,26.55 151.55,26.55 151.16,26.17 v1(148.67,26.17)
  BOTTOM w0.102: v1(164.3,32.55) v2(163.66,32.55)
DIMM3_SA1: length 15.9
  TOP w0.102: JDIMM3.201 152.05,28.16 153.07,27.14 155.81,27.14 v1(156.29,27.62) ; v1(161.45,29.88) 161.91,29.42 163.28,29.42 163.69,29.83 RD27.1
  IN1 w0.109: v1(161.45,29.88) 160.89,29.32 159.83,29.32 158.12,27.62 v1(156.29,27.62)
  BOTTOM w0.102: v1(161.45,29.88) 161.45,29.97 v2(161.79,30.31)
DIMM4_SA0: length 9.8
  BOTTOM w0.102: JDIMM4.197 159.41,29.35 162.57,29.35 v2(163.88,30.66) 164.5,31.28 166.66,31.28 167.67,32.29 RD37.2
DIMM4_SA1: length 13.2
  BOTTOM w0.102: RD36.1 169.71,32.6 v2(168.42,31.31) 168.16,31.05 165.02,31.05 162.96,28.99 161.65,28.99 160.82,28.16 JDIMM4.201
DIS_BAT_PROCHOT#: length 116.4
  IN1 w0.109: v1(154.64,145.32) 155.8,144.17 155.8,142.76 157.68,140.88 157.68,139.14 159.52,137.3 161.01,137.3 162.57,135.74 166,135.74 166.58,136.32 173.65,136.32 174.9,135.08 174.9,113.39 175.08,113.21 176.19,113.21 187.49,101.9 196.25,101.9 208.24,89.9 222.92,89.9 v1(223.4,90.38)
  BOTTOM w0.102: v1(154.64,145.32) 154.64,145.62 v2(154.29,145.97) 154,146.26 152.48,146.26 152.33,146.42 151.29,146.42 150.83,146.87 150.83,148.12 149.56,149.39 PR1081.1 ; v1(223.4,90.38) 223.55,90.23 R760.2
DIS_BAT_PROCHOT#_R: length 3.7
  BOTTOM w0.102: R760.1 223.22,88.53 v2(223.22,87.79) 223.22,87.52 221.92,86.22 U46.B51
DIS_PROCHOT#: length 34.5
  IN4 w0.254: v1(215.44,57.28) 229.13,57.28 232.42,60.56 v1(232.42,61.83)
  BOTTOM w0.102: v1(232.42,61.83) v2(232.42,60.72)
  BOTTOM w0.254: PR740.2 221.27,56.42 220.63,57.06 PU703.7 217.97,57.06 217.53,56.63 216.57,56.63 216.16,57.03 PR735.1 v1(215.44,57.28) 215.43,57.27 PR716.1 ; v1(232.42,61.83) 231.81,61.83 PC736.1 PC735.1 232.03,63.04 PQ706.2
DISP_ON: length 16.8
  TOP w0.102: JEDP1.19 48.45,146.45 47.53,145.53 47.53,143.17 v1(45.58,141.21)
  BOTTOM w0.102: R1138.1 44.92,140.17 44.32,139.58 D64.1 ; R1138.1 44.92,140.55 v1(45.58,141.21) ; R1138.1 44.15,141.26 D67.1 ; D69.1 44.77,142.53 D67.1 ; D67.1 43.5,142.16 v2(44.05,142.71)
DK_AC_OFF: length 5.6
  BOTTOM w0.102: v2(155.16,127.65) 154.91,127.65 154.35,127.09 154.35,126.21 PR1014.1
  BOTTOM w0.254: PU1001.25 152.7,124.18 153.83,125.3 PR1014.1
DK_AC_OFF_EN: length 2.7
  BOTTOM w0.254: PR1020.1 v2(150.78,124.67) 151.2,124.25 PU1001.22
DK_CSS_GC: length 66.2
  TOP w0.254: PR714.1 89.7,112.69 v1(89.47,112.46)
  IN2 w0.254: v1(141.44,112.86) 141.36,112.94 131.35,112.94 128.06,116.23 121.72,116.23 119.1,113.6 92.72,113.6 91.45,112.33 89.59,112.33 v1(89.47,112.46)
  BOTTOM w0.254: PU1001.11 148.07,118.78 147.57,118.28 147.57,117.25 147.3,116.98 145.55,116.98 v2(142.67,114.1) v1(141.44,112.86)
DK_PWR_BAR: length 2.3
  BOTTOM w0.254: PR1007.2 156.56,119.78 PU1001.33
DL_1.35V: length 4
  BOTTOM w0.508: PQ202.4 181.44,74.92 v2(181.15,75.21) 181.01,75.35 180.37,75.35 180.25,75.47
DL_CHG: length 8.8
  BOTTOM w0.254: PU700.15 179.23,50.71 179.87,51.34
  BOTTOM w0.762: 185.58,52.36 184.66,53.28 v2(180.91,53.28) 179.87,52.23 179.87,51.34
DMI_CRX_PTX_N0: length 99.8
  TOP w0.102: UH1.BD21 42.8,98.14 42.87,98.08 43.02,98.08 43.12,98.18 43.49,98.18 43.61,98.31 47.02,98.31 47.71,98.99 47.94,98.99 48.07,99.12 v1(48.07,99.3) ; JCPU1.D21 86.59,43.22 v1(86.12,42.75)
  IN1 w0.089: v1(86.12,42.75) 86.69,42.75 86.75,42.81 86.75,43.09 86.67,43.17 84.01,43.17 83.74,42.9 83.74,40.62 83.76,40.6 83.76,40.58
  IN1 w0.117: v1(48.07,99.3) 48.01,99.3 47.74,99.57 47.74,99.81 47.87,99.93 49.23,99.93 51.09,98.08 51.09,96.76 52.26,95.58 52.59,95.58 54.03,94.14 54.03,93.64 56.96,90.71 56.96,88.96 58.38,87.54 59.57,87.54 65.53,81.58 65.53,56.49 71.45,50.56 71.45,39.49 72.1,38.84 83.09,38.84 83.76,39.52 83.76,40.58
DMI_CRX_PTX_N1: length 97
  TOP w0.102: v1(45.75,97.38) 45.75,97.45 45.4,97.8 45.2,97.8 44.99,98 43.75,98 43.53,97.79 43.34,97.79 UH1.BE20 ; JCPU1.C21 86.59,42.22 v1(86.12,41.75)
  IN1 w0.089: 84.74,40.57 84.74,40.6 84.72,40.62 84.72,41.92 84.97,42.17 86.43,42.17 86.72,41.88 86.72,41.69 86.65,41.62 86.25,41.62 v1(86.12,41.75)
  IN1 w0.117: 84.74,40.57 84.74,39.94 84.62,39.83 84.62,39.41 83.39,38.18 71.69,38.18 70.69,39.18 70.69,50.38 64.87,56.2 64.87,81.3 61.66,84.51 60.09,84.51 56.17,88.43 56.17,90.56 53.83,92.89 53.67,92.89 50.85,95.71 50.85,95.98 49.92,96.91 48.27,96.91 47.23,97.95 45.6,97.95 45.47,97.83 45.47,97.65 45.74,97.38 v1(45.75,97.38)
DMI_CRX_PTX_N2: length 95.9
  TOP w0.102: v1(86.12,40.75) 86.59,41.22 JCPU1.B21 ; v1(46.92,97.37) 45.92,96.36 43.6,96.36 43.4,96.56 43.11,96.56 43.01,96.45 42.86,96.45 42.8,96.51 UH1.BD17
  IN1 w0.089: v1(86.12,40.75) 86.28,40.9 86.62,40.9 86.72,40.8 86.72,40.62 86.47,40.37 85.91,40.37 85.53,39.99 85.53,39.67 85.5,39.63
  IN1 w0.117: v1(46.92,97.37) 46.67,97.11 46.67,96.79 46.97,96.49 49.73,96.49 50.3,95.92 50.3,95.65 53.48,92.47 53.53,92.47 55.23,90.76 55.23,88.76 60.03,83.96 61.53,83.96 64.44,81.04 64.44,55.31 70.16,49.59 70.16,38.97 71.38,37.76 83.75,37.76 84.19,38.19 84.19,38.32 84.47,38.6 84.59,38.6 84.87,38.87 84.87,39 85.14,39.27 85.27,39.27 85.5,39.5 85.5,39.63
DMI_CRX_PTX_N3: length 94.3
  TOP w0.102: UH1.BE18 43.63,97.06 43.71,96.99 44.18,96.99 44.57,97.38 v1(44.57,97.38) ; v1(86.12,39.75) 86.59,40.22 JCPU1.A21
  IN1 w0.117: v1(86.12,39.75) 86.26,39.89 86.57,39.89 86.73,39.73 86.73,39.49 86.45,39.21 86.33,39.21 86.05,38.94 86.05,38.81 85.78,38.54 85.65,38.54 85.38,38.27 85.38,38.14 84.34,37.09 70.98,37.09 69.4,38.68 69.4,49.29 63.78,54.9 63.78,80.53 61.17,83.14 59.91,83.14 54.31,88.74 54.31,90.54 53.86,90.99 53.33,90.99 48.93,95.4 46.05,95.4 44.38,97.06 44.38,97.29 44.47,97.38 v1(44.57,97.38)
DMI_CRX_PTX_P0: length 100
  TOP w0.102: v1(87.12,42.75) 87.59,43.22 JCPU1.D20 ; v1(47.43,99.3) 47.43,99.02 46.93,98.52 43.52,98.52 43.38,98.38 43.13,98.38 42.94,98.57 42.66,98.57 42.38,98.28 UH1.BB21
  IN1 w0.089: v1(87.12,42.75) 87.12,42.75 86.94,42.92 86.94,43.17 86.75,43.36 83.93,43.36 83.55,42.98 83.55,40.62 83.53,40.6 83.53,40.58
  IN1 w0.117: v1(47.43,99.3) 47.51,99.38 47.51,99.91 47.77,100.17 49.33,100.17 51.32,98.17 51.32,96.85 52.36,95.82 52.69,95.82 54.27,94.24 54.27,93.73 57.19,90.81 57.19,89.06 58.48,87.78 59.67,87.78 65.76,81.68 65.76,56.58 71.69,50.66 71.69,39.59 72.2,39.08 82.99,39.08 83.53,39.62 83.53,40.58
DMI_CRX_PTX_P1: length 97.3
  TOP w0.102: UH1.BC20 42.45,97.78 42.92,97.78 43.12,97.57 43.62,97.57 43.84,97.79 44.9,97.79 45.16,97.53 v1(45.16,97.38) ; JCPU1.C20 87.59,42.22 v1(87.12,41.75)
  IN1 w0.089: 84.5,40.57 84.5,40.6 84.53,40.62 84.53,42 84.89,42.37 86.5,42.37 v1(87.12,41.75)
  IN1 w0.117: v1(45.16,97.38) 45.24,97.46 45.24,97.92 45.5,98.19 47.33,98.19 48.37,97.15 50.02,97.15 51.09,96.08 51.09,95.81 53.77,93.13 53.93,93.13 56.4,90.66 56.4,88.53 60.19,84.75 61.76,84.75 65.1,81.4 65.1,56.3 70.93,50.48 70.93,39.28 71.79,38.42 83.3,38.42 84.39,39.51 84.39,39.93 84.5,40.04 84.5,40.57
DMI_CRX_PTX_P2: length 96.1
  TOP w0.102: v1(87.12,40.75) 87.59,41.22 JCPU1.B20 ; v1(46.34,97.37) 46.34,97.09 45.83,96.58 43.69,96.58 43.51,96.76 43.11,96.76 42.93,96.94 42.68,96.94 42.39,96.66 UH1.BB17
  IN1 w0.089: 85.73,39.63 85.73,39.65 85.72,39.66 85.72,39.91 85.98,40.18 86.55,40.18 v1(87.12,40.75)
  IN1 w0.117: v1(46.34,97.37) 46.43,97.27 46.43,96.69 46.87,96.25 49.64,96.25 50.06,95.82 50.06,95.55 53.38,92.23 53.43,92.23 54.99,90.66 54.99,88.66 59.93,83.72 61.43,83.72 64.21,80.94 64.21,55.21 69.93,49.49 69.93,38.88 71.28,37.52 83.85,37.52 85.73,39.4 85.73,39.63
DMI_CRX_PTX_P3: length 94.5
  TOP w0.102: UH1.BC18 42.45,97.16 42.92,97.16 43.12,97.37 43.44,97.37 43.53,97.28 43.89,97.28 v1(43.99,97.38) ; JCPU1.A20 87.59,40.22 v1(87.12,39.75)
  IN1 w0.117: v1(43.99,97.38) 44.15,97.22 44.15,96.97 45.95,95.16 48.83,95.16 53.23,90.76 53.76,90.76 54.08,90.44 54.08,88.64 59.81,82.91 61.07,82.91 63.55,80.43 63.55,54.81 69.17,49.19 69.17,38.58 70.88,36.86 84.43,36.86 86.97,39.39 86.97,39.6 v1(87.12,39.75)
DMI_CTX_PRX_N0: length 103.9
  TOP w0.102: UH1.AW22 40.72,98.64 v1(40.43,98.35) ; JCPU1.D18 89.59,43.22 v1(89.12,42.75)
  IN1 w0.089: 87.49,39.53 87.49,39.56 87.51,39.58 87.51,42.04 87.84,42.37 89.44,42.37 89.51,42.43 89.51,42.64 89.4,42.75 v1(89.12,42.75)
  IN1 w0.117: 87.49,39.53 87.49,39.31 84.62,36.43 70.57,36.43 68.64,38.36 68.64,48.96 63.12,54.47 63.12,80.1 60.82,82.41 59.7,82.41 53.5,88.61 53.5,88.91 53.18,89.23 53.18,90 48.46,94.71 45.8,94.71 43.47,97.05 43.47,98.16 42.6,99.03 40.95,99.03 40.67,98.75 40.67,98.59 v1(40.43,98.35)
DMI_CTX_PRX_N1: length 104.7
  TOP w0.102: JCPU1.C17 90.59,42.22 v1(90.12,41.75) ; v1(39.19,97.32) 38.93,97.57 UH1.AR20
  IN1 w0.089: 41.26,97.75 41.24,97.75 41.21,97.77 39.06,97.77 38.96,97.67 38.96,97.55 v1(39.19,97.32) ; 88.74,39.56 88.74,39.58 88.71,39.61 88.71,40.91 88.96,41.15 89.46,41.15 89.71,41.4 89.71,41.68 89.78,41.75 v1(90.12,41.75)
  IN1 w0.117: 88.74,39.56 88.74,39.28 84.99,35.54 70.07,35.54 67.64,37.96 67.64,48.68 62.23,54.09 62.23,79.65 60.36,81.51 59.33,81.51 52.53,88.31 52.53,88.58 52.27,88.84 52.27,89.47 47.93,93.81 45.25,93.81 43.07,96 43.07,96.18 42.27,96.97 42.27,97.52 42.05,97.75 41.26,97.75
DMI_CTX_PRX_N2: length 115
  TOP w0.102: JCPU1.B17 90.59,41.22 v1(90.12,40.75) ; UH1.AP17 38.34,96.73 v1(37.88,96.28)
  IN1 w0.089: v1(90.12,40.75) 90.12,40.75 89.95,40.57 89.95,40.43 90.05,40.32 90.45,40.32 90.72,40.04 90.72,39.63 90.75,39.61 90.75,39.59 ; v1(37.88,96.28) 38.06,96.1 38.06,95.98 38.37,95.67 41.23,95.67 41.5,95.4 41.5,95.37 41.52,95.35
  IN1 w0.117: 90.75,39.59 90.75,39.24 88.81,37.3 88.81,36.66 87.38,35.24 86.75,35.24 85.71,34.2 81.34,34.2 79.47,32.32 79.47,30.96 76.18,27.66 72.73,27.66 70.31,30.09 70.31,33.29 66.22,37.38 66.22,44.74 65.53,45.43 65.53,48.79 60.91,53.41 60.91,79.01 59.93,79.99 58.95,79.99 51.77,87.18 50.21,87.18 49.64,87.74 48.45,87.74 46.8,89.39 46.8,90.43 46.24,90.99 45.44,90.99 44.23,92.19 44.23,92.41 41.64,95 41.64,95.22 41.56,95.31 41.52,95.35
DMI_CTX_PRX_N3: length 109.5
  TOP w0.102: v1(40.43,97.32) 40.43,97.37 40.13,97.67 UH1.AV20 ; JCPU1.A17 90.59,40.22 v1(90.12,39.75)
  IN1 w0.089: v1(40.43,97.32) 40.58,97.17 40.58,96.92 40.79,96.72 41.67,96.72 42.42,95.97 42.42,95.68 42.4,95.66 42.4,95.65
  IN1 w0.117: 42.4,95.65 42.4,95.4 45.11,92.69 47.74,92.69 51.22,89.2 51.22,88.32 51.62,87.92 51.96,87.92 59.06,80.83 60.03,80.83 61.57,79.29 61.57,53.69 66.88,48.38 66.88,37.66 70.97,33.57 70.97,30.37 73.01,28.32 75.9,28.32 78.58,31 78.58,32.47 80.98,34.88 85.45,34.88 89.96,39.38 89.96,39.58 90.12,39.75 v1(90.12,39.75)
DMI_CTX_PRX_P0: length 103.8
  TOP w0.102: JCPU1.D17 90.59,43.22 v1(90.12,42.75) ; UH1.AY22 41.32,98.62 v1(41.06,98.35)
  IN1 w0.089: v1(90.12,42.75) 89.81,42.75 89.7,42.63 89.7,42.35 89.52,42.17 87.92,42.17 87.7,41.96 87.7,39.58 87.72,39.56 87.72,39.53
  IN1 w0.117: 87.72,39.53 87.72,39.21 84.71,36.2 70.47,36.2 68.4,38.27 68.4,48.86 62.89,54.37 62.89,80 60.72,82.17 59.6,82.17 53.26,88.51 53.26,88.81 52.94,89.14 52.94,89.9 48.37,94.48 45.7,94.48 43.23,96.95 43.23,98.06 42.5,98.79 41.04,98.79 40.9,98.65 40.9,98.51 v1(41.06,98.35)
DMI_CTX_PRX_P1: length 104.6
  TOP w0.102: v1(89.12,41.75) 89.59,42.22 JCPU1.C18 ; v1(38.59,97.32) 38.59,97.56 UH1.AP20
  IN1 w0.089: v1(89.12,41.75) 89.46,41.75 89.52,41.69 89.52,41.48 89.38,41.34 88.88,41.34 88.52,40.98 88.52,39.61 88.5,39.58 88.5,39.56 ; v1(38.59,97.32) 38.77,97.49 38.77,97.75 38.98,97.96 41.21,97.96 41.24,97.98 41.26,97.98
  IN1 w0.117: 41.26,97.98 42.14,97.98 42.51,97.62 42.51,97.07 43.3,96.28 43.3,96.1 45.35,94.05 48.03,94.05 52.51,89.57 52.51,88.94 52.76,88.68 52.76,88.41 59.42,81.75 60.46,81.75 62.47,79.74 62.47,54.19 67.88,48.78 67.88,38.06 70.16,35.77 84.9,35.77 88.5,39.38 88.5,39.56
DMI_CTX_PRX_P2: length 114.9
  TOP w0.102: JCPU1.B18 89.59,41.22 v1(89.12,40.75) ; UH1.AR17 38.93,96.61 v1(38.59,96.27)
  IN1 w0.089: v1(38.59,96.27) 38.34,96.27 38.25,96.17 38.25,96.06 38.45,95.86 41.31,95.86 41.64,95.53 41.67,95.53 41.68,95.52 ; v1(89.12,40.75) 89.66,40.75 89.76,40.65 89.76,40.35 89.97,40.13 90.37,40.13 90.53,39.96 90.53,39.62 90.51,39.6 90.51,39.59
  IN1 w0.117: 41.68,95.52 41.8,95.4 41.88,95.32 41.88,95.1 44.47,92.51 44.47,92.29 45.53,91.22 46.34,91.22 47.03,90.53 47.03,89.49 48.54,87.98 49.74,87.98 50.3,87.41 51.86,87.41 59.05,80.22 60.03,80.22 61.14,79.11 61.14,53.51 65.77,48.88 65.77,45.53 66.46,44.84 66.46,37.48 70.54,33.39 70.54,30.19 72.83,27.9 76.08,27.9 79.23,31.05 79.23,32.42 81.25,34.44 85.61,34.44 86.65,35.48 87.29,35.48 88.57,36.76 88.57,37.4 90.51,39.34 90.51,39.59
DMI_CTX_PRX_P3: length 109.4
  TOP w0.102: v1(89.12,39.75) 89.59,40.22 JCPU1.A18 ; UH1.AW20 40.72,97.76 41.13,97.36 v1(41.13,97.32)
  IN1 w0.089: v1(41.13,97.32) 40.93,97.32 40.77,97.16 40.77,97 40.86,96.91 41.75,96.91 42.62,96.05 42.62,95.69 42.64,95.67 42.64,95.65
  IN1 w0.117: v1(89.12,39.75) 89.63,39.75 89.72,39.66 89.72,39.48 85.35,35.11 80.88,35.11 78.34,32.57 78.34,31.1 75.8,28.56 73.11,28.56 71.2,30.47 71.2,33.67 67.12,37.76 67.12,48.47 61.8,53.79 61.8,79.39 60.13,81.06 59.15,81.06 52.06,88.16 51.72,88.16 51.46,88.42 51.46,89.3 47.84,92.92 45.21,92.92 42.64,95.5 42.64,95.65
DMI_RCOMP: length 2.7
  TOP w0.203: v1(41.07,96.28) 41.07,96.33 41.32,96.58 UH1.AY17
  BOTTOM w0.254: RH100.2 42.76,95.79 42.27,96.28 v2(41.79,96.28) v1(41.07,96.28)
DMIC0: length 98
  TOP w0.102: JEDP1.13 51.77,149.45 v2(52.17,149.85) 52.66,150.34 56.93,150.34 57.12,150.15 58.97,150.15 59.37,150.55 D22.3 58.53,151.17 v1(58.42,151.28) ; v1(15.3,92.42) 15.29,92.43 13.08,92.43 JIO1.64
  IN1 w0.109: v1(37.71,138.25) 37.31,137.84 36.84,137.84 33.77,134.77 33.77,125.73 25.87,117.83 25.87,113.37 25.64,113.14 24.02,113.14 23.72,112.85 21.83,112.85 17.31,108.34 17.31,103.8 16.7,103.19 16.7,99.81 17.13,99.39 17.13,98.5 17.67,97.96 17.67,94.79 v1(15.3,92.42)
  IN4 w0.109: v1(37.71,138.25) 37.71,138.34 39.28,139.9 40.51,139.9 41.52,140.92 43.13,140.92 44.57,142.36 45.58,142.36 49.81,146.58 51.66,146.58 55.11,150.03 56.78,150.03 58.02,151.28 v1(58.42,151.28)
DMIC_CLK: length 97.9
  TOP w0.102: JEDP1.11 50.86,150.45 51,150.32 52.31,150.32 52.57,150.57 56.46,150.57 57.06,151.17 D22.2 57.69,151.17 v1(58.43,151.9) ; v1(15.6,93.53) 15.01,92.94 13.99,92.94 13.93,93 JIO1.62
  IN1 w0.109: v1(15.6,93.53) 17.43,95.36 17.43,97.86 16.89,98.4 16.89,99.29 16.47,99.72 16.47,103.29 17.08,103.9 17.08,108.43 21.73,113.09 23.62,113.09 23.86,113.32 23.86,116.16 33.53,125.83 33.53,134.87 36.95,138.29 v1(37.07,138.29)
  IN4 w0.109: v1(58.43,151.9) 58.31,151.9 56.68,150.27 55.01,150.27 51.56,146.82 49.71,146.82 47.97,145.08 47.81,145.08 47.68,145.21 47.54,145.21 47.41,145.07 47.41,144.92 47.56,144.77 47.56,144.67 47.36,144.47 47.2,144.47 46.72,144.96 46.59,144.96 46.44,144.81 46.44,144.63 46.86,144.22 46.86,143.97 46.05,143.17 45.83,143.17 45.3,143.69 45.12,143.69 44.92,143.49 44.92,143.31 45.23,142.99 45.23,142.83 44.99,142.6 44.88,142.6 44.56,142.91 44.34,142.91 42.58,141.15 41.43,141.15 40.41,140.14 39.18,140.14 37.93,138.89 37.66,138.89 v1(37.07,138.29)
DMUX_CEXT: length 4.1
  TOP w0.089: 24.86,161.16 24.93,161.23
  TOP w0.102: U9.1 24.86,161.16 ; 24.93,161.23 25.12,161.23 v2(25.65,161.76) 26.08,162.19 26.08,162.96 26.63,163.51 C86.1
DOCK_AC_OFF: length 101.7
  TOP w0.102: v2(94.98,120.18) 95.72,120.91 v1(95.72,120.97)
  IN2 w0.254: v1(95.72,120.97) 96,120.69 98.59,120.69 99.65,119.62 99.65,116.88 101.94,114.59 119.01,114.59 121.45,117.03 128.34,117.03 131.51,113.85 146.57,113.85 147.58,112.85 152.19,112.85 152.62,113.28 153.95,113.28 v1(154.81,114.15)
  BOTTOM w0.254: v1(154.81,114.15) 154.83,114.15 155.16,113.82 155.16,111.48 154.19,110.5 154.19,108.7 154.59,108.29 PR1031.2 PD1010.1 ; JDOCK1.2 73.2,125.19 74.2,124.19 77.4,124.19 78.55,123.05 84.08,123.05 84.77,123.73 88.07,123.73 88.86,122.95 93.73,122.95 v1(95.72,120.97)
DOCK_AC_OFF_EC: length 106
  IN1 w0.254: v1(151.77,127.26) 152.05,127.26 156.19,123.12 156.19,117.91 157.03,117.08 157.03,115.4 159.32,113.11 159.32,110.68 172.33,97.66 174.7,97.66 180.06,92.3 180.06,88.38 185.47,82.97 197.65,82.97 203.56,77.05 208.03,77.05 208.24,77.25 210.33,77.25 210.49,77.1 212.18,77.1 213.29,75.98 218.73,75.98 218.86,76.11 222.44,76.11 222.56,75.98 223,75.98 224.11,77.09 v1(224.11,78.02)
  BOTTOM w0.102: v2(151.46,127.73) 151.77,127.42 v1(151.77,127.26)
  BOTTOM w0.254: v1(151.77,127.26) 151.77,127.24 151.8,127.21 PR1018.1 PR1020.2 ; U46.A63 v1(224.11,78.02)
DOCK_DCIN_IS+: length 40
  TOP w0.102: v1(104.92,129.47) 104.63,129.47 102.68,127.52 102.68,119.92 100.3,117.55 100.3,116.48 99.17,115.35 v2(96.66,115.35) PR715.1 85.63,115.17 85.63,112.56 85.25,112.18 PQ703.6
  BOTTOM w0.102: JDOCK1.134 108.2,127.9 106.98,129.12 105.3,129.12 104.95,129.47 v1(104.92,129.47)
DOCK_DCIN_IS-: length 36.2
  TOP w0.102: v1(105.53,129.53) 105.18,129.88 104.71,129.88 102.45,127.61 102.45,120.03 99.96,117.54 99.96,116.86 99.23,116.14 v2(94.52,116.14) 94.19,116.14 94.09,116.24 PR713.2
  BOTTOM w0.102: v1(105.53,129.53) 105.58,129.58 106.94,129.58 108.7,127.82 JDOCK1.136
DOCK_DET#: length 135.6
  TOP w0.102: D32.2 R755.2 106.18,126.06 v2(106.18,124.97) 106.18,122.29 108.19,120.28 108.19,117.87 v1(108.97,117.08)
  IN3 w0.127: v1(217.13,84.62) 216.44,83.93 215.12,83.93 214.79,84.26 212.58,84.26 211.87,84.97 190.59,84.97 187.55,88.01 187.55,88.7 183.38,92.87 179.61,92.87 178.02,94.46 173.52,94.46 159.53,108.46 150.17,108.46 144.67,113.96 112.1,113.96 v1(108.97,117.08)
  BOTTOM w0.102: U46.B41 216.92,85.63 216.72,85.43 216.72,85.02 v1(217.13,84.62)
DOCK_DET_R#: length 8.9
  TOP w0.102: D32.1 v2(108.11,125.12) v1(108.11,124.24)
  BOTTOM w0.102: JDOCK1.144 110.7,127.29 110.55,127.44 110.32,127.44 110.2,127.32 JDOCK1.142 110.2,124.68 109.43,123.91 108.44,123.91 v1(108.11,124.24)
DOCK_HP_DET: length 250.1
  TOP w0.102: v1(16.16,91.83) 16.09,91.91 14.11,91.91 14,91.8 JIO1.66
  IN2 w0.127: v1(16.16,91.83) 16.44,91.83 18.46,89.81 18.46,88.98 21.2,86.24 24.98,86.24 25.57,86.83 28.01,86.83 28.82,86.02 30.66,86.02 31.34,86.69 34.89,86.69 36.18,85.41 40.3,85.41 40.42,85.52 45.54,85.52 47.25,87.23 56.93,87.23 57.82,88.12 61.07,88.12 62.08,87.11 65.35,87.11 69.76,91.53 71.38,91.53 75.88,96.02 79.18,96.02 80.13,96.98 81.04,96.98 81.76,97.69 81.76,98.5 82.94,99.68 86.28,99.68 87.43,100.84 91.26,100.84 91.43,100.67 109.04,100.67 109.56,100.15 115.12,100.15 115.35,99.92 119.67,99.92 120.33,99.26 121.07,99.26 122.06,100.25 128.49,100.25 132.65,104.4 138.77,104.4 140.4,102.78 182.36,102.78 189.42,95.72 191.27,95.72 v1(191.42,95.87)
  BOTTOM w0.102: v1(191.42,95.87) 191.91,95.87 196.27,91.5 202.24,91.5 203.44,90.3 203.44,88.43 202.93,87.91 202.93,73.89 207.37,69.45 212.91,69.45 214.21,70.75 217.18,70.75 v2(217.65,71.22) 218.67,72.24 U46.A7
DOCK_LOM_ACTLED_YEL#: length 49
  TOP w0.102: v2(99.58,130.54) 99.55,130.52 v1(99.55,129.74)
  IN4 w0.109: v1(99.55,129.74) 99.82,129.47 103.82,129.47 104.54,130.19 108.33,130.19 111.04,132.9 115.48,132.9 119.82,137.25 119.82,138.09 120.76,139.02 122.51,139.02 123.17,139.69 123.17,141.31 124.09,142.23 132.07,142.23 132.56,141.73 133.17,141.73 133.77,141.14 v1(133.77,139.05)
  BOTTOM w0.102: v1(99.55,129.74) 99.7,129.59 99.7,128.98 99.55,128.83 99.55,127.34 99.7,127.19 JDOCK1.100 ; v1(133.77,139.05) 133.56,138.84 U32.19
DOCK_LOM_SPD10LED_GRN#: length 65.9
  TOP w0.102: v1(122.94,138.31) v2(122.94,139)
  IN4 w0.109: v1(73.21,117.03) 73.87,117.68 82.96,117.68 85.42,115.23 87.6,115.23 88.74,116.37 89.71,116.37 97.33,123.99 98.61,123.99 99.48,124.85 99.48,128.48 99.99,129 108.24,129 111.62,132.37 115.99,132.37 119.82,136.21 120.84,136.21 v1(122.94,138.31)
  BOTTOM w0.102: U32.40 122.97,138.34 v1(122.94,138.31) ; v1(73.21,117.03) 73.7,117.52 JDOCK1.3
DOCK_LOM_SPD100LED_ORG#: length 78.6
  TOP w0.102: v2(133.17,138.34) 133.18,138.34 v1(133.82,138.34)
  IN4 w0.109: v1(133.82,138.34) 133.33,138.83 133.33,141.23 133.07,141.5 132.46,141.5 131.97,141.99 124.19,141.99 123.41,141.21 123.41,139.59 122.59,138.77 120.86,138.77 120.1,138.01 120.1,137.19 115.53,132.62 111.47,132.62 108.8,129.96 104.64,129.96 103.92,129.23 99.89,129.23 99.24,128.58 99.24,124.95 98.51,124.22 96.64,124.22 96.1,123.68 94.83,123.68 v1(94.32,123.18)
  BOTTOM w0.102: JDOCK1.4 73.7,125.12 74.3,124.52 77.5,124.52 78.67,123.35 83.78,123.35 84.57,124.14 88.1,124.14 88.35,123.89 93.61,123.89 v1(94.32,123.18) ; U32.20 v1(133.82,138.34)
DOCK_LOM_TRD0+: length 43
  IN4 w0.102: v1(100.24,127.57) 100.36,127.7 100.54,127.7 100.69,127.54 100.69,127.09 104.31,123.48 109.45,123.48 110.56,124.59 110.56,125.07 113.22,127.72 123.12,127.72 127.89,132.5 129.57,132.5 132.37,135.3 132.37,135.78 v1(132.52,135.93)
  BOTTOM w0.089: U32.22 132.43,136.38 132.36,136.31 132.36,136.09 v1(132.52,135.93) ; JDOCK1.104 100.7,127.24 100.77,127.31 100.77,127.52 100.58,127.71 100.38,127.71 v1(100.24,127.57)
DOCK_LOM_TRD0-: length 43
  IN4 w0.102: v1(131.88,135.93) 132.01,135.8 132.01,135.44 129.42,132.85 127.75,132.85 122.97,128.08 113.07,128.08 110.21,125.22 110.21,124.74 109.31,123.84 104.45,123.84 101.05,127.24 101.05,127.69 100.69,128.05 100.39,128.05 v1(100.24,128.2)
  BOTTOM w0.089: U32.23 131.93,136.36 132.01,136.28 132.01,136.06 v1(131.88,135.93) ; JDOCK1.106 101.2,127.19 101.11,127.28 101.11,127.66 100.72,128.05 100.39,128.05 v1(100.24,128.2)
DOCK_LOM_TRD1+: length 37.3
  IN4 w0.102: v1(130.52,135.93) 130.39,135.79 130.39,135.3 128.71,133.61 127.49,133.61 122.76,128.89 112.86,128.89 109.38,125.41 104.41,125.41 102.17,127.65 101.86,127.65 v1(101.76,127.54)
  BOTTOM w0.089: JDOCK1.110 102.2,127.22 102.28,127.3 102.28,127.53 102.14,127.67 101.89,127.67 v1(101.76,127.54) ; v1(130.52,135.93) 130.37,136.08 130.37,136.28 130.43,136.35 U32.26
DOCK_LOM_TRD1-: length 37.3
  IN4 w0.102: v1(101.76,128.13) 101.89,128 102.32,128 104.56,125.77 109.23,125.77 112.71,129.25 122.61,129.25 127.34,133.97 128.56,133.97 130.03,135.44 130.03,135.78 v1(129.88,135.93)
  BOTTOM w0.089: v1(101.76,128.13) 101.88,128.01 102.28,128.01 102.62,127.67 102.62,127.26 102.7,127.19 JDOCK1.112 ; v1(129.88,135.93) 130.02,136.07 130.02,136.26 129.93,136.36 U32.27
DOCK_LOM_TRD2+: length 31.3
  IN4 w0.102: v1(104.76,127.54) 104.88,127.66 105.08,127.66 105.19,127.54 105.19,127.09 105.8,126.48 108.9,126.48 112.4,129.98 122.33,129.98 127.06,134.71 127.42,134.71 127.88,135.18 127.88,135.83 v1(127.98,135.93)
  BOTTOM w0.089: v1(127.98,135.93) 127.83,136.08 127.83,136.2 127.93,136.31 U32.31 ; JDOCK1.122 105.2,127.22 105.28,127.3 105.28,127.53 105.14,127.67 104.89,127.67 v1(104.76,127.54)
DOCK_LOM_TRD2-: length 31.3
  IN4 w0.102: v1(104.76,128.13) 104.88,128.01 105.22,128.01 105.55,127.69 105.55,127.24 105.95,126.83 108.75,126.83 112.26,130.34 122.18,130.34 126.91,135.07 127.27,135.07 127.54,135.34 127.54,135.73 v1(127.34,135.93)
  BOTTOM w0.089: JDOCK1.124 105.7,127.19 105.62,127.26 105.62,127.67 105.28,128.01 104.88,128.01 v1(104.76,128.13) ; U32.32 127.43,136.33 127.48,136.28 127.48,136.07 v1(127.34,135.93)
DOCK_LOM_TRD3+: length 26.4
  IN4 w0.102: v1(126.02,135.93) 125.87,135.77 125.87,135.45 121.54,131.13 112.02,131.13 108.71,127.81 106.37,127.81 v1(106.26,127.7)
  BOTTOM w0.089: JDOCK1.128 106.7,127.22 106.78,127.3 106.78,127.68 106.64,127.82 106.39,127.82 v1(106.26,127.7) ; v1(126.02,135.93) 125.87,136.08 125.87,136.24 125.93,136.31 U32.35
DOCK_LOM_TRD3-: length 26.4
  IN4 w0.102: v1(125.38,135.93) 125.51,135.8 125.51,135.6 121.4,131.48 111.88,131.48 108.56,128.16 106.38,128.16 v1(106.26,128.28)
  BOTTOM w0.089: JDOCK1.130 107.2,127.19 107.2,127.21 107.12,127.29 107.12,127.82 106.78,128.17 106.38,128.17 v1(106.26,128.28) ; v1(125.38,135.93) 125.52,136.07 125.52,136.24 125.43,136.33 U32.36
DOCK_MIC_DET: length 241.3
  TOP w0.102: v1(14.72,90.84) 14.36,91.2 JIO1.68
  IN2 w0.127: v1(14.72,90.84) 14.72,90.13 15.91,88.94 15.91,88.61 15.96,88.56 15.96,86.53 19.37,83.12 21.52,83.12 21.8,83.4 21.8,83.93 23.12,85.25 35.17,85.25 35.79,84.63 40.76,84.63 40.88,84.75 46.47,84.75 46.78,85.06 50.65,85.06 51.89,86.31 58.3,86.31 59.26,87.27 60.7,87.27 61.99,85.98 65.51,85.98 70.27,90.74 71.73,90.74 75.67,94.68 79.46,94.68 80.81,96.02 81.72,96.02 84.4,98.7 87.1,98.7 87.76,99.36 114.12,99.36 114.34,99.15 118.88,99.15 119.68,98.35 120.17,98.35 120.92,97.6 123.43,97.6 124.21,98.38 128.17,98.38 133.3,103.52 138.21,103.52 140.55,101.18 178.59,101.18 184.66,95.11 198.92,95.11 200.39,93.64 200.39,92.49 201.61,91.27 201.61,83.68 204.81,80.48 204.81,79.72 v1(204.78,79.69)
  IN3 w0.127: v1(204.78,79.69) 205.14,79.33 208.84,79.33 211.25,76.92 217.08,76.92 217.43,77.28 217.43,77.51 v1(217.92,78)
  BOTTOM w0.102: U46.B8 218.42,77.5 v1(217.92,78) ; v1(14.72,90.84) 14.7,90.84 v2(14.19,91.35)
DOCK_POR_RST#: length 38.3
  TOP w0.102: v1(107.65,129.45) 108.05,129.84 v2(108.05,129.98)
  IN1 w0.109: v1(107.65,129.45) 106.1,131 106.1,134.35 104.91,135.55 104.91,136.4 104.01,137.3 104.01,140.41 103.26,141.16 103.26,144.7 105.24,146.68 105.24,147.79 106.05,148.6 106.05,149.41 v1(105.95,149.52)
  IN3 w0.127: v1(105.95,149.52) 106.4,149.07 107.42,149.07 107.88,149.53 107.88,149.57 108.57,150.26 v1(108.57,150.28)
  BOTTOM w0.102: v1(108.57,150.28) 110,150.28 111.53,148.75 RP7.7 ; U51.A21 105.5,149.28 C737.1 105.95,148.96 v1(105.95,149.52) ; JDOCK1.140 109.7,127.4 v1(107.65,129.45)
DOCK_PSID: length 161
  TOP w0.102: PU1.1 5.11,87.63 v2(4.91,87.83) 4.59,88.15 v1(4.45,88.15)
  IN1 w0.109: v1(116.82,93.46) 116.55,93.46 115.45,94.55 115.45,96.1 114.69,96.86 114.69,100.32 114.86,100.48 114.86,105.74 113.06,107.53 113.06,110.17 110.88,112.35 110.88,117.28 107.98,120.18 v1(107.68,120.18)
  IN2 w0.127: v1(116.82,93.46) 116.79,93.5 113.14,93.5 112.84,93.79 95.03,93.79 93.66,92.42 93.66,92.21 89.89,88.44 88.08,88.44 82.86,83.22 70.1,83.22 67.89,81.01 58.33,81.01 56.93,79.61 52.38,79.61 51.83,79.07 47.31,79.07 47.09,78.85 39.59,78.85 38.98,78.24 34.42,78.24 33.58,79.08 29.59,79.08 29.36,78.85 25.86,78.85 25.23,78.22 19.66,78.22 19.03,77.58 13.11,77.58 6.58,84.11 6.3,84.11 5.85,84.56 5.85,85.17 4.99,86.03 4.99,87.67 4.5,88.15 v1(4.45,88.15)
  BOTTOM w0.102: v1(107.68,120.18) 108.7,119.16 JDOCK1.135
DOCK_PWR_BTN#: length 67.5
  TOP w0.102: v1(113.95,159.5) 114.99,160.54 114.99,165.77 112.51,168.26 v2(109.66,168.26) 107.27,168.26 106.46,167.45 R825.2
  IN2 w0.127: v1(113.95,159.5) 114.46,158.99 114.46,152.42 114.75,152.13 115.22,152.13 116.2,151.15 116.2,149.76 116.02,149.58 116.02,148.46 119.62,144.87 119.62,135.9 116.37,132.65 116.37,130.85 108.87,123.35 108.87,121.7 110.19,120.38 v1(110.47,120.38)
  BOTTOM w0.102: v1(110.47,120.38) 109.7,119.61 JDOCK1.139
DOCK_PWR_SW#: length 77.3
  TOP w0.102: U10.1 166.29,138.83 165.88,138.43 162.41,138.43 161.86,138.97 156.73,138.97 156.6,138.85 v2(156.36,138.85) v1(155.67,138.85) ; v1(107.27,162.7) 107.35,162.77 C734.1 106.46,164.3 R819.2 R825.1
  IN3 w0.127: v1(107.27,162.7) 110.74,162.7 112.61,160.83 116.76,160.83 118.11,162.18 124.09,162.18 125.13,161.13 127.86,161.13 128.19,160.81 130.65,160.81 133.97,157.49 138.82,157.49 142.48,153.83 143.74,153.83 147.96,149.62 149.44,149.62 150.86,148.2 150.86,147.19 152.82,145.23 152.82,142.5 155.67,139.64 v1(155.67,138.85)
  BOTTOM w0.102: v1(107.27,162.7) 107.27,162.67 107,162.4 U51.A63
DOCK_SMB_ALERT#: length 325.1
  TOP w0.102: v1(224.12,84.02) 223.66,83.56 223.66,82.36 225.64,80.38 225.64,79.79 225.66,79.79 227.44,78.01 227.44,77.18 229.85,74.76 235.9,74.76 237.6,73.06 241.78,73.06 243.98,70.86 243.98,66.02 244.86,65.14 247,65.14 247.25,65.39 260.38,65.39 v1(262.8,62.98)
  IN3 w0.127: v1(185.4,28.56) 185.84,28.99 186.52,28.99 186.92,28.6 186.92,27.1 190.06,23.96 195.74,23.96 199.16,27.38 228.23,27.38 237.77,36.92 248.06,36.92 252.15,41.01 264.18,41.01 269.5,46.33 269.5,61.76 267.93,63.33 263.15,63.33 v1(262.8,62.98) ; v1(108.31,117.03) 108.42,117.03 111.74,113.7 144.57,113.7 150.07,108.2 155.62,108.2 156.26,107.57 159.81,107.57 173.17,94.21 177.82,94.21 179.41,92.62 183.27,92.62 187.3,88.6 187.3,87.91 190.49,84.72 211.76,84.72 213.21,83.27 215.2,83.27 216.16,82.31 222.4,82.31 v1(224.12,84.02)
  BOTTOM w0.102: U46.A51 v1(224.12,84.02) 224.12,84.12 224.77,84.78 224.77,84.9 R763.2 ; PQ1.3 173.15,33.16 174.91,31.41 174.91,30.11 175.42,29.6 177.04,29.6 177.55,29.09 177.55,27.88 178.31,27.12 v2(182.18,27.12) 183.07,27.12 184.51,28.56 v1(185.4,28.56) ; JDOCK1.133 108.2,117.14 v1(108.31,117.03)
DOCK_SMB_CLK: length 77.3
  TOP w0.102: v1(106.9,159.51) 107.48,158.94 108.54,158.94 109.28,159.68 109.28,160.56 110.23,161.5 110.88,161.5 R841.2
  IN1 w0.109: v1(106.9,159.51) 107.4,159.01 109.58,159.01 109.76,158.84 111.36,158.84 111.51,158.69 111.51,155.78 112.48,154.81 112.48,151.64 110.73,149.88 110.73,148.78 109.53,147.58 109.53,146.36 109.05,145.88 109.05,143.35 106.86,141.15 106.86,139.59 107.48,138.97 107.48,135.95 117.93,125.5 117.93,115.71 v1(117.74,115.52)
  BOTTOM w0.102: v1(106.9,159.51) 107.39,159.02 U51.B4 ; v1(117.74,115.52) 117.92,115.69 117.92,115.91 117.5,116.32 116.61,116.32 116.08,115.78 107.81,115.78 106.84,116.76 106.84,117.27 106.7,117.41 JDOCK1.127
DOCK_SMB_DAT: length 70.9
  TOP w0.102: v1(109.91,159.27) 109.51,159.68 109.51,160.46 110.32,161.28 110.88,161.28 R838.2
  IN1 w0.109: v1(118.32,115.52) 118.16,115.68 118.16,125.6 107.71,136.05 107.71,139.07 107.1,139.69 107.1,141.06 109.29,143.25 109.29,145.78 109.76,146.26 109.76,147.48 110.96,148.68 110.96,149.79 112.72,151.54 112.72,154.91 111.75,155.88 111.75,158.78 111.46,159.07 110.11,159.07 v1(109.91,159.27)
  BOTTOM w0.102: v1(109.91,159.27) U51.A3 ; v1(118.32,115.52) 118.14,115.69 118.14,116 117.6,116.55 116.52,116.55 115.99,116.01 107.91,116.01 107.07,116.85 107.07,117.25 107.2,117.38 JDOCK1.129
DOCKED: length 285.5
  TOP w0.102: v1(130.43,141.21) 130.56,141.34 130.56,147.52 129.14,148.94 129.14,152.32 129.66,152.84 129.66,153.44 131.15,154.93 135.12,154.93 142.6,162.41 v2(142.6,162.81) 142.6,163.04 v1(143.14,163.57)
  IN2 w0.127: v1(143.14,163.57) 142.7,163.57 136.19,170.08 121.94,170.08 119.97,168.11 117.86,168.11 114.25,171.73 97.5,171.73 93.93,168.16 88.84,168.16 88.08,168.92 69.92,168.92 67.48,166.48 65.19,166.48 59.47,160.77 54.5,160.77 51.48,157.74 48.19,157.74 46.26,155.81 43.28,155.81 40.06,152.6 40.06,149.03 38.31,147.28 27.39,147.28 26.79,147.88 26.79,151.05 v1(26.63,151.22)
  IN3 w0.127: v1(130.43,141.21) 130.43,141.36 130.7,141.63 133.65,141.63 134.4,140.88 135.27,140.88 137.68,138.47 137.68,137.57 139.37,135.88 141.04,135.88 149.14,127.77 149.14,125.5 150.5,124.14 152.82,124.14 156.29,120.67 156.29,118.07 157.25,117.12 157.25,115.23 171.73,100.75 174.74,100.75 180.56,94.93 193.2,94.93 200.06,88.07 211.54,88.07 212.96,86.65 215.3,86.65 216.22,87.57 v1(216.26,87.57)
  BOTTOM w0.102: U46.A38 216.67,87.16 v1(216.26,87.57) ; U32.13 v1(130.43,141.21) ; v1(26.63,151.22) 26.65,151.22 26.72,151.28 Q326.2
