# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXM_MB_DP_N2: length 6.1
  TOP w0.102: JMXM1.295 58.25,105.78 58.13,105.89 58.13,107.21 59.8,108.88 v3(59.8,109.21) 59.8,109.89 C286.1
MXM_MB_DP_N2_C: length 193.8
  TOP w0.102: C286.2 59.79,111.42 59.79,111.61 v1(59.98,111.8)
  IN4 w0.117: v1(59.98,111.8) 59.8,111.97 59.8,112.13 61.65,113.98 64.91,113.98 67.74,111.15 70.86,111.15 71.25,111.54 73.56,111.54 73.84,111.82 77.94,111.82 78.04,111.72 82.84,111.72 83.24,111.31 88.96,111.31 89.37,111.72 126.27,111.72 127.54,110.45 157.69,110.45 157.95,110.2 164.81,110.2 167.02,107.99 177.3,107.99 187,98.28 194.52,98.28 199.32,93.49 199.32,93.08 201.13,91.27 207.25,91.27 209.74,88.78 229.06,88.78 230.16,87.68 233.91,87.68 234.61,86.98 235.86,86.98 236.13,87.24 236.13,87.57 v1(236.33,87.77)
  BOTTOM w0.102: U22.45 236.74,87.14 236.69,87.08 236.69,86.98 236.61,86.9 236.43,86.9 236.04,87.3 236.04,87.65 236.15,87.77 v1(236.33,87.77)
MXM_MB_DP_N3: length 5.9
  TOP w0.102: C282.1 58.02,109.89 v3(58.02,109.14) 58.02,108.47 56.63,107.08 56.63,105.9 56.75,105.78 JMXM1.301
MXM_MB_DP_N3_C: length 198.5
  TOP w0.102: C282.2 58.02,111.42 58.02,111.64 v1(58.17,111.8)
  IN4 w0.117: v5(236,89.52) 236,89.31 236.25,89.06 236.25,88.61 235.84,88.19 234.97,88.19 234.5,88.66 234.5,89.27 234.2,89.57 210.78,89.57 208.24,92.11 202.07,92.11 195,99.17 187.31,99.17 179.1,107.38 179.1,108.02 178.34,108.77 167.75,108.77 164.25,112.27 159.89,112.27 159.05,113.12 156.84,113.12 156.4,112.67 154.17,112.67 153.73,113.12 152.19,113.12 151.63,112.56 146.54,112.56 145.81,113.29 140.8,113.29 139.23,111.73 129.08,111.73 128.3,112.51 90.09,112.51 89.71,112.88 83.99,112.88 83.75,113.12 83.24,113.12 82.73,112.6 73.51,112.6 73.25,112.34 70.97,112.34 69.32,113.99 66.02,113.99 65.24,114.77 60.61,114.77 58.02,112.18 58.02,111.95 v1(58.17,111.8)
  BOTTOM w0.102: v5(236,89.52) 235.9,89.42 235.9,89.21 236.58,88.53 236.75,88.53 236.86,88.64 U22.48
MXM_MB_DP_P0: length 6.3
  TOP w0.102: JMXM1.285 60.75,105.76 60.87,105.88 60.87,107.37 v3(62.11,108.62) 63.09,109.6 63.09,109.88 C285.1
MXM_MB_DP_P0_C: length 191.3
  TOP w0.102: v1(62.9,111.8) 63.08,111.61 63.08,111.42 C285.2
  IN4 w0.117: v1(235.52,84.06) 235.67,83.91 235.67,83.65 235.53,83.51 234.44,83.51 233.1,84.85 228.89,84.85 227.14,86.6 223.44,86.6 222.95,86.12 211.12,86.12 210.29,86.96 202.54,86.96 197.44,92.06 197.44,92.69 194.72,95.41 188.03,95.41 182.46,100.99 181.97,100.99 177.21,105.76 165.94,105.76 164.16,107.53 158.72,107.53 158.05,108.19 127.18,108.19 126.61,108.77 119.36,108.77 118.94,109.18 117.42,109.18 117.08,108.85 83.86,108.85 82.31,110.4 77.37,110.4 77.24,110.53 74.86,110.53 74,109.68 67.17,109.68 64.16,112.69 63.48,112.69 63.07,112.27 63.07,111.97 v1(62.9,111.8)
  BOTTOM w0.102: U22.38 236.9,83.64 236.47,83.21 235.79,83.21 235.52,83.48 v1(235.52,84.06)
MXM_MB_DP_P1: length 6.2
  TOP w0.102: C280.1 61.31,109.88 61.31,109.43 59.37,107.49 v3(59.37,106.88) 59.37,105.85 59.25,105.74 JMXM1.291
MXM_MB_DP_P1_C: length 193.3
  TOP w0.102: v1(61.15,111.8) 61.31,111.64 61.31,111.42 C280.2
  IN4 w0.117: v1(61.15,111.8) 61.29,111.94 61.29,112.29 62.48,113.48 64.64,113.48 67.66,110.46 73.68,110.46 74.53,111.32 77.62,111.32 77.74,111.2 82.64,111.2 83.08,110.76 89.47,110.76 89.91,111.2 125.77,111.2 127.51,109.46 164.01,109.46 165.99,107.48 177.09,107.48 186.92,97.65 189.92,97.65 190.63,96.94 194.36,96.94 198.56,92.75 198.56,92.06 201.15,89.47 203.28,89.47 204.91,87.85 210.79,87.85 211.66,86.99 222.49,86.99 222.92,87.42 227.74,87.42 229.25,85.91 231.93,85.91 232.5,86.48 233.92,86.48 234.69,85.71 235.52,85.71 235.64,85.83 235.64,86.05 v1(235.47,86.22)
  BOTTOM w0.102: v1(235.47,86.22) 235.47,85.63 235.96,85.14 U22.41
MXM_MB_DP_P2: length 6.1
  TOP w0.102: C281.1 59.53,109.88 59.53,108.99 57.87,107.32 v3(57.87,106.89) 57.87,105.87 57.75,105.76 JMXM1.297
MXM_MB_DP_P2_C: length 193.9
  TOP w0.102: v1(59.34,111.8) 59.53,111.61 59.53,111.42 C281.2
  IN4 w0.117: v1(235.64,87.77) 235.85,87.56 235.85,87.36 235.75,87.26 234.73,87.26 234.02,87.96 230.28,87.96 229.18,89.07 209.86,89.07 207.37,91.56 201.24,91.56 199.6,93.2 199.6,93.61 194.64,98.57 187.12,98.57 177.42,108.27 167.14,108.27 164.93,110.48 158.06,110.48 157.81,110.73 127.66,110.73 126.39,112 89.25,112 88.84,111.6 83.36,111.6 82.96,112 78.16,112 78.06,112.1 73.72,112.1 73.44,111.82 71.14,111.82 70.75,111.43 67.86,111.43 65.02,114.26 61.54,114.26 59.52,112.24 59.52,111.97 v1(59.34,111.8)
  BOTTOM w0.102: U22.44 236.32,86.64 235.77,87.19 235.77,87.64 v1(235.64,87.77)
MXM_MB_DP_P3: length 6
  TOP w0.102: C279.1 57.76,109.88 57.76,108.58 56.37,107.19 v3(56.37,106.82) 56.37,105.88 56.25,105.76 JMXM1.303
MXM_MB_DP_P3_C: length 198.4
  TOP w0.102: v1(57.59,111.8) 57.75,111.64 57.75,111.42 C279.2
  IN4 w0.117: v1(57.59,111.8) 57.74,111.94 57.74,112.29 60.5,115.05 65.35,115.05 66.13,114.27 69.44,114.27 71.09,112.62 73.13,112.62 73.4,112.88 82.61,112.88 83.13,113.4 83.87,113.4 84.1,113.17 89.83,113.17 90.2,112.79 128.41,112.79 129.19,112.01 139.12,112.01 140.68,113.58 145.92,113.58 146.66,112.84 151.51,112.84 152.07,113.4 153.85,113.4 154.29,112.96 156.28,112.96 156.72,113.4 159.17,113.4 160.01,112.56 164.37,112.56 167.87,109.06 178.46,109.06 179.38,108.14 179.38,107.5 187.43,99.46 195.12,99.46 202.18,92.4 208.36,92.4 210.9,89.86 234.31,89.86 234.79,89.38 234.79,88.78 235.09,88.48 235.72,88.48 235.97,88.73 235.97,88.94 235.77,89.14 235.59,89.14 v1(235.52,89.06)
  BOTTOM w0.102: U22.47 236.87,88.14 236.75,88.26 236.47,88.26 235.67,89.06 v1(235.52,89.06)
MXM_OVERT#: length 42.8
  TOP w0.102: v1(86.88,97.93) 89.39,100.44 109.53,100.44 110.88,99.1 118.53,99.1 119.5,98.12 JMXM1.56
  BOTTOM w0.102: R10.2 85.07,101.36 85.07,100.3 v2(85.71,99.66) 86.88,98.49 v1(86.88,97.93) 87.9,98.95 Q4.3
MXM_PANEL_BKEN: length 106.8
  TOP w0.102: v1(115.07,116.44) v2(117.34,114.18) 117.52,113.99 117.52,107.32 117.28,107.08 117.28,106.49 117.69,106.08 117.95,106.08 118.25,105.78 JMXM1.61
  IN3 w0.127: v1(46.59,140.04) 47.62,140.04 48.45,140.87 49.45,140.87 54.26,145.68 55.74,145.68 59.98,149.92 77.36,149.92 78.85,148.44 87,148.44 90.86,144.57 90.86,139.18 97.81,132.23 98.39,132.23 101.33,129.29 101.33,126.3 104.1,123.53 104.1,122.57 107.53,119.14 108.7,119.14 112.18,115.66 114.46,115.66 115.07,116.27 v1(115.07,116.44)
  BOTTOM w0.102: D64.2 46.42,139.87 v1(46.59,140.04)
MXM_PRESENTL#: length 69.1
  TOP w0.102: UH1.G15 27.16,95.8 v1(26.78,95.42) ; JMXM1.310 54.25,105.65 53.74,106.16 v1(53.16,106.16)
  IN1 w0.109: v1(53.16,106.16) 52.56,106.16 51.32,107.4 51.32,109.4 50.25,110.48 48.89,110.48 48.44,110.03 43.68,110.03 42.71,111 35.76,111 34.45,109.69 29.96,109.69 28.84,108.57 28.84,107.68 28.13,106.97 28.13,106.77 27.62,106.26 27.62,105.67 27.21,105.27 26.6,105.27 25.85,104.52 25.6,104.52 25.35,104.26 25.35,103.43 26.53,102.25 27.57,102.25 27.92,101.89 27.92,101.67 28.62,100.98 28.62,100.73 27.9,100.01 27.9,99.6 27.49,99.2 27.01,99.2 25.42,97.61 25.42,96.92 26.78,95.57 v1(26.78,95.42)
  IN3 w0.127: v1(26.78,95.42) 24.93,95.42 23.61,94.09 15.5,94.09 14.61,94.98 11.95,94.98 v1(11.68,94.71)
  BOTTOM w0.102: v1(11.68,94.71) 11.68,94.61 12.05,94.24 13.03,94.24 13.34,94.56 RPH8.8
MXM_PRESENTR#: length 131
  TOP w0.102: v1(27.36,94.35) 27.16,94.55 UH1.G13 ; JMXM1.38 v1(124,103.44)
  IN2 w0.127: v1(124,103.44) 123.52,102.96 121.93,102.96 120.68,104.2 115.25,104.2 115.03,104.42 81.57,104.42 80.95,103.8 80.3,103.8 78.72,102.22 76.85,102.22 76.18,101.55 72.79,101.55 69.45,98.21 69.26,98.21 67.75,96.71 66.66,96.71 62.8,92.85 49.45,92.85 45.08,88.48 43.05,88.48 42.81,88.24 38.58,88.24 37.05,89.77 31.77,89.77 31.2,90.34 29.08,90.34 27.77,91.65 27.77,92.19 27.17,92.79 27.17,94.15 v1(27.36,94.35)
  BOTTOM w0.102: RPH9.7 14.58,97.83 15.85,96.56 17.01,96.56 17.55,96.02 18.96,96.02 20.54,94.45 24,94.45 v2(24.26,94.71) 24.41,94.85 26.44,94.85 26.57,94.73 26.98,94.73 v1(27.36,94.35)
MXM_PWR_LEVEL: length 10.1
  TOP w0.102: JMXM1.54 v1(120,97.93)
  BOTTOM w0.102: v2(124.49,102.63) 123.8,101.93 123.8,101.67 123.37,101.24 U17.4 123.92,100.61 R37.2 123.96,99.76 123.17,99.76 121.34,97.93 v1(120,97.93)
MXM_RSVD1: length 4.8
  TOP w0.102: JMXM1.268 64.5,97.79 64.76,98.05 64.76,98.94 v1(64.47,99.23)
  BOTTOM w0.102: v1(64.47,99.23) 64.81,98.9 v2(64.81,98.32) 64.81,97.33 R6.2
MXM_RSVD2: length 4.7
  TOP w0.102: v1(64.34,98.66) 64,98.32 JMXM1.270
  BOTTOM w0.102: v2(62.8,97.13) 62.94,97.27 R1979.2 63.79,97.54 64.34,98.09 v1(64.34,98.66)
MXM_SRC_EN#: length 5.7
  TOP w0.102: C774.1 149.21,109.7 v2(148.54,110.37)
  TOP w0.508: C774.1 150.17,109.7 150.54,109.33 R944.1 R940.2 149.41,108.93 Q186.4
NB_LAN_TX0+: length 9.8
  TOP w0.229: T156.24 156.82,155.6 157.23,156.02 157.23,156.75 162.18,161.7 JLOM1.1
NB_LAN_TX0-: length 9.8
  TOP w0.229: JLOM1.2 162.97,161.45 162.42,161.45 157.58,156.61 157.58,156.03 158.09,155.52 T156.23
NB_LAN_TX1+: length 9.5
  TOP w0.229: T156.20 161.9,155.8 162.36,156.27 162.36,156.61 v1(162.21,156.75)
  IN1 w0.178: v1(162.21,156.75) 162.37,156.91 162.37,157.72 164.05,159.4 164.58,159.4 164.84,159.65 164.84,159.94 164.22,160.56 JLOM1.3
NB_LAN_TX1-: length 9.5
  TOP w0.229: v1(162.85,156.75) 162.7,156.61 162.7,156.27 163.17,155.8 T156.19
  IN1 w0.178: v1(162.85,156.75) 162.69,156.91 162.69,157.59 164.18,159.08 164.71,159.08 165.16,159.52 165.16,159.9 166.48,161.22 JLOM1.6
NB_LAN_TX2+: length 8.2
  TOP w0.229: T156.18 164.44,155.75 164.92,156.24 164.92,159.34 166.05,160.47 166.05,161.2 165.72,161.53 165.55,161.53 JLOM1.4
NB_LAN_TX2-: length 8.3
  TOP w0.229: JLOM1.5 166.39,162.19 166.39,160.32 165.27,159.2 165.27,156.24 165.71,155.8 T156.17
NB_LAN_TX3+: length 8.8
  TOP w0.229: JLOM1.7 168.19,162.21 168.19,160.42 169,159.61 169.56,159.61 169.9,159.28 169.9,155.95 169.52,155.57 T156.14
NB_LAN_TX3-: length 8.8
  TOP w0.229: T156.13 170.79,155.42 170.24,155.97 170.24,159.42 169.71,159.95 169.15,159.95 168.54,160.56 168.54,161.2 168.82,161.48 169.06,161.48 JLOM1.8
NB_PSID: length 11.7
  TOP w0.102: v1(4.86,73.43) PL3.2
  BOTTOM w0.102: v2(14.77,74.94) 14.13,74.3 PJPDC1.2 5.73,74.3 v1(4.86,73.43)
NB_PSID_TS5A63157: length 5.7
  TOP w0.102: PR8.1 1.81,87.78 3.08,89.05 v2(3.08,89.08) ; PR8.1 1.79,87.51 PR9.2 ; PR8.1 2.32,87.03 3.59,87.03 3.81,86.81 PU1.3
NTC: length 50.9
  TOP w0.102: v1(54.14,22.77) PR528.1 53.53,22.69 PU500.6 ; PH500.1 41.44,56.55 40.06,55.18 40.06,51.06 42.2,48.93 42.2,44.56 40.72,43.09 v2(40.72,42.43) 40.72,41.82 v1(40.14,41.23)
  IN4 w0.102: v1(40.14,41.23) 40.14,39.89 41.37,38.66 41.37,34.8 43.04,33.13 43.04,29.13 44.36,27.81 46.35,27.81 47.33,26.83 47.33,23.1 48.88,21.55 52.92,21.55 v1(54.14,22.77)
NUM_LED: length 85.2
  TOP w0.102: JIO1.92 v1(14.31,84)
  IN2 w0.127: v1(8.92,151.22) 8.92,151.32 10.68,153.07 11.36,153.07 12.89,151.54 12.89,142.25 14.23,140.9 14.23,139.16 13.62,138.55 13.62,135.04 11.82,133.23 11.82,126.6 14.66,123.76 14.66,119.12 16.09,117.69 16.09,116.8 15.32,116.03 15.07,116.03 13.53,114.48 12.67,114.48 11.49,113.3 11.49,112.17 9.15,109.84 9.15,106.23 10.31,105.07 10.31,104.42 10.75,103.98 10.75,95.79 11.14,95.41 11.14,93.9 12.12,92.91 12.12,91.87 13.27,90.73 13.27,85.04 v1(14.31,84)
  BOTTOM w0.102: v2(8.67,149.88) 8.67,150.19 8.29,150.57 R942.2 8.75,151.04 v1(8.92,151.22)
NUM_LED#: length 294.1
  IN1 w0.109: v1(38.06,165.71) 37.28,166.48 28.08,166.48 26.21,164.61 19.12,164.61 15.18,160.67 15.18,155.63 13.86,154.31 v1(13.86,150.73)
  IN3 w0.127: v1(202.93,90) 202.78,89.85 199.72,89.85 197.8,91.77 197.8,92.68 196.99,93.48 196.09,93.48 193.62,95.95 192.7,95.95 191.79,96.86 185.55,96.86 184.66,95.97 180.98,95.97 175.19,101.76 172.21,101.76 159.08,114.9 159.08,116.72 157.3,118.5 157.3,121.17 152.51,125.96 151.31,125.96 150.16,127.11 150.16,129.43 135.92,143.67 133.05,143.67 132.05,142.67 118.27,142.67 117.44,143.5 101.21,143.5 98.05,146.66 97.55,146.66 96.65,147.56 93.6,147.56 92.67,148.49 89.1,148.49 87.63,149.96 79.48,149.96 77.94,151.5 61.69,151.5 59.2,153.99 52.05,153.99 50.35,152.29 50.35,150.05 48.78,148.47 46.99,148.47 44.83,150.63 43.14,150.63 41.36,152.41 41.36,163.37 39.44,165.29 38.48,165.29 v1(38.06,165.71)
  BOTTOM w0.102: v1(202.93,90) 203.06,89.88 203.06,88.36 202.7,88.01 202.7,73.77 207.25,69.23 213.51,69.23 v2(214.21,69.93) 214.8,70.52 219.25,70.52 220.55,71.82 221.19,71.82 221.24,71.86 221.44,71.86 221.73,72.15 221.73,74.91 221.17,75.47 U46.A2 ; Q84.3 v1(13.86,150.73)
NVRAM_PWR_EN: length 80.5
  TOP w0.102: v1(263.23,56.75) 260.31,59.68 258.66,59.68 253.63,64.7 247.54,64.7 247.28,64.45 244.56,64.45 240.14,68.87 227.46,68.87 227.18,68.59 218.75,68.59 216.01,71.33 213.65,71.33 211.08,73.9 211.08,76.9 209.76,78.22 209.76,80.38 210.52,81.14 214.82,81.14 215.4,81.72 215.4,82.92 214.59,83.73 v1(214.59,83.75)
  BOTTOM w0.102: U46.B32 214.25,84.27 214.56,83.96 214.56,83.78 v1(214.59,83.75) ; v1(263.23,56.75) 263.57,56.41 R720.1 263.88,56.08 264.17,55.79 264.91,55.79 265.34,56.22 U43.3
P1_SW: length 28.6
  TOP w0.102: v1(55.79,38.52) v2(55.79,39.41)
  TOP w0.254: v1(52.74,58.48) 52.72,58.48 52.74,58.46 PL502.2 ; v1(55.79,38.52) 55.41,38.14 PR553.1
  IN1 w0.254: v1(55.79,38.52) 55.91,38.64 55.91,39.38 57.31,40.77 57.31,48.84 56.38,49.77 56.38,56.06 55.55,56.88 55,56.88 53.4,58.48 v1(52.74,58.48)
  BOTTOM w0.254: v1(55.79,38.52) 55.79,38.2 PR553.1
P2_SW: length 15.4
  TOP w0.254: PL501.2 v1(52.74,47.66) ; PR539.1 53.12,38.14 v1(53.5,38.52)
  IN1 w0.254: v1(52.74,47.66) 52.96,47.66 53.22,47.41 54.39,47.41 54.77,47.03 54.77,40.45 53.63,39.31 53.63,38.64 v1(53.5,38.52)
  BOTTOM w0.254: PR539.1 53.5,38.2 v1(53.5,38.52)
  vias: v2(55.01,41.65)
P3_SW: length 41.3
  TOP w0.102: PC507.1 50.96,75.09 v2(51.3,75.44)
  TOP w0.254: PL500.2 52.74,69.63 v1(52.36,69.25) ; v1(58.07,38.52) 57.69,38.14 PR510.2
  IN1 w0.254: v1(58.07,38.52) 58.2,38.64 58.2,49.66 57.18,50.68 57.18,66.58 55.66,68.11 53,68.11 52.55,68.56 52.55,69.06 v1(52.36,69.25)
  BOTTOM w0.254: v1(58.07,38.52) 58.07,38.2 PR510.2
P33ALW: length 3.4
  BOTTOM w0.254: PU1001.18 148.32,122.28 147.56,123.05 v2(147.56,123.62) 147.25,123.92 PR1025.1
P33ALW2: length 3.1
  BOTTOM w0.254: PU1001.9 149.7,117 v2(148.76,116.06) 148.24,115.54 PR1022.2
P50ALW: length 3.9
  BOTTOM w0.254: PU1001.27 153.7,123.62 154.58,124.5 155.46,124.5 v2(155.58,124.62) 155.86,124.9 PR1012.1
PANEL_BKEN_EC: length 212.6
  IN3 w0.127: v1(215.17,87.46) 214.61,86.9 213.11,86.9 211.69,88.33 200.16,88.33 193.31,95.18 180.69,95.18 174.87,101 171.83,101 157.5,115.33 157.5,117.22 156.54,118.18 156.54,120.85 152.19,125.2 150.99,125.2 149.4,126.79 149.4,127.88 141.15,136.13 139.47,136.13 137.93,137.67 137.93,138.58 135.37,141.14 134.5,141.14 133.76,141.88 117.98,141.88 117.12,142.73 100.22,142.73 97.77,145.18 96.98,145.18 95.74,146.43 93.65,146.43 92.35,147.73 88.79,147.73 87.32,149.2 79.16,149.2 77.62,150.73 61.38,150.73 58.9,153.21 52.35,153.21 51.67,152.53 51.67,151.83 51.82,151.67 51.82,149.71 50.88,148.76 50.88,143.44 49.95,142.5 47.63,142.5 v1(46.82,141.69)
  BOTTOM w0.102: U46.A35 215.17,87.49 215.17,87.49 v1(215.17,87.46) ; D69.2 47.57,142.44 v1(46.82,141.69) 46.82,141.43 v2(47.38,140.87)
PANEL_BKEN_PCH: length 90
  TOP w0.102: v1(28.2,104.86) 28.2,104.44 28.36,104.29
  IN3 w0.127: v1(28.2,104.86) 28.2,104.86 28.71,105.37 28.71,106.36 29.07,106.72 29.57,106.72 29.98,106.31 30.95,106.31 31.38,106.74 32.57,106.74 32.8,106.97 33.54,106.97 33.77,106.74 34.86,106.74 35.24,106.36 35.24,103.06 35.54,102.75 35.87,102.75 36.15,103.03 38.11,103.03 38.39,103.31 39.56,103.31 40.62,104.38 45.98,104.38 49.1,107.5 52.65,107.5 53.65,108.51 53.65,114.84 56.78,117.97 56.78,129.57 55.26,131.09 49.52,131.09 48.11,132.5 38.4,132.5 36.18,134.72 v1(35.01,134.72)
  BOTTOM w0.102: v1(35.01,134.72) 36.64,136.35 37.6,136.35 v2(41.11,139.85) 41.4,140.15 D67.2
PBA_GPU_SEL#: length 244.3
  TOP w0.102: v1(43.62,147.41) 43.37,147.15 42.1,147.15 v2(41.34,146.39) 38.47,143.52 37.56,143.52 37.04,143 35.89,143 34.98,143.9 34.98,147.13 35.63,147.77 U629.54
  IN3 w0.127: v1(205.04,89.14) 204.63,89.55 199.66,89.55 197.54,91.67 197.54,92.57 196.89,93.23 195.98,93.23 193.52,95.69 192.6,95.69 191.68,96.61 185.66,96.61 184.77,95.72 180.88,95.72 175.08,101.51 172.11,101.51 158.82,114.79 158.82,116.62 157.05,118.39 157.05,121.06 152.4,125.71 151.21,125.71 149.91,127.01 149.91,128.09 141.32,136.68 139.65,136.68 138.44,137.88 138.44,139.58 134.6,143.42 133.26,143.42 132.25,142.42 118.16,142.42 117.34,143.24 101.11,143.24 97.95,146.4 97.44,146.4 96.54,147.31 93.49,147.31 92.56,148.24 89,148.24 87.53,149.71 79.37,149.71 77.84,151.24 61.59,151.24 59.1,153.73 52.15,153.73 50.63,152.21 50.63,149.78 47.77,146.92 44.1,146.92 v1(43.62,147.41)
  BOTTOM w0.102: U46.A15 214.67,74.54 213.32,73.19 213.32,72.65 211.77,71.11 211.07,71.11 210.65,71.52 207.63,71.52 205.09,74.07 205.09,78.76 205.65,79.32 205.65,80.46 205.14,80.97 205.14,89.04 v1(205.04,89.14)
PBAT_PRES#: length 310.3
  TOP w0.102: v1(258.07,63.64) 257.64,63.64 257.31,63.31 256.11,63.31 254.26,65.16 247.35,65.16 247.1,64.91 244.77,64.91 243.75,65.93 243.75,70.77 241.68,72.83 236.38,72.83 236.18,72.63 228.02,72.63 225.28,75.37 225.28,77.46 222.54,80.2 220.05,80.2 215.91,84.34 215.91,84.8 v1(216.32,85.2)
  IN1 w0.109: v1(216.32,85.2) 215.87,85.64 211.93,85.64 210.87,86.7 202.16,86.7 197.54,91.33 197.54,94.15 192.78,98.9 186.04,98.9 176.56,108.38 175.7,108.38 172.13,111.95 172.13,119.76 169.92,121.97 169.92,127.24 167.3,129.86 167.3,131.4 165.85,132.84 159.09,132.84 154.79,137.14 154.79,139.34 150.07,144.06 150.07,145.83 150.91,146.67 150.91,148.63 148.83,150.71 148.83,151.29 v1(148.8,151.32)
  IN3 w0.127: v1(184.87,27.7) 185.28,27.29 185.96,27.29 189.79,23.45 196.15,23.45 199.57,26.87 228.44,26.87 237.98,36.41 248.27,36.41 252.36,40.5 264.39,40.5 270.01,46.12 270.01,62.27 268.44,63.84 258.28,63.84 v1(258.07,63.64)
  BOTTOM w0.102: v1(184.87,27.7) 184.74,27.57 184.74,26.96 184.45,26.66 PR3.7 183.39,26.66 183.17,26.44 v2(180.12,26.44) 177.77,26.44 176.44,27.77 PD5.1 176.44,28.43 176.34,28.53 174.68,28.53 174.63,28.48 PR2.2 ; v1(148.8,151.32) 150.07,152.59 151.62,152.59 152.07,152.14 PU1081.1 ; U46.B40 216.42,85.31 v1(216.32,85.2)
PBAT_SMBCLK: length 217.2
  TOP w0.102: RP5.8 102.64,164.76 102.5,164.63 102.5,164.52 103.25,163.78 103.25,163.14 v1(103.72,162.67)
  IN1 w0.109: v1(103.72,162.67) 103.72,162.48 104.51,161.69 111.48,161.69 112.32,160.85 114.53,160.85 115.27,160.11 115.27,156.91 117.2,154.98 117.2,144.77 114.86,142.43 114.86,139.62 117.61,136.87 117.61,131.76 123.63,125.74 123.63,123.87 122.85,123.09 122.85,109.06 120.91,107.12 120.91,102.83 122,101.74 122,99.65 123.05,98.61 123.05,98.31 125.1,96.25 136.05,96.25 136.59,96.79 159.8,96.79 161.02,95.57 161.2,95.57 161.34,95.71 161.34,95.85 v1(161.1,96.1)
  BOTTOM w0.102: PR3.5 183.83,25.66 183.69,25.8 173.16,25.8 172.35,26.61 172.35,30.52 171.31,31.56 171.31,34.43 170.93,34.81 169.41,34.81 167.75,36.47 164.28,39.93 164.28,43.96 165.9,45.57 165.9,50.4 166.45,50.95 167.72,50.95 167.99,51.22 167.99,53.14 166.53,54.6 166.53,67.3 161.3,72.53 161.3,95.9 v1(161.1,96.1) ; U51.A56 103.5,162.45 v1(103.72,162.67)
PBAT_SMBDAT: length 221.2
  TOP w0.102: RP5.7 102.14,164.76 102.27,164.63 102.27,164.43 103.02,163.68 103.02,163.05 103.31,162.76 103.31,162.5 103.46,162.35 103.46,160.21 103.79,159.88 v1(103.89,159.88)
  IN1 w0.109: v1(103.89,159.88) 103.92,159.85 104.3,160.23 104.3,160.69 105.06,161.45 111.39,161.45 112.23,160.61 114.44,160.61 115.04,160.01 115.04,156.81 116.97,154.88 116.97,144.87 114.62,142.52 114.62,139.53 117.37,136.77 117.37,131.67 123.39,125.65 123.39,123.97 122.61,123.19 122.61,109.15 120.68,107.22 120.68,102.73 121.77,101.64 121.77,99.56 122.81,98.51 122.81,98.21 125.01,96.02 136.15,96.02 136.69,96.56 159.7,96.56 160.92,95.34 161.3,95.34 161.58,95.62 161.58,95.95 v1(161.73,96.1)
  BOTTOM w0.102: v1(103.89,159.88) 103.72,159.88 103.25,160.35 U51.B59 ; v1(161.73,96.1) 161.53,95.9 161.53,72.63 166.76,67.4 166.76,54.7 168.22,53.24 168.22,51.13 167.81,50.72 166.54,50.72 166.12,50.3 166.12,45.48 164.51,43.86 164.51,40.03 167.98,36.56 167.98,36.56 169.5,35.04 171.02,35.04 171.53,34.52 171.53,31.66 172.58,30.62 172.58,26.71 173.25,26.03 183.7,26.03 183.84,26.16 PR3.6
PBATT+: length 153
  IN1 w0.254: v1(159.14,120.25) 157.92,119.04 157.92,118.58 158.71,117.79 158.71,117.41 160.08,116.04 160.08,114.74 161.78,113.04 161.78,110.69 169.65,102.83 172.72,102.83 184.9,90.65 184.9,85.53 v1(184.84,85.48)
  IN2 w0.254: v3(174.83,81.22) 174.83,81.21 173.69,80.07 172.55,80.07 170.91,78.44 170.91,58.5 170.24,57.83 170.24,54.91 172.78,52.37 172.78,47.99 175.22,45.55 175.22,32.02 176.28,30.96 186.41,30.96 186.6,31.15 188.8,31.15 189.66,32.01 194.57,32.01 195.84,33.28 v1(195.84,34.96)
  IN4 w0.254: v3(174.83,81.22) 181.51,81.22 184.26,78.47 v1(188.78,78.47)
  BOTTOM w0.254: v1(184.84,85.48) 184.79,85.43 184.79,82.46 v4(186.43,80.83) v1(188.78,78.47) ; v1(159.14,120.25) 159.22,120.33 159.22,121.87 158.49,122.59 PR1008.2
PBATT+_C:
  vias: v2(162.71,22.06) v3(201.33,32.51) v3(201.33,31.87) v3(201.33,31.24) v3(201.96,32.5) v3(201.96,31.86) v3(201.96,31.23) v3(202.6,32.5) v3(202.6,31.86) v3(202.6,31.23) v3(203.23,32.5) v3(203.23,31.86) v3(203.23,31.23) v3(203.87,32.5) v3(203.87,31.86)
PBATT_IN_SS:
  vias: v2(183.45,29.84)
PCH_ALW_ON: length 193.9
  TOP w0.102: v1(111.53,149.64) 112.07,150.19 v2(112.07,151.33) 112.07,151.71 114.61,154.25 114.61,156.37 115.48,157.23 115.48,168.08 v1(116.37,168.97)
  IN2 w0.127: v1(116.37,168.97) 113.86,171.47 97.61,171.47 94.04,167.9 88.73,167.9 87.97,168.67 70.03,168.67 66.32,164.96 65.1,164.96 63.2,163.06 63.2,161.61 61.04,159.45 54.61,159.45 51.9,156.73 50.08,156.73 49.41,156.06 47.94,156.06 46.68,154.8 43.7,154.8 41.11,152.2 41.11,148.64 38.71,146.24 34.79,146.24 33.49,144.93 33.49,142.17 30.54,139.22 v1(30.54,139.05)
  IN3 w0.127: v1(30.54,139.05) 30.54,138.28 33.49,135.33 36,135.33 38.55,132.78 48.19,132.78 49.62,131.35 55.37,131.35 57.03,129.68 57.03,115.33 55.48,113.77 55.48,110.47 56.68,109.27 57.13,109.27 v1(57.29,109.42) ; v1(104.5,150.33) 104.9,149.93 104.9,149.2 105.28,148.82 108.01,148.82 108.03,148.84 108.33,148.84 109.42,149.92 111.25,149.92 v1(111.53,149.64)
  BOTTOM w0.102: PR23.1 31.28,139.79 v1(30.54,139.05) ; U51.A23 v1(104.5,150.33) ; RP7.8 111.92,149.25 v1(111.53,149.64) ; v1(57.29,109.42) 57.21,109.34 56.5,109.34 56.4,109.44 U34.5
PCH_AZ_BITCLK: length 6
  TOP w0.102: RH65.2 20.13,100.92 20.76,100.92 21.04,100.65 21.04,100.44 21.76,99.72 22.58,99.72 22.63,99.77 23.78,99.77 23.8,99.78 24.47,99.78 24.62,99.93 UH1.B25
PCH_AZ_CODEC_BITCLK: length 6.8
  TOP w0.102: JIO1.36 14.44,100.8 14.77,101.13 v2(15.82,101.13) CH9.1 17.38,101.79 18.65,101.79 19.01,101.43 RH65.1
PCH_AZ_CODEC_RST#: length 6.4
  TOP w0.102: JIO1.40 14.5,99.6 14.83,99.27 16.01,99.27 16.42,98.87 17.94,98.87 18.3,99.22 RH63.1
PCH_AZ_CODEC_SDIN0: length 21.6
  TOP w0.102: JIO1.44 12.11,98.4 v1(11.34,99.17) ; v1(28.05,98.38) 28.55,98.38 UH1.L22
  IN3 w0.127: v1(11.34,99.17) 11.49,99.17 12.99,100.67 16.49,100.67 16.75,100.42 19.36,100.42 19.76,100.01 23.98,100.01 25.48,98.51 26.74,98.51 27.01,98.78 27.66,98.78 v1(28.05,98.38)
PCH_AZ_CODEC_SDOUT: length 4
  TOP w0.102: JIO1.38 14.6,100.2 15.05,99.76 v2(15.77,99.76) 16.32,99.76 RH59.1
PCH_AZ_CODEC_SYNC: length 6.3
  TOP w0.102: JIO1.42 14.42,99 15.1,98.32 v2(15.87,98.32) 16.39,98.32 16.46,98.38 18.96,98.38 RH61.1
PCH_AZ_RST#: length 6.2
  TOP w0.102: UH1.C24 25.07,99.5 24.76,99.19 24.5,99.19 24.3,99.4 23.96,99.4 23.94,99.39 22.79,99.39 22.2,98.8 v2(22.12,98.8) 21.17,98.8 20.75,99.22 RH63.2
PCH_AZ_SDOUT: length 8.8
  TOP w0.102: UH1.A24 24.54,99.59 23.88,99.59 23.86,99.58 22.71,99.58 22.41,99.29 21.4,99.29 v2(20.79,99.9) 20.57,100.11 RH35.2 19.41,100.62 18.7,100.62 18.53,100.44 17.84,100.44 RH45.2 RH59.2
PCH_AZ_SYNC: length 5.7
  TOP w0.102: UH1.A22 24.5,98.56 24.01,98.56 23.38,99.2 22.86,99.2 22.63,98.96 22.63,98.64 22.14,98.16 v2(20.9,98.16) 20.72,98.33 RH61.2
PCH_BATLOW#: length 9.8
  TOP w0.102: UH1.K7 28.47,92.31 v1(28.25,92.53)
  BOTTOM w0.102: RH112.2 21.73,92.62 21.97,92.87 v2(22.47,92.87) 24.53,92.87 25.22,93.56 26.04,93.56 26.6,93 26.93,93 27.49,92.44 28.16,92.44 v1(28.25,92.53)
PCH_CL_CLK1: length 163.6
  TOP w0.102: UH1.AF11 35.5,93.83 v1(35.79,93.83)
  IN3 w0.089: v1(35.79,93.83) 35.79,93.81 36,93.61 36.12,93.61 36.21,93.69 36.21,94.92 36.42,95.13 38.78,95.13 39.5,95.86 41.34,95.86 41.76,95.44 42.25,95.44 42.67,95.86 42.67,95.94 42.69,95.96
  IN3 w0.127: 42.69,95.96 42.87,96.14 45.72,96.14 46.67,95.18 49.46,95.18 49.89,95.62 49.89,95.97 52.1,98.18 54.21,98.18 56.58,95.82 64.42,95.82 66.76,98.16 67.59,98.16 67.8,98.36 67.8,99.3 69.88,101.38 71.29,101.38 72.86,102.95 72.86,104.21 74.34,105.69 74.34,106.4 74.91,106.97 75.45,106.97 76.59,108.11 76.59,115.15 75.42,116.31 75.42,117.64 79.07,121.29 79.07,126.57 78.49,127.14 78.49,133.95 81.39,136.84 81.39,137.81 80.87,138.34 80.87,139.96 80.37,140.46 79.54,140.46 v1(79.38,140.31)
  IN4 w0.109: v1(79.38,140.31) 79.58,140.5 81.37,140.5 89.77,148.91 89.77,156.47 97.03,163.73 111.11,163.73 111.42,164.04 122.34,164.04 124.1,162.28 127.47,162.28 128.51,161.24 132.12,161.24 133.74,159.62 134.35,159.62 v1(134.53,159.45)
  BOTTOM w0.102: JMINI4.45 135.29,159.34 135,159.63 134.71,159.63 v1(134.53,159.45)
PCH_CL_DATA1: length 164.4
  TOP w0.102: v1(35.79,93.18) 35.46,93.51 UH1.AF10
  IN3 w0.089: v1(35.79,93.18) 35.79,93.23 36,93.43 36.19,93.43 36.39,93.62 36.39,94.85 36.5,94.96 38.85,94.96 39.58,95.68 41.27,95.68 41.68,95.26 42.32,95.26 42.8,95.74 42.9,95.74
  IN3 w0.127: 42.9,95.74 43.05,95.89 45.61,95.89 46.57,94.93 49.57,94.93 50.15,95.51 50.15,95.87 52.21,97.93 54.11,97.93 56.47,95.56 64.52,95.56 66.86,97.9 67.7,97.9 68.06,98.26 68.06,99.2 69.99,101.13 71.4,101.13 73.11,102.84 73.11,104.1 74.59,105.58 74.59,106.29 75.02,106.72 75.55,106.72 76.84,108.01 76.84,115.25 75.68,116.42 75.68,117.54 79.32,121.18 79.32,126.67 78.75,127.25 78.75,133.84 81.64,136.74 81.64,137.92 81.12,138.44 81.12,140.07 80.48,140.71 79.59,140.71 v1(79.38,140.92)
  IN4 w0.109: v1(134.53,160.04) 134.35,159.86 133.84,159.86 132.22,161.48 128.61,161.48 127.57,162.52 124.19,162.52 122.44,164.27 111.32,164.27 111.01,163.97 96.94,163.97 89.54,156.57 89.54,149 81.27,140.74 79.56,140.74 v1(79.38,140.92)
  BOTTOM w0.102: v1(134.53,160.04) 134.71,159.86 134.94,159.86 135.23,160.14 JMINI4.47
PCH_CL_RST1#: length 164.4
  TOP w0.102: UH1.AF7 35.51,92.59 v1(35.8,92.59)
  IN3 w0.127: v1(35.8,92.59) 36.64,92.59 37.19,93.15 37.19,93.86 37.42,94.09 38.29,94.09 38.52,93.86 41.46,93.86 41.54,93.79 42.51,93.79 45.05,91.25 49.08,91.25 51.09,89.24 51.09,88.4 51.47,88.02 52.23,88.02 52.97,88.76 52.97,90.26 55.33,92.62 56.39,92.62 56.82,93.05 63.71,93.05 64.17,93.51 67.19,93.51 67.85,94.17 67.85,95.18 70.07,97.4 70.22,97.4 71.85,99.03 72.21,99.03 74.93,101.75 78.03,101.75 80.25,103.97 82.32,103.97 84.7,106.35 84.7,111.04 85.66,112 85.66,115.3 87.79,117.43 93.46,117.43 v1(94.24,116.65)
  IN4 w0.109: v1(94.24,116.65) 94.6,117 100.52,117 101.02,117.51 109.51,117.51 109.94,117.07 116.5,117.07 121.4,121.97 121.4,124.94 128.15,131.7 129.88,131.7 135.59,137.41 135.59,145.53 130.35,150.77 v1(130.35,151.81)
  BOTTOM w0.102: JMINI4.49 135.15,160.94 134.95,161.15 134.35,161.15 133.51,160.31 131.83,160.31 v2(131.27,159.74) 130.13,158.61 130.13,155.24 130.35,155.03 v1(130.35,151.81)
PCH_CLK_BIASREF: length 3
  TOP w0.102: v1(38.01,109.81) 38.03,109.8 UH1.AN44
  BOTTOM w0.102: RH165.1 38.26,109.56 v1(38.01,109.81)
PCH_CRT_BLU: length 88.2
  TOP w0.102: v1(26.45,114.16) 25.99,113.7 25.99,112.43 RH115.2
  TOP w0.178: UH1.T45 31.1,109.13 30.41,109.81 29.24,109.81 28.09,110.97 27.46,110.97 RH115.2
  IN4 w0.109: v1(26.45,114.16) 26.73,114.44 26.73,115.82 30.23,119.32 30.23,120.85 32.58,123.19 32.58,130.03 40,137.45 40.53,137.45 41.88,138.8 46.61,138.8 48.77,140.96 49.54,140.96 50.56,141.98 50.56,142.18 54.77,146.39 56.5,146.39 61.39,151.28 73.18,151.28 74.41,152.5 79.4,152.5 81.75,154.85 v1(81.95,154.85)
  BOTTOM w0.102: v1(81.95,154.85) 82.2,155.1 U19.19
PCH_CRT_DDC_CLK: length 94.5
  TOP w0.102: v1(24.55,114.13) 24.77,113.9 24.77,112.51 27.07,110.22 27.72,110.22 28.38,109.56 28.71,109.56 29.04,109.23 29.04,108.4 29.47,107.97 UH1.M43
  IN4 w0.109: v1(83.9,154.32) 83.73,154.49 83.73,155.23 82.99,155.97 81.29,155.97 78.93,153.61 73.95,153.61 72.72,152.39 60.24,152.39 56.88,149.03 55.2,149.03 52.08,145.92 49.94,145.92 45.89,141.87 44.91,141.87 43.46,140.42 41.94,140.42 40.09,138.58 38.86,138.58 35.92,135.63 35.92,134.94 31.47,130.5 31.47,123.65 29.12,121.3 29.12,119.78 25.25,115.91 25.25,115.26 24.74,114.75 24.74,114.33 v1(24.55,114.13)
  BOTTOM w0.102: v1(83.9,154.32) 83.73,154.49 83.73,155.1 83.8,155.18 U19.15
PCH_CRT_DDC_DAT: length 92.7
  TOP w0.102: v1(25.18,114.13) 25,113.96 25,112.61 27.16,110.45 27.81,110.45 28.48,109.79 28.81,109.79 29.27,109.33 29.27,108.5 29.36,108.41 29.47,108.41 UH1.M45
  IN4 w0.109: v1(25.18,114.13) 24.98,114.33 24.98,114.66 25.48,115.16 25.48,115.81 29.35,119.68 29.35,121.2 31.7,123.55 31.7,130.4 36.15,134.85 36.15,135.53 38.96,138.34 40.19,138.34 42.04,140.19 43.56,140.19 45.01,141.63 45.99,141.63 50.04,145.68 52.18,145.68 55.3,148.8 56.98,148.8 60.33,152.15 72.82,152.15 74.05,153.38 79.03,153.38 81.39,155.74 82.89,155.74 83.5,155.13 83.5,154.49 v1(83.32,154.32)
  BOTTOM w0.102: v1(83.32,154.32) 83.5,154.49 83.5,155.08 83.4,155.18 U19.16
PCH_CRT_GRN: length 88.1
  TOP w0.102: v1(27.47,114.16) 26.96,113.65 26.96,112.48 RH116.2
  TOP w0.178: UH1.U44 31.53,109.31 30.59,110.25 29.83,110.25 v2(29.26,110.81) 28.63,111.44 28,111.44 RH116.2
  IN4 w0.109: v1(27.47,114.16) 27.47,115.68 30.85,119.07 30.85,120.29 33.2,122.63 33.2,129.72 38.83,135.35 39.75,135.35 41.89,137.5 46.19,137.5 49.03,140.35 49.79,140.35 51.18,141.73 51.18,141.92 54.84,145.59 56.57,145.59 61.64,150.66 73.44,150.66 74.67,151.89 80.09,151.89 82.13,153.92 82.13,154.32 82.55,154.74 v1(82.55,154.82)
  BOTTOM w0.102: v1(82.55,154.82) 82.6,154.87 U19.18
PCH_CRT_HSYNC: length 89.9
  IN4 w0.109: v1(23.43,114.21) 23.45,114.21 23.86,114.62 23.86,115.39 28.5,120.03 28.5,121.57 30.85,123.92 30.85,130.75 34.49,134.4 34.49,135.09 34.88,135.47 34.88,137.58 37.31,140.02 38.18,140.02 39.32,141.15 40.5,141.15 42.53,143.18 43.73,143.18 46.51,145.95 47.83,145.95 49.9,148.03 51.56,148.03 54.42,150.89 56.42,150.89 58.9,153.37 72.72,153.37 74.13,154.78 76.62,154.78 79.26,157.41 82.42,157.41 84.57,155.27 84.57,154.86 v1(84.6,154.82)
  BOTTOM w0.102: U19.13 v1(84.6,154.82) ; v1(23.43,114.21) 23.43,114.16 23.81,113.78 23.81,113.37 RH94.1
PCH_CRT_RED: length 87.1
  TOP w0.102: v1(28.43,114.16) 28.02,113.75 28.02,112.43 RH117.2
  TOP w0.178: RH117.2 29.12,111.97 30.51,110.58 30.82,110.58 32.04,109.36 32.04,108.54 31.91,108.41
  IN4 w0.089: v1(82.69,154.21) 82.77,154.13 82.77,154.09
  IN4 w0.109: 82.77,154.09 82.77,153.52 80.17,150.91 74.56,150.91 73.7,150.04 61.9,150.04 56.82,144.97 55.09,144.97 51.79,141.67 51.79,141.36 49.43,139 48.88,139 46.76,136.88 42.22,136.88 40.05,134.72 39.07,134.72 33.82,129.47 33.82,122.38 31.47,120.03 31.47,118.81 28.56,115.9 28.56,114.67 28.43,114.54 v1(28.43,114.16)
  BOTTOM w0.102: U19.17 83,154.53 v1(82.69,154.21)
PCH_CRT_VSYNC: length 94
  IN4 w0.109: v1(23.43,114.79) 23.43,115.54 28.09,120.2 28.09,121.74 29.75,123.41 29.75,125.08 30.44,125.76 30.44,131.61 34.46,135.64 34.46,137.75 38.27,141.56 40.33,141.56 42.45,143.69 42.88,143.69 45.56,146.37 47.66,146.37 50.7,149.41 51.7,149.41 53.58,151.3 56.21,151.3 58.69,153.78 71.72,153.78 74.2,156.27 75.26,156.27 78.42,159.42 81,159.42 85.01,155.41 85.01,154.64 v1(84.59,154.21)
  BOTTOM w0.102: U19.14 84.2,154.6 v1(84.59,154.21) ; RH95.1 23,113.29 23,114.36 v1(23.43,114.79)
PCH_DDPD_AUX: length 102.7
  TOP w0.076: v1(27.73,109.58) 28.13,109.18 28.13,108.78 28.31,108.59 28.31,108.33 28.53,108.11 28.53,107.99 28.46,107.91 28.32,107.91 UH1.J44
  TOP w0.102: v1(34.45,163) 34.25,162.8 33.94,162.8 33.41,162.27 33.41,161.38 C535.1
  IN4 w0.109: v1(34.45,163) 34.65,162.8 36.05,162.8 37.22,163.97 41.11,163.97 44.13,160.95 44.13,158.61 42.4,156.88 42.4,148.25 39.18,145.02 37.04,145.02 34.48,142.46 34.48,142.05 30.3,137.87 30.09,137.87 28.99,136.76 28.99,135.1 28.05,134.16 28.05,133.22 27.62,132.79 27.62,129.78 24.37,126.53 24.37,123.12 23.66,122.41 23.66,121.37 20.99,118.7 20.99,118.17 19.83,117.01 19.83,116.12 19.21,115.5 19.21,115.07 18.63,114.49 18.63,109.94 18.22,109.54 18.22,102.71 19.4,101.52 23.46,101.52 24.44,102.5 24.44,107.2 26.63,109.39 27.55,109.39 v1(27.73,109.58)
PCH_DDPD_AUX#: length 102.6
  TOP w0.076: UH1.J42 28.25,107.55 27.97,107.83 27.97,108.12 28.15,108.29 28.15,108.52 27.76,108.91 v1(27.73,108.91)
  TOP w0.102: C536.1 33.71,161.15 33.64,161.22 33.64,162.17 34.04,162.57 34.25,162.57 34.3,162.52 v1(34.45,162.37)
  IN4 w0.109: v1(34.45,162.37) 34.65,162.56 36.15,162.56 37.31,163.73 41.01,163.73 43.89,160.85 43.89,158.71 42.17,156.98 42.17,148.34 39.08,145.26 36.94,145.26 34.25,142.56 34.25,142.15 30.2,138.1 30,138.1 28.75,136.86 28.75,135.2 27.81,134.26 27.81,133.32 27.38,132.89 27.38,129.88 24.13,126.63 24.13,123.22 23.42,122.51 23.42,121.47 20.75,118.8 20.75,118.27 19.59,117.11 19.59,116.22 18.97,115.6 18.97,115.17 18.39,114.59 18.39,110.04 17.98,109.63 17.98,102.61 19.31,101.29 23.56,101.29 24.67,102.4 24.67,107.1 26.73,109.15 27.5,109.15 v1(27.73,108.91)
PCH_DDPD_AUX#_C: length 3.1
  TOP w0.102: U629.29 34.83,158.22 34.74,158.3 34.74,158.6 33.74,159.6 33.74,159.9 C536.2
PCH_DDPD_AUX_C: length 3.1
  TOP w0.102: U629.30 34.43,158.21 34.51,158.29 34.51,158.5 v3(33.94,159.08) 33.51,159.5 33.51,159.9 C535.2
PCH_DDPD_CTRLCLK: length 81.4
  TOP w0.102: v1(29.24,106.32) 29.4,106.47 UH1.N40 ; v1(36.74,161.81) 36.91,161.63 36.91,159.34 36.51,158.94 36.51,158.28 36.43,158.2 U629.25
  IN1 w0.109: v1(30.29,135.27) 30.49,135.06 30.74,135.06 30.97,135.29 30.97,143.29 31.28,143.6 31.28,148.24 30.28,149.24 30.28,156.32 30.48,156.52 30.48,158.2 32.12,159.84 35.65,159.84 36.91,161.09 36.91,161.64 v1(36.74,161.81)
  BOTTOM w0.102: v1(30.29,135.27) 30.49,135.06 30.81,135.06 31.45,134.42 31.45,128.69 33.28,126.86 33.28,120.31 30.39,117.41 27.18,117.41 25.76,115.99 23.76,115.99 22.06,114.29 22.06,112.43 RH255.2 21.98,111.97 21.9,111.9 21.9,111.79 22.77,110.92 22.81,110.92 23.86,109.87 23.86,109.53 24.97,108.42 26.67,108.42 27.38,107.71 27.85,107.71 28.84,106.72 28.84,106.3 29.01,106.13 29.17,106.13 29.24,106.2 v1(29.24,106.32)
PCH_DDPD_CTRLDATA: length 81.4
  TOP w0.102: v1(29.22,105.73) 29.66,105.28 UH1.N38 ; U629.24 36.83,158.18 36.73,158.27 36.73,158.84 37.14,159.25 37.14,161.63 v1(37.32,161.81)
  IN1 w0.109: v1(30.29,134.66) 30.46,134.83 30.84,134.83 31.21,135.19 31.21,143.19 31.51,143.5 31.51,148.34 30.51,149.34 30.51,156.22 30.72,156.42 30.72,158.1 32.22,159.61 35.75,159.61 37.14,161 37.14,161.63 v1(37.32,161.81)
  BOTTOM w0.102: v1(29.22,105.73) 29.09,105.73 28.61,106.21 28.61,106.62 27.75,107.48 27.29,107.48 26.58,108.19 24.88,108.19 23.63,109.43 23.63,109.77 22.71,110.69 22.68,110.69 21.4,111.97 RH256.2 21.83,112.43 21.83,114.38 23.66,116.22 25.66,116.22 27.09,117.64 30.29,117.64 33.05,120.4 33.05,126.76 31.23,128.59 31.23,134.33 30.72,134.83 30.46,134.83 v1(30.29,134.66)
PCH_DPWROK: length 217.9
  TOP w0.102: UH1.L13 28.95,94.74 v1(28.55,94.34)
  IN2 w0.127: v1(56.63,93.46) 56.27,93.1 49.35,93.1 44.98,88.73 42.94,88.73 42.7,88.49 38.69,88.49 37.15,90.03 31.88,90.03 31.31,90.6 30.12,90.6 29.24,91.48 29.04,91.48 28.74,91.78 28.74,94.15 v1(28.55,94.34)
  IN3 w0.127: v1(165.91,85.65) 166.98,84.58 175.32,84.58 177.31,82.59 180.27,82.59 180.81,83.12 182.93,83.12 187.14,78.9 202.08,78.9 207.69,73.3 v1(207.69,72.1)
  IN4 w0.109: v1(165.91,85.65) 165.91,85.71 158.2,93.42 129.72,93.42 128.94,94.2 115.57,94.2 114.53,95.24 107.56,95.24 106.26,96.54 81.87,96.54 81.57,96.84 72.4,96.84 69.41,93.85 66.42,93.85 65.36,94.91 58.08,94.91 v1(56.63,93.46)
  BOTTOM w0.102: R802.1 210.4,74.94 210.4,73.67 210.09,73.37 210.09,72.81 209.39,72.1 v1(207.69,72.1) ; v1(28.55,94.34) 28.69,94.2 v2(28.69,93.42) 28.74,93.37 28.74,92.47 28.61,92.34 28.61,91.5 27.24,90.13 27.24,88.61 26.69,88.05 25.15,88.05 24.49,87.4 24.49,86.56 23.67,85.74 RH79.1 RH131.2
PCH_GPIO3: length 11.4
  TOP w0.102: v1(26.86,96.25) 26.56,96.54 UH1.F17
  BOTTOM w0.102: v1(26.86,96.25) v2(25.51,96.25) 25.36,96.25 24.12,97.49 22.39,97.49 21.29,98.59 20.01,98.59 19.21,99.39 18.11,99.39 RH83.2
PCH_GPIO06: length 13.1
  TOP w0.102: UH1.A14 24.56,95.36 23.07,95.36 v1(22.58,94.87)
  IN3 w0.127: v1(22.58,94.87) 22.58,94.84 22.16,94.42 19.29,94.42 18.73,94.98 17.53,94.98 17.28,94.73 15.68,94.73 15.02,95.39 v1(14.74,95.39)
  BOTTOM w0.102: RPH8.7 14.14,95.06 14.46,95.39 v1(14.74,95.39) 14.78,95.39 v2(15.36,95.97)
PCH_GPIO13: length 3.2
  TOP w0.102: v1(24.11,99.02) 24.14,98.99 24.49,98.99 24.49,99 24.76,99 25.07,98.69 UH1.C22
  BOTTOM w0.089: v1(24.11,99.02) 24.47,99.02 v2(24.65,99.2)
  BOTTOM w0.102: v1(24.11,99.02) 24.11,99.1 RH60.2
PCH_GPIO15: length 14.5
  TOP w0.102: v1(33.15,94.51) 33.55,94.1 UH1.AB11
  BOTTOM w0.102: v1(33.15,94.51) 32.75,94.1 32.75,88.21 34.84,86.12 v2(34.84,84.96) 34.84,84.63 35.16,84.31 35.16,82.46 RH211.2
PCH_GPIO24: length 11.1
  TOP w0.102: v1(32.22,93.22) 32.37,93.22 UH1.Y10
  BOTTOM w0.076: 31.7,92.69 v1(32.22,93.22)
  BOTTOM w0.089: 31.59,91.67 31.7,91.78 31.7,92.69
  BOTTOM w0.102: 31.59,91.67 31.57,91.65 31.57,90.72 31.86,90.42 31.86,88.14 v2(32.02,87.98) 34.15,85.85 34.15,84.62 RH213.1
PCH_GPIO33: length 5.8
  TOP w0.102: RH40.2 21.01,97.32 21.5,96.84 v2(21.5,96.64) 21.67,96.47 23.92,96.47 24.21,96.76 25.01,96.76 UH1.B17
PCH_GPIO34: length 9.8
  TOP w0.102: v1(38.65,91.95) 38.41,91.72 UH1.AN6
  BOTTOM w0.102: RPH10.5 42.97,85.75 42.71,86.02 42.34,86.02 40.52,87.83 v2(40.03,87.83) 39.67,87.83 38.69,88.81 38.69,90.69 38.97,90.97 38.97,91.63 v1(38.65,91.95)
PCH_GPIO35: length 110.2
  TOP w0.102: RH25.1 37.93,118.12 v1(37.93,118.5) ; UH1.AP1 38.49,89.71 38.49,89.01 41.31,86.2 v2(41.31,86.02) 41.31,85.58 RH205.1 42.27,84.62 42.27,83.3 v1(42.25,83.27)
  IN3 w0.127: v1(42.25,83.27) 42.07,83.09 40.75,83.09 39.87,83.97 38.3,83.97 37.84,84.43 35.81,84.43 33.94,86.29 31.48,86.29 29.17,83.98 17.46,83.98 17,83.53 13.73,83.53 8.75,88.51 8.75,89.15 5.95,91.95 5.95,96.02 7.7,97.77 7.7,112.26 8.41,112.96 8.56,112.96 9.58,113.98 10.66,113.98 12.84,116.16 15.07,116.16 15.83,116.93 15.83,118.88 17.67,120.71 22.09,120.71 22.97,121.59 25.29,121.59 25.93,122.24 30.82,122.24 33.33,119.72 36.71,119.72 v1(37.93,118.5)
PCH_GPIO36: length 117.9
  TOP w0.102: v1(43.85,82.94) RH230.1 43.39,82.74 43.39,84.62 RH228.1 43.08,85.08 v2(42.88,85.27) 38.92,89.23 38.92,89.91 38.92,89.91 38.92,89.93 38.94,89.95 38.95,89.95 39.13,90.13 39.13,90.13 39.23,90.23 UH1.AT3 ; RH12.1 38.64,120.18 v1(39.05,119.77)
  IN3 w0.127: v1(39.05,119.77) 39.05,118.43 38.69,118.07 37.75,118.07 36.36,119.47 32.11,119.47 29.6,121.98 26.04,121.98 25.39,121.33 23.08,121.33 22.2,120.46 17.77,120.46 16.09,118.77 16.09,116.82 15.18,115.91 12.95,115.91 10.76,113.73 9.69,113.73 8.67,112.71 8.52,112.71 7.96,112.15 7.96,97.67 6.21,95.91 6.21,92.05 9.01,89.25 9.01,88.61 13.1,84.52 16.94,84.52 17.22,84.24 29.06,84.24 31.37,86.55 34.05,86.55 35.91,84.68 37.94,84.68 38.39,84.24 41.44,84.24 41.92,83.75 43.04,83.75 v1(43.85,82.94)
PCH_GPIO37: length 106.5
  TOP w0.102: UH1.AK1 36.79,89.62 37.12,89.29 37.12,88.37 37.64,87.85 v2(37.64,85.99) 37.64,85.31 RH62.1 37.83,85.08 37.42,84.67 37.42,83.37 RH37.1 37.42,82.46 37.42,81.62 v1(37.65,81.39) ; v1(37.96,120.64) 37.52,121.07 RH14.1
  IN3 w0.127: v1(37.65,81.39) 37.04,82 36.61,82 36.27,81.66 35.48,81.66 34.55,82.59 13.6,82.59 6.74,89.44 6.54,89.44 6.1,89.88 6.1,90.72 5.19,91.63 5.19,96.33 6.94,98.09 6.94,113.49 8.19,114.74 10.34,114.74 17.95,122.35 24.97,122.35 25.62,123 31.14,123 33.65,120.48 37.8,120.48 v1(37.96,120.64)
PCH_GPIO49: length 71.7
  TOP w0.102: v1(13.42,115.35) 14.05,115.35 RH19.1 ; UH1.AK3 36.86,90.61 36.86,90.14 37.1,89.91 37.1,89.58 37.35,89.33 37.35,88.46 37.98,87.83 v2(37.98,87.29) 37.98,86.09 38.77,85.3 38.77,85.08 39.23,84.62 39.23,83.83 39.12,83.73 39.12,83.27 RH225.1 39.4,82.28 v1(39.4,81.39)
  IN4 w0.109: v1(13.42,115.35) 11.45,113.38 11.45,112.18 10.35,111.09 10.35,111.05 8.97,109.68 8.97,103.62 10.39,102.21 10.39,93.55 13.78,90.16 14.46,90.16 15.67,88.94 15.67,88.36 19.51,84.53 24.78,84.53 25.74,83.56 26.07,83.56 26.97,82.66 33.65,82.66 35.38,80.94 37.8,80.94 38.18,81.32 38.18,81.39 38.59,81.8 39,81.8 v1(39.4,81.39)
PCH_GPIO55: length 11
  TOP w0.102: v1(37.67,91.9) 37.37,91.9 UH1.AL6
  BOTTOM w0.102: v1(37.67,91.9) 37.67,88.86 38.27,88.26 38.27,88.03 v2(38.53,87.77) 39.23,87.08 39.23,86.64 39.52,86.35 39.63,86.35 40.47,85.5 40.47,83.37 RH76.1
PCH_GPIO69: length 14.8
  TOP w0.102: UH1.D13 25.5,95.03 25.21,94.75 24.95,94.75 24.76,94.93 24.37,94.93 23.91,94.47 23.55,94.47 v1(23.16,94.87)
  BOTTOM w0.102: RPH9.6 14.4,98.33 15.9,96.84 v2(17.52,96.84) 19.21,96.84 19.46,96.59 19.46,95.85 20,95.31 22.72,95.31 v1(23.16,94.87)
PCH_GPIO71: length 16.6
  TOP w0.102: UH1.H15 27.76,95.78 v1(27.4,95.42)
  IN3 w0.127: v1(14.64,96.25) 14.72,96.33 15.35,96.33 15.5,96.48 18.25,96.48 18.63,96.86 19.29,96.86 19.9,96.25 26.17,96.25 26.58,95.84 27.06,95.84 27.4,95.5 v1(27.4,95.42)
  BOTTOM w0.089: v1(27.4,95.42) 27.46,95.42 27.96,94.92 v2(28.38,94.92)
  BOTTOM w0.102: RPH8.5 13.97,96.06 14.16,96.25 v1(14.64,96.25)
PCH_INTVRMEN: length 10.9
  TOP w0.102: v1(27.59,93.42) 27.59,93.43 27.16,93.86 UH1.G10
  BOTTOM w0.102: RH5.2 19.74,94.52 20.28,93.99 v2(25.35,93.99) 25.46,93.99 25.64,93.81 27.2,93.81 v1(27.59,93.42)
PCH_JTAG_RST: length 35.6
  TOP w0.102: v1(33.15,91.9) 33.34,91.72 UH1.AB6 ; RH32.2 18.83,113.5 v1(17.9,112.57)
  IN4 w0.109: v1(33.15,91.9) 32.65,91.4 28.02,91.4 27.75,91.68 27.75,92.19 26.98,92.95 26.6,92.95 26.3,93.25 26.3,96 25.61,96.68 25.56,96.68 24.23,98.02 22.59,98.02 20.49,100.11 19.79,100.11 17.39,102.51 17.39,111.8 17.9,112.3 v1(17.9,112.57)
  BOTTOM w0.102: v1(17.9,112.57) 17.9,113.09 v4(18.04,113.23)
PCH_JTAG_RST_R: length 2.6
  TOP w0.102: JXDP2.54 19.3,115.98 18.83,115.5 RH32.1
PCH_JTAG_TCK: length 61.3
  TOP w0.102: v1(15.38,113.88) 15.17,114.08 14.11,114.08 13.01,115.17 13.01,115.63 14.16,116.77 14.16,118.06 17.54,121.45 18.04,121.45 18.3,121.71 JXDP2.57 ; v1(31.78,85.68) RH47.1 32.32,85.61 32.32,85.85 33.51,87.04 33.51,89.32 33.84,89.66 33.84,89.91 33.54,90.22 UH1.AB3
  IN4 w0.109: v1(15.38,113.88) 14.99,113.5 14.99,111.28 14.03,110.31 14.03,107.92 13.48,107.37 13.48,101.86 14.47,100.88 14.47,99.6 17.66,96.4 17.66,95.57 18.27,94.96 19.86,94.96 22.37,92.45 22.5,92.45 22.96,91.99 22.96,89.45 24.3,88.11 24.61,88.11 25.83,86.9 28.6,86.9 29.3,86.19 31.28,86.19 v1(31.78,85.68)
  BOTTOM w0.102: v1(15.38,113.88) v4(15.96,113.88)
PCH_JTAG_TDI: length 72.3
  TOP w0.102: v1(17.92,119.44) 18.03,119.44 18.8,118.67 JXDP2.56 ; v1(35.85,82.33) 35.29,82.33 RH50.2 35.16,83.37 35.16,84.62 RH55.1 34.99,85.36 34.99,87.79 34.73,88.05 34.73,89.44 34.65,89.52 34.65,90.16 UH1.AE2
  IN4 w0.109: v1(35.85,82.33) 35.37,82.81 35.37,83.6 34.33,84.64 31.57,84.64 31.33,84.87 25.85,84.87 25.43,85.29 24.82,85.29 24.55,85.55 21.64,85.55 18.3,88.89 18.3,89.4 16.63,91.07 16.63,92.25 16.01,92.88 15.16,92.88 14.74,92.46 13.74,92.46 12.61,93.59 12.61,100.47 11.89,101.2 11.89,103.13 11.08,103.94 11.08,107.23 12.44,108.58 12.44,111.13 12.88,111.58 12.88,111.94 13.24,112.29 13.24,113.36 14.7,114.82 14.7,115.21 16.39,116.9 16.39,118.55 17.28,119.44 v1(17.92,119.44)
  BOTTOM w0.102: v4(18.55,119.28) 18.39,119.44 v1(17.92,119.44)
PCH_JTAG_TDO: length 81.6
  TOP w0.102: v1(8.57,111.54) 9.1,111.01 11.33,111.01 13.11,112.79 14.1,112.79 14.81,112.08 18.02,112.08 19.31,113.37 19.31,115.48 19.8,115.97 JXDP2.52 ; v1(31.71,80.81) 32.32,81.42 32.86,81.42 33.14,81.7 33.14,82.45 RH52.2 32.34,83.25 32.34,84.62 RH56.1 33.23,85.51 33.23,85.84 33.92,86.52 33.92,89.22 34.04,89.34 34.04,89.91 34.35,90.22 UH1.AD3
  IN4 w0.109: v1(31.71,80.81) 31.28,80.38 21.19,80.38 20.12,81.45 19.2,81.45 17.79,82.86 13.15,82.86 6.16,89.84 6.16,90.42 7.3,91.55 7.3,110.27 v1(8.57,111.54)
  BOTTOM w0.102: v1(8.57,111.54) 8.57,111.38 v4(8.07,110.88)
PCH_JTAG_TMS: length 82.2
  TOP w0.102: JXDP2.58 18.3,113.58 17.64,112.91 16.26,112.91 15.82,112.48 14.98,112.48 14.27,113.19 12.94,113.19 11.16,111.42 9.28,111.42 v1(8.57,112.13) ; v1(33.89,80.81) 33.33,81.37 33.33,82.43 RH48.2 33.36,83.37 33.36,84.62 RH54.1 34.32,85.58 34.32,89.76 UH1.AD1
  IN4 w0.109: v1(8.57,112.13) 8.52,112.13 6.89,110.5 6.89,91.72 5.75,90.59 5.75,88.96 12.26,82.45 17.62,82.45 19.03,81.04 19.85,81.04 20.92,79.96 33.05,79.96 v1(33.89,80.81)
  BOTTOM w0.102: v4(9.01,112.55) 8.59,112.13 v1(8.57,112.13)
PCH_PCIE_RCOMP: length 6.6
  TOP w0.254: v1(47.66,101.43) 47.66,101.51 47.3,101.86 44.2,101.86 43.9,101.56 42.85,101.56 UH1.BD29
  BOTTOM w0.102: v2(47.34,101.9) 47.66,101.59 v1(47.66,101.43)
  BOTTOM w0.254: v1(47.66,101.43) 47.84,101.26 RH192.2
PCH_PCIE_WAKE#: length 178.7
  TOP w0.102: RH78.2 24.67,82.03 RH129.2 ; RH78.2 23.33,82.46 23.33,81.67 23.46,81.54 23.5,81.54 23.8,81.25 23.8,80.92 23.55,80.68 21.42,80.68 20.53,81.57 20.53,83.35 v1(20.74,83.55) ; RH78.2 24.21,83.35 24.21,85.41 24.47,85.66 25.07,85.66 26.75,87.34 27.61,87.34 28.81,88.54 28.81,89.44 28.97,89.6 28.97,89.91 28.75,90.13 28.75,90.6 UH1.K3 ; v1(92.34,167.02) 92.34,163.28 v2(93.5,162.12) 96.83,158.79 v1(96.99,158.79)
  IN2 w0.127: v1(92.34,167.02) 92.26,167.02 91.6,166.36 89.21,166.36 87.66,167.9 72.34,167.9 69.98,165.54 68.39,165.54 61.53,158.68 56.82,158.68 54.97,156.83 53.08,156.83 52.21,155.97 50.74,155.97 49.98,155.21 49.98,154.42 49.3,153.73 46.68,153.73 41.87,148.92 41.87,148.32 39.02,145.48 37.27,145.48 36.62,144.83 35.6,144.83 34.27,143.5 34.27,140.84 27.69,134.26 27.69,133.39 21.08,126.78 17.57,126.78 15.93,125.15 15.93,119.64 17.36,118.22 17.36,116.27 15.84,114.76 15.6,114.76 14.36,113.51 14.36,111.36 12.71,109.71 12.71,108.48 12.28,108.05 12.28,101.37 12.99,100.66 12.99,95.47 13.57,94.89 13.57,92.72 15.5,90.79 16.4,90.79 17.51,89.68 17.51,88.66 17.28,88.43 17.28,87.95 19.39,85.84 19.39,84.9 v1(20.74,83.55)
  BOTTOM w0.102: U51.A44 98.08,158.27 97.93,158.43 97.34,158.43 v1(96.99,158.79)
PCH_PLTRST#: length 383.9
  TOP w0.102: JUSH1.15 56.05,8.17 57.9,10.02 v1(57.9,17.16) ; v1(32.22,93.84) 32.4,93.84 UH1.Y11 ; JIO1.6 13.97,109.8 14.33,109.43 14.33,109 14.64,108.7 18.41,108.7 18.83,108.28 v1(18.83,107.81) 16.87,105.85 15.71,105.85 v1(15.49,105.63) ; QH2.2 48.85,81.49 v1(48.22,80.86) 48.22,78.95 v1(48.68,78.5) ; v1(49.72,113.37) 50.78,113.37 51.27,113.85 53.43,113.85 68.77,129.19 70.87,129.19 77.89,136.21 82.44,136.21 83.3,137.06 85.24,137.06 87.88,134.42 87.88,134.07 89.09,132.87 v1(89.09,132.13)
  IN1 w0.109: v1(48.22,80.86) 46.34,80.86 44.33,82.87 44.33,83.65 43.05,84.94 38,84.94 37.51,85.42 36.6,85.42 32.72,89.29 32.72,93.34 v1(32.22,93.84) ; v1(64.75,89.24) 61.02,92.97 61.02,94.5 60.19,95.33 58.33,95.33 56.23,97.43 56.23,97.79 55.76,98.26 55.76,102.19 53.59,104.37 53.59,106.5 51.74,108.35 51.74,109.6 50.45,110.89 48.72,110.89 48.27,110.44 47,110.44 46.36,111.08 46.36,111.73 47.05,112.42 49.6,112.42 49.72,112.53 v1(49.72,113.37) 45.27,113.37 44.26,112.36 26.56,112.36 26.13,111.93 24.51,111.93 24.17,111.59 22.26,111.59 18.83,108.16 v1(18.83,107.81)
  IN3 w0.127: v1(32.22,93.84) 31.76,93.38 31.76,92.09 31.15,91.48 30.16,91.48 28.63,89.95 24.95,89.95 22.56,92.34 17.41,92.34 16.47,91.4 15.58,91.4 15.2,91.78 12.64,91.78 11.3,90.44 9.8,90.44 9.48,90.76 8.95,90.76 7.23,92.49 7.23,95.5 9.31,97.58 9.31,99.13 9.76,99.58 v1(9.76,99.6)
  IN4 w0.109: v1(48.68,78.5) 49.11,78.93 51.67,78.93 52.31,78.29 55.35,78.29 56.38,77.26 56.38,52.82 57.26,51.93 57.26,38.24 66.07,29.43 66.07,23.68 61.08,18.69 58.9,18.69 57.9,17.69 v1(57.9,17.16)
  BOTTOM w0.089: 120.14,147.81 120.14,147.53 119.01,146.4
  BOTTOM w0.102: UH3.1 12.47,108.61 12.73,108.88 12.96,108.88 13.12,108.72 UH3.2 13.12,108.02 14.83,106.31 14.83,106.28 v1(15.49,105.63) 14.81,105.63 14.49,105.95 13.6,105.95 13.27,106.28 13.27,106.66 12.68,107.25 11.66,107.25 10.68,106.26 10.68,102.91 10.3,102.53 10.3,100.14 v1(9.76,99.6) ; 119.01,146.4 119.01,144.45 119.62,143.84 119.62,137.96 118.61,136.95 112.16,136.95 109.86,134.66 109.86,133.92 107.43,131.48 89.73,131.48 v1(89.09,132.13) ; v1(48.68,78.5) 48.68,77.82 v2(48.66,77.81) ; U16.2 82.97,104.46 82.53,104.89 82.11,104.89 75.9,98.68 75.9,95.78 69.36,89.24 v1(64.75,89.24) ; U31.36 120.14,147.81
PCH_PLTRST#_EC: length 401.8
  TOP w0.102: v1(89.12,133.46) 89.12,133.75 85.41,137.46 83.08,137.46 82.23,136.61 77.72,136.61 70.7,129.6 68.6,129.6 53.26,114.26 50.66,114.26 v1(50.58,114.18) ; JIO1.8 12.23,109.2 11.95,109.48 v1(11.77,109.48) ; v1(101.84,152.64) 102.79,151.69 102.79,149.9 103.07,149.62 103.07,148.69 100.67,146.29 100.67,144.79 100.85,144.61 101.3,144.61 102.52,145.83 105.59,145.83 106.89,144.53 v1(106.89,144.28) ; v1(214.03,79.18) 213.95,79.18 211.49,76.72 211.49,74.36 211.97,73.87 212.73,73.87 213.47,73.14 213.47,72.55 214.28,71.74 216.27,71.74 219.02,69 227.01,69 227.31,69.3 241.44,69.3 242.3,70.17 v1(243.11,70.17)
  IN1 w0.109: v1(147.1,149.52) 148.78,147.83 148.78,143.04 154.14,137.68 154.14,136.85 158.8,132.19 165.58,132.19 166.65,131.13 166.65,129.59 169.25,126.99 169.25,121.42 171.34,119.33 171.34,113 170.72,112.38 170.72,111.31 v1(170.85,111.19) 171.5,110.54 171.81,110.54 175.75,106.6 176.34,106.6 185.02,97.93 190.86,97.93 192.75,96.04 192.75,95.19 196.58,91.35 196.58,90.87 202.48,84.98 204.69,84.98 205.75,86.04 208.78,86.04 209.84,84.98 211.8,84.98 212.48,84.3 214.63,84.3 215.32,83.6 215.32,79.87 214.69,79.23 214.08,79.23 v1(214.03,79.18)
  IN2 w0.127: v1(164.44,112.98) 165.58,112.98 166.99,111.57 170.47,111.57 v1(170.85,111.19) ; v1(106.89,144.28) 106.89,140.49 108.13,139.25 108.13,138.94 v1(108.17,138.9)
  IN3 w0.127: v1(50.58,114.18) 50.2,114.56 48.87,114.56 48.51,114.21 44.92,114.21 44.61,114.51 42.86,114.51 41.49,113.14 32.47,113.14 31.92,113.69 31.67,113.69 29.42,115.94 27.42,115.94 26.58,115.1 24.6,115.1 24.44,115.25 19.39,115.25 15.2,111.06 14.74,111.06 13.17,109.48 v1(11.77,109.48)
  IN4 w0.109: v1(106.89,144.28) 108.98,146.37 108.98,152.31 109.81,153.14 110.25,153.14 112.46,155.36 113.09,155.36 113.46,155.73 117.18,155.73 117.64,156.19 124.6,156.19 124.85,155.94 125.34,155.94 125.5,155.78 131.01,155.78 131.33,156.1 132.25,156.1 133.03,155.32 133.03,155.28 138.79,149.52 v1(147.1,149.52)
  BOTTOM w0.102: v1(101.84,152.64) 101.75,152.55 U51.B30 ; U46.B22 213.94,79.27 v1(214.03,79.18) ; JMINI2.22 250.83,77 249.82,78.01 247.56,78.01 246.67,77.13 246.67,76.02 244.76,74.11 244.76,71.49 243.44,70.17 v1(243.11,70.17) ; v1(108.17,138.9) 108.75,138.33 108.75,133.38 107.31,131.94 89.89,131.94 89.12,132.7 v1(89.12,133.46) 88.25,133.46 v2(87.46,132.67) ; v1(147.1,149.52) 146.47,150.14 JMINI4.22 139.54,150.14 137.54,148.14 JMINI4.17 ; v1(106.89,144.28) 106.45,144.28 106.15,143.99 JMINI3.22 ; UH3.4 13.77,106.74 12.67,107.83 12.07,107.83 11.36,108.54 11.36,109.08 v1(11.77,109.48) ; v1(164.44,112.98) 164.58,112.84 164.58,111.08 164.24,110.75 U39.16
