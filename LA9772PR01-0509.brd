# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_SMBDATA: length 19.6
  TOP w0.102: v1(22.51,87.03) 22.34,87.21 21.08,87.21 20.98,87.11 19.8,87.11 19.61,86.92 QH4.3 ; v1(31.12,93.84) 31.38,94.1 UH1.U11
  IN1 w0.089: 30.32,90.87 30.32,90.89 30.29,90.92 30.29,91.15 30.75,91.61 30.75,93.15 30.72,93.18 30.72,93.44 v1(31.12,93.84)
  IN1 w0.109: 30.32,90.87 30.32,89.86 27.28,86.82 26.75,86.82 26.2,86.27 23.35,86.27 22.97,86.65 22.97,87.08 22.84,87.21 22.69,87.21 v1(22.51,87.03)
  BOTTOM w0.102: RPH5.2 21.85,87.15 21.98,87.29 22.26,87.29 v1(22.51,87.03)
MINI1CLK_REQ#: length 277.6
  TOP w0.102: UH1.AB1 33.1,89.35 33.1,87.21 31.98,86.09 31.61,86.09 31.33,85.81 31.33,83.37 RH123.1 31.28,82.41 31.28,81.32 v1(30.77,80.81)
  IN2 w0.127: v1(30.77,80.81) 31.23,80.35 34.2,80.35 34.3,80.45 34.91,80.45 35.24,80.12 46.57,80.12 46.78,80.34 51.3,80.34 53.89,82.93 67.3,82.93 69.25,84.88 80.01,84.88 84.88,89.76 84.88,92.13 86.21,93.46 87.71,93.46 89.91,95.65 113.35,95.65 113.99,95.02 114.99,95.02 115.59,95.62 117.17,95.62 118.39,94.4 131,94.4 133.3,96.7 133.3,97.45 134.74,98.89 138.66,98.89 139.73,97.83 154.31,97.83 155,97.14 158.83,97.14 162.26,93.71 179.23,93.71 179.87,93.08 194.29,93.08 198.46,88.91 198.46,82.84 202.73,78.57 202.73,74.52 207.75,69.49 216.27,69.49 218.12,71.33 218.48,71.33 218.53,71.38 219.88,71.38 220.59,70.67 222.71,70.67 223.52,71.49 224.98,71.49 227.64,74.15 234.99,74.15 240.25,79.41 246.73,79.41 253.52,86.2 v1(253.53,86.2)
  BOTTOM w0.102: v1(253.53,86.2) JMINI2.7
MINI2CLK_REQ#: length 164
  TOP w0.102: UH1.AE4 34.76,90.65 35.04,90.36 35.04,90.11 34.85,89.92 34.85,89.66 34.96,89.55 34.96,88.2 35.26,87.89 35.26,86.32 v2(35.42,86.16) 35.85,85.74 RH124.1 35.39,84.62 35.39,83.37 v1(35.85,82.92)
  IN1 w0.109: v1(133.94,101.97) 132.09,103.82 132.09,114.79 127.85,119.04 127.85,129.3 131.91,133.36 132.8,133.36 v1(134.25,134.81)
  IN2 w0.127: v1(35.85,82.92) 35.9,82.87 41.11,82.87 41.39,82.59 43.52,82.59 43.87,82.23 46.09,82.23 47.65,83.79 52.24,83.79 53.16,84.71 66.25,84.71 71.01,89.47 72.26,89.47 76.2,93.41 81.13,93.41 84.45,96.73 88.12,96.73 88.82,97.43 114.25,97.43 114.51,97.18 117.91,97.18 119.17,95.92 129.39,95.92 131.12,97.65 131.12,99.22 133.87,101.97 v1(133.94,101.97)
  BOTTOM w0.102: v1(134.25,134.81) 134.25,140.33 134.86,140.94 JMINI4.7
MINI3CLK_REQ#: length 130.9
  TOP w0.089: UH1.T3 31.1,90.22 30.79,89.91 v1(30.79,89.29)
  IN1 w0.109: v1(106.16,102.64) 107.4,103.88 107.4,106.67 108.62,107.88 108.62,111.49 107.43,112.68 107.43,117.3 105,119.73 105,123.48 108.43,126.9 108.43,130.05 v1(107.83,130.64)
  IN2 w0.127: v1(106.16,102.64) 94.26,102.64 93.39,103.5 89.81,103.5 89.34,103.03 81.36,103.03 79.37,101.04 74.14,101.04 72.04,98.94 71.76,98.94 70.09,97.27 69.03,97.27 67.97,96.2 66.97,96.2 63.11,92.34 49.66,92.34 45.29,87.97 43.26,87.97 43.02,87.73 38.37,87.73 36.84,89.27 30.82,89.27 v1(30.79,89.29)
  BOTTOM w0.102: RH254.1 v2(30.77,86.97) 30.77,87.69 31.17,88.1 31.17,88.91 v1(30.79,89.29) ; v1(107.83,130.64) 112.28,130.64 115.35,133.72 115.35,134.36 115.35,134.37 JMINI3.7
MOD_MD: length 204.6
  TOP w0.102: R808.2 111.54,118.49 v1(112.2,117.83) ; JODD1.11 38.05,33.75 39.72,32.08 Q81.1 39.44,31.8 39.23,31.58 39.23,29.72 v1(38.03,28.52)
  IN1 w0.109: v1(112.2,117.83) 112.2,112.51 114.97,109.74 114.97,107.53 115.71,106.79 115.71,101 114.93,100.22 114.93,96.96 115.69,96.2 115.69,94.65 116.45,93.89 117.49,93.89 118.86,92.52 119.21,92.52 v1(119.64,92.95)
  IN4 w0.109: v1(38.03,28.52) 38.03,28.27 42.09,24.21 42.09,13.63 48.81,6.91 72.07,6.91 75.44,10.28 75.44,11.4 89.72,25.68 92.21,25.68 92.7,26.17 92.7,28.53 93.76,29.59 93.76,33.01 96.46,35.71 107.14,35.71 114.12,42.69 114.12,67.43 119.64,72.95 v1(119.64,92.95)
  BOTTOM w0.102: v1(38.03,28.52) v4(39.11,28.52)
MODC_EN: length 358.7
  TOP w0.102: U57.3 43.88,30.66 44.02,30.52 44.02,30.04 44.28,29.78 44.28,29.2 43.83,28.75 43.24,28.75 42.68,29.31 v2(42.68,30) 42.71,30.02 42.71,30.54 42.29,30.96 v1(42.29,31.04) 42.17,31.15 Q81.5 ; v1(219.79,74.51) 219.77,74.51 218.92,75.36 v1(218.92,77.37)
  IN1 w0.109: v1(219.79,74.51) 220.23,74.94 220.23,75.19 220.56,75.52 221.71,75.52 222.24,75 244.28,75 246.87,77.59 251.42,77.59 253.78,79.95 261,79.95 271.23,69.71 271.23,46.89 264.24,39.9 258.93,39.9 256.79,37.76 251.44,37.76 250.26,36.58 236.58,36.58 222.35,22.35 196.01,22.35 195.2,21.54 132.33,21.54 131.74,22.14 107.34,22.14 103.79,25.69 89.26,25.69 88.91,26.03 84.65,26.03 76.79,18.18 76.79,14.99 72.68,10.88 56.47,10.88 52.76,14.59 50.28,14.59 49.44,15.43 48.99,15.43 48.29,14.73 46.49,14.73 45.97,15.25 45.97,17.8 44.17,19.6 44.17,25.37 41.73,27.81 41.73,30.48 v1(42.29,31.04)
  BOTTOM w0.102: R514.1 219.62,74.33 v1(219.79,74.51) ; v1(218.92,77.37) U46.B7
MODC_EN#: length 4
  TOP w0.102: Q81.2 Q81.3 40.17,30.06 R515.2 39.26,28.42 v2(39.26,27.72)
MODE: length 3.3
  TOP w0.102: U9.53 26.27,158.54 26.4,158.41 v2(26.89,158.41) 27.54,158.41 R58.2 27.85,158.96 R63.2
MSATA_PCIE_PIN51: length 1.1
  BOTTOM w0.102: U46.A57 224.41,81.02 T119.1
MSATA_PRX_WANTX_N4_RP: length 2.8
  BOTTOM w0.102: U637.12 219.73,65.56 219.87,65.7 220.24,65.7 220.43,65.89 220.45,65.89 220.84,66.28 221.36,66.28 C538.2
MSATA_PRX_WANTX_N4_RP_C: length 43.1
  IN1 w0.117: v1(223.96,66.08) 224.16,66.28 224.82,66.28 225.49,65.61 231.78,65.61 236.79,70.62 242.79,70.62 243.39,71.22 247.4,71.22 248.72,72.55 251.97,72.55 253.5,74.08 254.16,74.08 256.17,76.08 257.96,76.08 v1(258.17,75.87)
  BOTTOM w0.102: v1(223.96,66.08) 223.75,66.29 222.95,66.29 C538.1 ; JMINI2.25 259.47,75.8 259.2,76.07 258.36,76.07 v1(258.17,75.87)
MSATA_PRX_WANTX_P4_RP: length 2.8
  BOTTOM w0.102: U637.11 219.77,66.06 219.91,65.92 220.15,65.92 v3(220.47,66.24) 220.74,66.5 221.36,66.5 C537.2
MSATA_PRX_WANTX_P4_RP_C: length 43.1
  IN1 w0.117: v1(223.96,66.71) 224.16,66.51 224.92,66.51 225.59,65.85 231.68,65.85 236.69,70.86 242.69,70.86 243.29,71.46 247.3,71.46 248.62,72.78 251.88,72.78 253.41,74.31 254.06,74.31 256.07,76.32 257.98,76.32 v1(258.17,76.51)
  BOTTOM w0.102: v1(223.96,66.71) 223.75,66.5 222.95,66.5 C537.1 ; JMINI2.23 259.5,76.6 259.19,76.29 258.39,76.29 v1(258.17,76.51)
MSATA_PTX_WANRX_N4_RP: length 2.7
  BOTTOM w0.102: U637.14 219.78,64.56 219.92,64.42 220.24,64.42 220.25,64.43 220.79,64.43 221.08,64.73 221.37,64.73 C539.2
MSATA_PTX_WANRX_N4_RP_C: length 42.5
  IN1 w0.117: v1(223.43,64.93) 223.63,64.73 225.53,64.73 225.77,64.97 232.12,64.97 235.75,68.6 243.17,68.6 244.49,69.92 246.39,69.92 246.53,69.78 247.8,69.78 248.45,70.42 248.45,71.16 249.21,71.92 252.31,71.92 253.5,73.11 255.18,73.11 255.19,73.1 258.38,73.1 v1(258.58,73.3)
  BOTTOM w0.102: v1(223.43,64.93) 223.22,64.72 222.95,64.72 C539.1 ; v1(258.58,73.3) 258.8,73.09 259.19,73.09 259.5,73.4 JMINI2.31
MSATA_PTX_WANRX_P4_RP: length 2.7
  BOTTOM w0.102: U637.15 219.78,64.06 219.92,64.2 v3(220.53,64.2) 220.86,64.2 221.17,64.51 221.36,64.51 C540.2
MSATA_PTX_WANRX_P4_RP_C: length 42.5
  IN1 w0.117: v1(258.58,72.67) 258.38,72.87 255.09,72.87 255.08,72.88 253.6,72.88 252.4,71.68 249.31,71.68 248.68,71.06 248.68,70.32 247.9,69.54 246.43,69.54 246.29,69.68 244.59,69.68 243.27,68.36 235.85,68.36 232.22,64.73 225.87,64.73 225.63,64.5 223.63,64.5 v1(223.43,64.3)
  BOTTOM w0.102: C540.1 222.95,64.51 223.22,64.51 v1(223.43,64.3) ; JMINI2.33 259.47,72.6 259.2,72.87 258.78,72.87 v1(258.58,72.67)
MSCLK: length 135
  TOP w0.102: v1(106.82,138.87) 106.82,140.99 104.92,142.89 95.77,142.89 93.02,145.63 93.02,152.17 v2(92.85,152.34) 92.29,152.91 v1(92.29,152.97) ; v1(166.43,115.36) 166.57,115.5 167.23,115.5 167.46,115.74 JDEG2.5 171.15,115.74 R847.2
  IN1 w0.109: v1(140.2,148.84) 144.61,144.43 144.61,139.66 153.98,130.29 154.23,130.29 155.47,129.05 155.47,127.3 160.82,121.95 160.82,121.44 163.56,118.7 163.56,118.2 165.45,116.31 165.45,116.07 165.72,115.8 166,115.8 v1(166.43,115.36)
  IN3 w0.127: v1(92.29,152.97) 92.29,153.08 92.82,153.62 93,153.62 95.39,156 99.77,156 v1(100.49,156.73) 101.28,155.94 109.11,155.94 109.77,155.28 117.8,155.28 119.43,153.66 126.7,153.66 129.41,150.95 133.02,150.95 133.99,151.92 137.13,151.92 v1(140.2,148.84)
  BOTTOM w0.102: v1(100.49,156.73) 100.11,156.35 99.5,156.35 99.33,156.52 U51.B43 ; v1(106.82,138.87) 106.82,136.94 107.35,136.41 107.35,134.64 JMINI3.19
MSDATA: length 144.1
  TOP w0.102: v1(111.15,141.17) 110.92,141.4 106.73,141.4 105.02,143.11 95.86,143.11 93.25,145.72 93.25,152.56 v1(92.87,152.94) ; JDEG2.4 167.41,115.24 166.85,114.68 166.44,114.68 v1(166.43,114.69)
  IN1 w0.109: v1(166.43,114.69) 165.9,114.69 164.98,115.62 164.98,116.12 163.09,118 163.09,118.5 160.34,121.25 160.34,121.76 155,127.1 155,128.85 154.04,129.81 153.79,129.81 153.78,129.82 144.14,139.46 144.14,143.99 139.58,148.55 138.74,148.55 v1(138.73,148.56)
  IN3 w0.127: v1(138.73,148.56) 135.63,151.66 134.1,151.66 133.13,150.7 129.3,150.7 126.6,153.4 119.08,153.4 118.09,154.39 115.55,154.39 115.3,154.14 113.8,154.14 112.96,154.98 109.62,154.98 109.5,155.09 106.35,155.09 106.27,155.17 98.62,155.17 98.05,155.74 96.76,155.74 v1(96,154.98) 94.69,153.67 93.59,153.67 v1(92.87,152.94)
  BOTTOM w0.102: R706.2 147.27,143.67 143.61,147.33 139.96,147.33 v1(138.73,148.56) ; U51.A40 97.37,156.27 v2(97.23,156.14) 96.71,155.61 R869.2 v1(96,154.98) ; JMINI3.14 112.55,142.75 112.55,142.75 112.55,141.89 111.83,141.17 v1(111.15,141.17)
MUX_AUX: length 18.5
  TOP w0.102: U9.50 25.18,157.33 25.05,157.47 25.05,158 25.19,158.14 U9.52 26.49,158.14 v1(26.78,157.85) ; v1(32.75,161.91) 32.38,162.28 Q335.1 ; v1(32.37,156.5) 32.55,156.68 33.1,156.68 33.18,156.6 U629.32
  IN4 w0.109: v1(32.75,161.91) 32.75,160.46 33.22,159.99 33.22,157.04 32.86,156.68 32.55,156.68 v1(32.37,156.5) 32.21,156.66 29.89,156.66 29.57,156.98 27.96,156.98 27.68,156.7 27.14,156.7 26.78,157.06 v1(26.78,157.85)
MUX_AUX#: length 20
  TOP w0.102: Q335.4 30.75,160.06 30.9,159.91 30.9,159.7 v1(30.82,159.62) ; v1(32.37,157.11) 32.57,156.91 33.1,156.91 33.18,157 U629.31 ; U9.51 26.26,157.74 26.56,157.44 v1(27.21,157.44) 27.36,157.29 27.36,156.32 27.26,156.22 27.11,156.22 27.01,156.32 27.01,156.91 26.88,157.03 26.35,157.03 26.25,156.93 U9.49
  IN4 w0.109: v1(30.82,159.62) 31.48,160.28 32.59,160.28 32.99,159.89 32.99,157.14 32.76,156.91 32.56,156.91 v1(32.37,157.11) 32.37,157.08 32.18,156.9 31.87,156.9 31.76,157.01 31.43,157.01 31.32,156.9 30.99,156.9 30.88,157.01 30.55,157.01 30.44,156.9 29.99,156.9 29.67,157.22 27.86,157.22 27.58,156.94 27.23,156.94 27.02,157.16 27.02,157.34 27.12,157.44 v1(27.21,157.44)
MUX_CA_DET: length 37.6
  TOP w0.102: U629.48 32.95,150.2 v1(32.88,150.12) ; U9.11 20.86,161.2 20.96,161.3 20.96,161.73 20.76,161.93 20.76,162.55 v1(20.81,162.6) ; Q346.2 39.02,141.79 38.74,142.07 37.93,142.07 R82.1 34.76,141.39 v1(33,143.14)
  IN1 w0.109: v1(33,143.14) 32.59,143.55 32.59,149.84 v1(32.88,150.12)
  IN4 w0.109: v1(20.81,162.6) 20.63,162.42 20.63,162.06 22.64,160.06 23.45,160.06 25.27,158.23 25.27,154.53 29.68,150.12 v1(32.88,150.12)
MUX_CEXT: length 2.9
  TOP w0.203: C97.2 31.56,150.1 32.23,150.1 32.73,150.6 U629.47
MUX_D0: length 26.8
  TOP w0.102: U629.46 33.21,151 33.13,151.08 32.56,151.08 v1(32.37,150.89) ; C505.1 25.35,165.17 25.35,165.71 25.75,166.11 v1(26.07,166.11)
  IN3 w0.127: v1(26.07,166.11) 25.82,166.11 25.66,165.95 25.66,165.65 25.84,165.47 26.81,165.47 27.87,166.53 29.63,166.53 33.56,162.6 33.56,151.49 33.11,151.04 32.53,151.04 v1(32.37,150.89)
MUX_D0#: length 26.8
  TOP w0.102: U629.45 33.24,151.4 33.13,151.29 32.55,151.29 v1(32.37,151.47) ; v1(25.59,166.56) 25.59,166.25 25.14,165.8 25.14,165.17 C506.1
  IN3 w0.127: v1(25.59,166.56) 25.66,166.48 25.66,166.3 25.41,166.05 25.41,165.54 25.73,165.22 26.91,165.22 27.98,166.28 29.52,166.28 33.31,162.5 33.31,151.6 33,151.29 32.55,151.29 v1(32.37,151.47)
MUX_D0#_C: length 4
  TOP w0.102: C506.2 25.12,163.6 25.12,163.37 v3(24.6,162.85) 23.75,162.01 23.75,161.22 23.66,161.13 U9.4
MUX_D0_C: length 4.1
  TOP w0.102: C505.2 25.33,163.56 25.33,163.28 24.95,162.9 24.95,162.88 24.56,162.49 24.55,162.49 23.97,161.92 23.97,161.22 24.06,161.13 U9.3
MUX_D1: length 3.5
  TOP w0.102: C507.1 31.57,151 31.77,151 31.96,151.19 31.96,151.65 32.19,151.88 32.21,151.88 32.62,152.28 33.13,152.28 33.22,152.2 U629.43
MUX_D1#: length 3.5
  TOP w0.102: C508.1 31.56,151.22 31.68,151.22 31.75,151.28 31.75,151.74 v3(32.24,152.23) 32.51,152.5 33.14,152.5 33.24,152.6 U629.42
MUX_D1#_C: length 19
  TOP w0.102: v1(22.36,162.01) 22.55,161.82 22.55,161.22 22.46,161.13 U9.7 ; C508.2 30.03,151.27 29.85,151.27 v1(29.63,151.5)
  IN3 w0.127: v1(29.63,151.5) 29.47,151.34 28.05,151.34 24.67,154.72 24.67,161.74 23.68,162.72 22.79,162.72 22.54,162.47 22.54,162.19 v1(22.36,162.01)
MUX_D1_C: length 19
  TOP w0.102: v1(22.97,162.01) 22.77,161.81 22.77,161.22 22.86,161.13 U9.6 ; C507.2 30.31,150.96 30.22,151.05 29.89,151.05 v1(29.63,150.79)
  IN3 w0.127: v1(29.63,150.79) 29.63,150.96 29.5,151.09 27.95,151.09 24.42,154.62 24.42,161.63 23.58,162.47 22.9,162.47 22.79,162.37 22.79,162.19 v1(22.97,162.01)
MUX_D2: length 3
  TOP w0.102: U629.40 33.21,153.4 33.12,153.49 32.56,153.49 32.26,153.19 32.24,153.19 31.82,152.77 31.56,152.77 C509.1
MUX_D2#: length 3
  TOP w0.102: U629.39 33.22,153.8 33.13,153.71 32.46,153.71 v3(32.29,153.54) 31.73,152.98 31.57,152.98 C510.1
MUX_D2#_C: length 20.4
  TOP w0.102: C510.2 30.04,153.06 29.84,153.06 v1(29.63,153.27) ; U9.10 21.26,161.15 21.36,161.25 21.36,161.92 v1(21.17,162.11)
  IN3 w0.127: v1(29.63,153.27) 29.47,153.12 27.37,153.12 25.43,155.05 25.43,162.06 24.01,163.48 21.87,163.48 21.33,162.94 21.33,162.28 v1(21.17,162.11)
MUX_D2_C: length 20.4
  TOP w0.102: v1(29.63,152.56) 29.9,152.84 30.21,152.84 30.31,152.74 C509.2 ; v1(21.75,162.11) 21.57,161.94 21.57,161.22 21.66,161.14 U9.9
  IN3 w0.127: v1(29.63,152.56) 29.63,152.74 29.5,152.87 27.26,152.87 25.18,154.95 25.18,161.96 23.91,163.23 21.98,163.23 21.58,162.84 21.58,162.28 v1(21.75,162.11)
MUX_D3: length 3
  TOP w0.102: U629.37 33.22,154.6 33.13,154.69 32.43,154.69 32.35,154.77 32.33,154.77 31.96,155.14 31.96,155.16 31.68,155.43 31.56,155.43 C511.1
MUX_D3#: length 3
  TOP w0.102: U629.36 33.2,155 33.11,154.91 32.51,154.91 v3(32.3,155.12) 31.77,155.65 31.57,155.65 C512.1
MUX_D3#_C: length 21.3
  TOP w0.102: v1(19.95,161.55) 20.14,161.37 20.14,161.21 20.06,161.13 U9.13 ; C512.2 30.03,155.71 29.85,155.71 v1(29.63,155.94)
  IN3 w0.127: v1(19.95,161.55) 20.13,161.74 20.13,163.43 20.94,164.24 24.34,164.24 26.19,162.39 26.19,155.84 26.45,155.58 28.56,155.58 28.76,155.78 29.47,155.78 v1(29.63,155.94)
MUX_D3_C: length 21.3
  TOP w0.102: v1(20.56,161.55) 20.35,161.35 20.35,161.2 20.46,161.09 U9.12 ; v1(29.63,155.23) 29.89,155.5 30.2,155.5 30.31,155.38 C511.2
  IN3 w0.127: v1(20.56,161.55) 20.38,161.74 20.38,163.33 21.04,163.99 24.24,163.99 25.94,162.29 25.94,155.74 26.35,155.33 28.66,155.33 28.86,155.53 29.5,155.53 29.63,155.41 v1(29.63,155.23)
MUX_HPD: length 19.3
  TOP w0.102: U629.44 v1(32.88,151.8) ; U9.5 v1(23.26,161.5)
  IN4 w0.109: v1(23.26,161.5) 25.51,159.25 25.51,154.9 26.7,153.71 30.97,153.71 v1(32.88,151.8)
  BOTTOM w0.102: v2(33.9,151.01) 33.12,151.8 v1(32.88,151.8)
MUX_PC0: length 7.3
  TOP w0.102: R98.1 31.82,154.21 v1(31.83,154.2) U629.38
  BOTTOM w0.102: v2(31.8,149.88) 31.23,150.45 R115.1 31.23,153.59 v1(31.83,154.2)
MUX_PC1: length 4.8
  TOP w0.102: U629.55 36.03,147.64 35.72,147.33 v2(35.72,147.2) R116.1 35.21,145.65 35.21,144.56 R99.1
MUX_PI0: length 6.1
  TOP w0.102: U629.56 36.43,148.22 36.38,148.17 36.38,146.77 R123.1 37.45,145.71 37.45,144.87 37.25,144.66 R124.1 37.25,143.85 v2(36.74,143.34)
MXM_ALERT#: length 7.4
  TOP w0.102: JMXM1.58 119,97.87 v1(119.05,97.92)
  BOTTOM w0.102: v1(119.05,97.92) 117.81,99.16 R4.2 117.81,100.62 117.75,100.69 Q5.3 117.75,102.02 v2(116.62,103.15)
MXM_BIA_PWM: length 99.3
  TOP w0.102: v1(114.46,116.42) v2(115.5,115.38) 117.29,113.59 117.29,107.41 117.05,107.17 117.05,106.4 117.75,105.7 JMXM1.63
  IN3 w0.127: v1(52.13,152.31) 52.13,151.18 53.13,150.18 77.46,150.18 78.95,148.69 87.11,148.69 91.14,144.65 91.14,139.26 97.92,132.48 98.5,132.48 102.35,128.64 102.35,127.62 104.38,125.59 104.38,123.01 106.75,120.64 107.87,120.64 108.68,119.83 108.68,119.59 112.33,115.94 113.98,115.94 v1(114.46,116.42)
  BOTTOM w0.102: U3.2 50.07,152.28 50.33,152.03 51.85,152.03 v1(52.13,152.31)
MXM_CLK_REQ#: length 14.6
  TOP w0.102: JMXM1.182 v1(86,95.13)
  BOTTOM w0.102: R1978.2 87.41,100.67 86.52,99.78 86.52,99.17 86.78,98.92 87.41,98.92 88.12,99.63 89.52,99.63 89.85,99.3 89.85,98.64 89.59,98.38 89.16,98.38 87.99,97.22 v2(87.59,97.22) 87.23,97.22 86,95.99 v1(86,95.13)
MXM_CRT_BLU: length 69.7
  TOP w0.102: v1(86.8,103.55) 86.8,103.55 85.54,103.55 82.03,100.03 82.03,99.25 81.5,98.72 JMXM1.200
  IN1 w0.109: v1(86.8,103.55) 86.8,104.47 86.33,104.94 86.33,108.55 85.72,109.16 85.72,110.77 88.05,113.09 88.05,116.14 90.53,118.63 90.53,121.09 89.28,122.35 89.28,125.76 91.22,127.7 91.22,128.05 90.76,128.51 90.76,129.25 90.46,129.55 90.46,130.76 89.66,131.56 89.66,134.24 90.13,134.71 90.13,137.41 89.46,138.08 89.46,142.45 88.89,143.02 88.89,154.35 86.98,156.26 v1(86.98,156.73)
  BOTTOM w0.102: U19.9 86.95,156.75 v1(86.98,156.73)
MXM_CRT_DDC_CLK: length 71.5
  TOP w0.102: JMXM1.188 84.5,97.51 v1(84.92,97.93)
  IN1 w0.109: v1(87.92,158.46) 87.74,158.29 86.96,158.29 85.86,157.19 85.86,142.24 87.62,140.48 87.62,132.03 88.39,131.26 88.39,127.17 88.17,126.95 88.17,121.62 88.81,120.99 88.81,118.51 86.51,116.21 86.51,113.19 84.6,111.28 84.6,108.68 84.92,108.36 84.92,104.79 85.62,104.08 85.62,103.59 85.1,103.06 85.1,98.11 v1(84.92,97.93)
  BOTTOM w0.102: v1(87.92,158.46) 87.74,158.28 86.6,158.28 86.53,158.35 U19.5 ; v1(84.92,97.93) 84.49,98.36 83.94,98.36 83.55,98.75 83.55,99.07 R5.2
MXM_CRT_DDC_DAT: length 71.4
  TOP w0.102: JMXM1.186 85,97.42 v1(85.51,97.93)
  IN1 w0.109: v1(85.51,97.93) 85.33,98.1 85.33,102.96 85.86,103.49 85.86,104.18 85.16,104.88 85.16,108.46 84.84,108.78 84.84,111.18 86.75,113.09 86.75,116.11 89.04,118.41 89.04,121.08 88.41,121.72 88.41,126.85 88.63,127.07 88.63,131.36 87.85,132.13 87.85,140.58 86.1,142.34 86.1,157.09 87.06,158.05 87.74,158.05 v1(87.92,157.87)
  BOTTOM w0.102: U19.6 86.55,157.95 86.65,158.05 87.74,158.05 v1(87.92,157.87) ; R3.2 83.78,99.07 83.78,98.84 84.03,98.59 84.58,98.59 84.84,98.33 85.1,98.33 v1(85.51,97.93)
MXM_CRT_GRN: length 72.4
  TOP w0.102: v1(87.92,103.56) 87.14,102.78 85.63,102.78 82.63,99.78 82.63,98.99 82,98.36 JMXM1.198
  IN1 w0.109: v1(87.61,156.73) 88.23,156.11 88.23,155.88 89.5,154.61 89.5,143.28 90.07,142.71 90.07,138.34 90.75,137.66 90.75,134.45 90.27,133.98 90.27,131.82 91.08,131.02 91.08,129.81 91.38,129.5 91.38,128.77 91.84,128.31 91.84,127.44 90.15,125.76 90.15,122.44 91.41,121.18 91.41,118.54 90.2,117.33 90.2,114.77 89.01,113.57 89.01,112.51 86.34,109.84 86.34,109.41 86.34,109.41 87.18,108.57 87.18,105.22 87.92,104.48 v1(87.92,103.56)
  BOTTOM w0.102: v1(87.92,103.56) 87.92,104.14 v2(87.41,104.65) ; v1(87.61,156.73) 87.19,157.15 U19.8
MXM_CRT_HSYNC: length 78.9
  TOP w0.102: JMXM1.192 83.5,96.08 84.88,94.7 86.21,94.7 v1(86.59,95.09)
  IN1 w0.109: v1(86.93,159.15) 87.33,159.56 88.29,159.56 91.15,156.7 91.15,143.96 91.72,143.39 91.72,139.02 92.49,138.25 92.49,137.52 93.65,136.36 93.65,129.82 93.83,129.65 93.83,127.1 92.04,125.31 92.04,122.88 93.06,121.87 93.06,115.32 93.73,114.64 93.73,113.55 91.73,111.54 91.73,109.54 90.69,108.49 90.69,97.8 87.99,95.11 86.61,95.11 v1(86.59,95.09)
  BOTTOM w0.102: U19.3 v1(86.93,159.15)
MXM_CRT_RED: length 71.9
  TOP w0.102: v1(88.55,103.56) 88.55,103.33 87.25,102.02 85.74,102.02 83.24,99.53 83.24,98.74 82.5,98 JMXM1.196
  IN1 w0.109: v1(88.55,103.56) 88.55,104.72 87.8,105.47 87.8,107.93 87.97,108.1 87.97,110.12 92.03,114.18 92.03,121.44 90.77,122.69 90.77,125.5 92.79,127.53 92.79,129.22 92.62,129.4 92.62,130.99 90.89,132.72 90.89,133.73 91.36,134.2 91.36,137.92 90.69,138.59 90.69,142.96 90.12,143.53 90.12,155.19 88.58,156.73 v1(88.23,156.73)
  BOTTOM w0.102: U19.7 87.65,157.55 88.23,156.97 v1(88.23,156.73)
MXM_CRT_VSYNC: length 77.5
  TOP w0.102: v1(85.38,95.11) 85.05,95.11 84,96.16 JMXM1.190
  IN1 w0.109: v1(87.51,159.14) 88.12,159.14 90.74,156.53 90.74,143.79 91.31,143.22 91.31,138.85 91.98,138.17 91.98,133.73 91.82,133.56 91.82,132.66 93.24,131.24 93.24,129.65 93.41,129.48 93.41,127.27 91.63,125.48 91.63,122.71 92.64,121.7 92.64,113.5 90.85,111.71 90.43,111.71 89.85,111.13 89.85,109.23 89.17,108.55 89.17,102.1 86.34,99.27 86.34,96.71 85.91,96.28 85.91,95.64 v1(85.38,95.11)
  BOTTOM w0.089: 87.56,159.14 v1(87.51,159.14)
  BOTTOM w0.102: U19.4 87.12,158.75 v1(87.51,159.14) ; v2(88.02,161.01) 88.02,159.6 87.56,159.14
MXM_DP_HDMI_HPD: length 199.6
  TOP w0.102: v1(220.76,74.51) 220.71,74.51 220.3,74.92 220.3,76 220.35,76.05 220.35,77.5 v1(220.81,77.96) 220.48,77.96 216.77,81.67 216.77,81.89 215.05,83.62 215.05,83.93 214.71,84.26 214.31,84.26 213.47,85.1 213.47,86.22 213.11,86.57 213.11,88.28 v1(211.06,90.33)
  IN2 w0.127: v1(211.06,90.33) 210.04,90.33 207.48,92.9 205.24,92.9 200.03,98.11 199.2,98.11 195.57,101.74 187.63,101.74 182.36,107.01 178.07,107.01 176.39,108.69 176.39,109.43 175.9,109.92 175.37,109.92 174.81,109.36 168.44,109.36 165.46,112.33 163.69,112.33 162.76,111.4 160.36,111.4 159.72,110.75 156.6,110.75 154.78,108.94 130.25,108.94 128.71,110.48 126.5,110.48 125.84,109.81 119.43,109.81 118.32,110.92 99.97,110.92 97.94,108.89 82.44,108.89 82.13,109.19 80.94,109.19 80.21,108.46 76.78,108.46 75.83,109.41 71.73,109.41 70.23,107.91 70.23,107.2 64.36,101.33 61.89,101.33 60.38,102.84 v1(58.66,102.84)
  BOTTOM w0.102: v1(220.76,74.51) 221.01,74.25 R17.2 ; D8.1 58.31,105.83 D7.1 D18.1 59.82,103.99 v1(58.66,102.84) ; U46.B4 220.42,77.57 v1(220.81,77.96)
MXM_DPB_AUX: length 50.7
  TOP w0.102: U20.12 72.62,113.5 v1(72.24,113.88) ; JMXM1.300 56.5,97.62 56.57,97.7 56.7,97.7 56.77,97.77 56.77,98.59 56.63,98.74 56.4,98.74 56.2,98.54 v1(56.2,98.41) ; v1(81.97,114.16) 81.85,114.03 C387.2
  IN3 w0.127: v1(56.2,98.41) 56.2,98.52 56.32,98.64 56.62,98.64 56.8,98.46 56.8,97.67 57.23,97.24 63.88,97.24 65.44,98.8 65.44,99.86 66.99,101.41 67.63,101.41 69,102.78 70.65,102.78 71.48,103.6 71.48,104.86 72.53,105.91 72.53,106.61 71.18,107.96 71.18,114.03 71.54,114.39 72.04,114.39 72.24,114.19 v1(72.24,113.88)
  IN4 w0.109: v1(72.24,113.88) 72.24,114.34 72.38,114.48 73.14,114.48 74.19,115.53 75.1,115.53 75.71,114.93 81.84,114.93 81.97,114.79 v1(81.97,114.16)
  BOTTOM w0.102: v2(82.55,112.98) 82.55,113.59 v1(81.97,114.16)
MXM_DPB_AUX#: length 49.3
  TOP w0.102: v1(72.27,115.19) 72.53,115.45 U20.9 ; v1(81.95,116.06) 81.85,115.96 81.42,115.96 C388.2 ; v1(56.19,99.1) 56.32,98.97 56.72,98.97 57,98.69 JMXM1.298
  IN3 w0.127: v1(72.27,115.19) 72.27,114.82 72.09,114.64 71.43,114.64 70.93,114.13 70.93,107.86 72.27,106.51 72.27,106.01 71.22,104.96 71.22,103.71 70.54,103.03 68.89,103.03 67.53,101.67 66.89,101.67 65.19,99.96 65.19,98.91 63.77,97.5 57.34,97.5 57.06,97.77 57.06,98.56 56.73,98.89 56.4,98.89 v1(56.19,99.1)
  IN4 w0.109: v1(81.95,116.06) 81.95,115.27 81.84,115.17 75.81,115.17 75.2,115.77 74.09,115.77 73.04,114.72 72.38,114.72 72.27,114.82 v1(72.27,115.19)
MXM_DPB_N0: length 50.6
  TOP w0.102: JMXM1.274 63,97.59 62.88,97.7 62.88,97.87 63.06,98.05 63.06,99.34 v1(63.22,99.49)
  IN3 w0.127: v1(63.22,99.49) 63.08,99.63 63.08,100.38 63.66,100.96 64.21,100.96 69.55,106.3 69.55,106.92 69.07,107.4 69.07,114.22 72.57,117.72 73.58,117.72 77.67,121.81 77.67,124.96 75.5,127.13 75.5,133.35 74.62,134.23 74.62,137.31 v1(74.79,137.48)
  BOTTOM w0.102: v1(74.79,137.48) 74.59,137.28 74.59,137.14 C438.2
MXM_DPB_N1: length 51.9
  TOP w0.102: JMXM1.280 61.5,97.64 61.45,97.69 61.32,97.69 61.27,97.74 61.27,98.09 61.84,98.66 62.01,98.66 62.09,98.58 62.09,98.48 62.16,98.41 62.26,98.41 v1(62.32,98.35)
  IN3 w0.127: v1(76.72,137.38) 76.72,134.71 77.12,134.31 77.12,127.02 78.49,125.65 78.49,121.47 74.18,117.16 74.18,116.95 73.26,116.04 72.07,116.04 69.88,113.85 69.88,107.76 70.37,107.27 70.37,105.97 64.03,99.63 64.03,99.06 63.32,98.35 v1(62.32,98.35)
  BOTTOM w0.102: v1(76.72,137.38) 76.67,137.32 76.67,137.08 76.92,136.83 76.93,136.83 C440.2
MXM_DPB_N2: length 58.4
  TOP w0.102: v1(60.09,98.36) 59.89,98.17 59.89,97.67 60,97.57 JMXM1.286
  IN3 w0.127: v1(78.88,137.37) 78.7,137.2 78.7,136.9 78.41,136.61 77.83,136.61 77.25,137.19 77.25,137.72 76.06,138.92 73.51,138.92 73.02,138.43 71.86,138.43 70.99,137.55 70.99,130.84 66.56,126.41 66.56,125.12 66.39,124.95 66.39,114.4 67.45,113.35 67.45,105.35 64.06,101.97 62.52,101.97 59.91,99.36 59.91,98.54 v1(60.09,98.36)
  BOTTOM w0.102: v1(78.88,137.37) 78.68,137.18 78.68,137.05 78.96,136.76 C442.2
MXM_DPB_N3: length 64.3
  TOP w0.102: JMXM1.292 58.5,97.57 58.39,97.67 58.39,98.17 v1(58.59,98.36)
  IN3 w0.127: v1(80.88,137.42) 80.72,137.27 80.72,136.91 80.41,136.59 79.86,136.59 79.39,137.06 79.39,137.67 78.74,138.31 78.06,138.31 76.62,139.76 73.17,139.76 72.67,139.27 71.54,139.27 70.18,137.91 70.18,131.17 65.75,126.75 65.75,125.45 65.58,125.28 65.58,113.86 66.63,112.81 66.63,105.7 64.8,103.87 60.82,103.87 58.02,101.08 58.02,99.33 58.43,98.92 58.43,98.52 v1(58.59,98.36)
  BOTTOM w0.102: C444.2 81.01,136.76 80.69,137.09 80.69,137.23 v1(80.88,137.42)
MXM_DPB_P0: length 50.6
  TOP w0.102: JMXM1.276 62.5,97.57 62.62,97.69 62.62,97.98 62.8,98.17 62.8,99.32 v1(62.63,99.49)
  IN3 w0.127: v1(74.15,137.48) 74.32,137.31 74.32,134.1 75.2,133.22 75.2,127 77.37,124.83 77.37,121.94 73.45,118.02 72.44,118.02 68.77,114.35 68.77,107.27 69.24,106.8 69.24,106.42 64.09,101.27 63.53,101.27 62.77,100.51 62.77,99.63 v1(62.63,99.49)
  BOTTOM w0.102: v1(74.15,137.48) 74.32,137.3 74.32,137.14 C431.2
MXM_DPB_P1: length 51.9
  TOP w0.102: JMXM1.282 61,98.2 61.73,98.93 v1(62.32,98.93)
  IN3 w0.127: v1(76.13,137.38) 76.13,137.35 76.41,137.07 76.41,134.59 76.81,134.19 76.81,126.89 78.18,125.52 78.18,121.6 73.87,117.29 73.87,117.08 73.14,116.34 71.95,116.34 69.58,113.98 69.58,107.63 70.06,107.15 70.06,106.09 63.72,99.75 63.72,99.18 63.19,98.65 62.63,98.65 62.35,98.93 v1(62.32,98.93)
  BOTTOM w0.102: v1(76.13,137.38) 76.16,137.38 76.36,137.17 76.36,136.95 76.17,136.76 C439.2
MXM_DPB_P2: length 58.4
  TOP w0.102: JMXM1.288 59.5,97.52 59.63,97.65 59.63,98.19 v1(59.45,98.36)
  IN3 w0.127: v1(59.45,98.36) 59.61,98.52 59.61,99.49 62.39,102.27 63.93,102.27 67.14,105.48 67.14,113.22 66.09,114.27 66.09,125.07 66.26,125.24 66.26,126.54 70.68,130.96 70.68,137.68 71.74,138.73 72.89,138.73 73.39,139.23 76.18,139.23 77.56,137.85 77.56,137.32 77.96,136.92 78.29,136.92 78.4,137.03 78.4,137.22 v1(78.24,137.37)
  BOTTOM w0.102: v1(78.24,137.37) 78.41,137.2 78.41,137.05 78.13,136.76 C441.2
MXM_DPB_P3: length 64.3
  TOP w0.102: JMXM1.294 58,97.52 58.13,97.65 58.13,98.19 v1(57.95,98.36)
  IN3 w0.127: v1(57.95,98.36) 58.13,98.54 58.13,98.79 57.72,99.2 57.72,101.2 60.69,104.18 64.68,104.18 66.33,105.83 66.33,112.69 65.28,113.74 65.28,125.41 65.45,125.58 65.45,126.87 69.87,131.3 69.87,138.03 71.41,139.57 72.54,139.57 73.04,140.07 76.74,140.07 78.19,138.62 78.87,138.62 79.69,137.79 79.69,137.19 79.98,136.9 80.28,136.9 80.42,137.03 80.42,137.25 v1(80.25,137.42)
  BOTTOM w0.102: C443.2 80.12,136.76 80.42,137.06 80.42,137.25 v1(80.25,137.42)
MXM_DPC_AUX: length 91.7
  TOP w0.102: v1(35.09,163.23) 35.29,163.03 35.29,161.48 C531.1 ; JMXM1.255 68.25,105.74 68.39,105.88 68.39,106.43 v1(68.2,106.62) ; v1(42.88,138.36) 42.99,138.36 43.11,138.24 43.11,137.98 43.05,137.92 42.25,137.92 42.02,138.15 R21.2 ; U629.23 37.23,158.2 37.31,158.28 37.31,158.67 37.8,159.17 37.8,160.79 v1(37.63,160.97)
  IN1 w0.109: v1(68.2,106.62) 68.39,106.43 68.39,106.25 67.89,105.75 63.6,105.75 62.65,106.7 62.65,109.39 60.67,111.36 60.67,112.1 59.25,113.52 59.25,130.61 54.64,135.21 48.93,135.21 45.39,138.75 44.6,138.75 44.3,139.06 43.35,139.06 43.1,138.81 43.1,138.59 v1(42.88,138.36)
  IN3 w0.127: v1(37.63,160.97) 37.79,160.81 37.79,152.78 38.6,151.96 38.6,149.83 39.68,148.75 39.68,142.03 42.67,139.05 42.98,139.05 43.09,138.94 43.09,138.58 v1(42.88,138.36)
  BOTTOM w0.102: v1(37.63,160.97) 37.8,161.15 37.8,161.91 37.14,162.57 35.52,162.57 35.29,162.8 35.29,163.03 v1(35.09,163.23)
MXM_DPC_AUX#: length 91.6
  TOP w0.102: v1(38.21,160.97) 38.03,160.79 38.03,159.07 37.53,158.57 37.53,158.32 37.63,158.22 U629.22 ; v1(68.81,106.62) 68.62,106.43 68.62,105.9 68.75,105.77 JMXM1.253 ; R20.2 42.26,137.69 43.14,137.69 43.34,137.89 43.34,138.19 v1(43.52,138.36) ; C532.1 35.52,161.48 35.52,163.03 v1(35.72,163.23)
  IN1 w0.109: v1(43.52,138.36) 43.34,138.54 43.34,138.72 43.45,138.82 44.2,138.82 44.51,138.52 45.29,138.52 48.83,134.98 54.55,134.98 59.01,130.51 59.01,113.42 60.44,112 60.44,111.26 62.41,109.29 62.41,106.61 63.5,105.51 67.98,105.51 68.64,106.17 68.64,106.45 v1(68.81,106.62)
  IN3 w0.127: v1(43.52,138.36) 43.35,138.53 43.35,139.04 43.09,139.3 42.77,139.3 39.94,142.14 39.94,148.85 38.86,149.93 38.86,152.07 38.04,152.89 38.04,160.8 v1(38.21,160.97)
  BOTTOM w0.102: v1(35.72,163.23) 35.51,163.02 35.51,162.9 35.61,162.8 37.24,162.8 38.03,162.01 38.03,161.15 v1(38.21,160.97)
MXM_DPC_AUX#_C: length 2.7
  TOP w0.102: C532.2 35.52,159.91 v3(35.52,159.04) 35.52,158.32 35.63,158.21 U629.27
MXM_DPC_AUX_C: length 2.7
  TOP w0.102: C531.2 35.3,159.9 35.3,158.28 35.23,158.21 U629.28
MXM_DPC_HPD: length 71.5
  TOP w0.102: U629.3 v1(39.58,150.2)
  IN3 w0.127: v1(61.78,113.45) 61.78,124.96 63.3,126.47 63.3,128.5 63.25,128.54 63.25,129.88 62.45,130.68 62.45,131.57 59.22,134.8 59.22,136.13 58.73,136.62 51.98,136.62 49.68,138.92 48.5,138.92 48.07,138.49 44.65,138.49 44.23,138.91 44.23,139.32 42.78,140.76 42.03,140.76 41.03,141.77 41.03,148.75 v1(39.58,150.2)
  BOTTOM w0.102: U25.2 65.95,102.83 65.77,103.01 64.9,103.01 64.25,102.35 63.48,102.35 63.23,102.6 63.23,104.51 D7.2 62.26,106.17 v2(62.26,109.57) 62.26,112.96 v1(61.78,113.45)
MXM_DPC_HPD_GATE: length 5.5
  TOP w0.102: v1(67.34,99.54) 67.28,99.54 65.97,98.23 65.97,97.62 66,97.6 JMXM1.262
  BOTTOM w0.102: v2(67.86,99.25) 67.57,99.54 v1(67.34,99.54) 66.82,99.54 66.6,99.77 U25.4
MXM_DPC_N0: length 66.3
  TOP w0.102: C524.1 42.45,148.32 43.29,148.32 43.64,148.66 44.6,148.66 44.71,148.77 45.32,148.77 v1(45.53,148.98) ; JMXM1.229 74.75,105.71 74.63,105.83 74.63,106.51 73.53,107.62 73.53,108 v1(73.76,108.23)
  IN1 w0.117: v1(45.53,148.98) 45.65,148.86 46.51,148.86 48.12,147.25 48.12,142.68 48.52,142.28 49.75,142.28 52.71,139.32 56.81,139.32 57.63,138.5 58.78,138.5 61.63,135.64 61.63,134.81 62.37,134.06 62.37,119.39 62.73,119.03 62.73,116.46 68.73,110.46 69.69,110.46 70.46,109.69 72.79,109.69 73.62,108.86 73.62,108.36 v1(73.76,108.23)
MXM_DPC_N0_C: length 3.4
  TOP w0.102: U629.2 39.22,149.8 39.29,149.73 39.61,149.73 40.21,149.13 40.21,148.83 40.28,148.76 40.73,148.31 40.92,148.31 C524.2
MXM_DPC_N1: length 65.1
  TOP w0.102: v1(44.26,149.79) 44.03,149.57 43.65,149.57 43.11,150.1 42.45,150.1 C526.1 ; JMXM1.235 73.25,105.71 73.13,105.83 73.13,106.36 72.22,107.27 72.22,108 v1(72.42,108.2)
  IN1 w0.117: v1(72.42,108.2) 72.29,108.34 72.29,108.64 72.02,108.91 70.14,108.91 69.64,109.41 68.6,109.41 61.95,116.06 61.95,118.72 61.59,119.07 61.59,133.52 59.92,135.2 59.92,135.86 58.89,136.88 58.05,136.88 56.6,138.33 51.84,138.33 49.25,140.92 48.66,140.92 47.27,142.31 47.27,145.79 45.02,148.04 45.02,149.38 44.73,149.67 44.38,149.67 v1(44.26,149.79)
MXM_DPC_N1_C: length 3
  TOP w0.102: U629.5 39.23,151 39.29,150.94 39.91,150.94 40.33,150.52 40.75,150.09 40.92,150.09 C526.2
MXM_DPC_N2: length 66.4
  TOP w0.102: C528.1 42.45,151.88 42.93,151.88 v1(43.14,152.08) ; v1(71.84,106.21) 71.63,106 71.63,105.83 71.75,105.71 JMXM1.241
  IN1 w0.117: v1(43.14,152.08) 43.26,151.95 43.58,151.95 43.9,151.64 43.9,150.6 43.75,150.45 43.75,148.31 43.19,147.75 43.19,147.15 44.15,146.19 44.15,142.01 45.39,140.77 46.93,140.77 48.54,139.15 49.74,139.15 51.4,137.49 56.32,137.49 60.81,133 60.81,116.08 68.63,108.26 69.69,108.26 69.82,108.13 70.22,108.13 71.7,106.65 71.7,106.35 v1(71.84,106.21)
MXM_DPC_N2_C: length 2.7
  TOP w0.102: C528.2 40.93,151.88 40.53,151.88 40.38,151.73 v3(39.98,151.73) 39.3,151.73 39.24,151.8 U629.7
MXM_DPC_N3: length 72
  TOP w0.102: v1(70.29,103.46) 70.13,103.63 70.13,104.1 70.25,104.23 JMXM1.247 ; C530.1 42.34,153.77 42.49,153.77 42.77,154.05 43.34,154.05 43.67,153.72 43.67,153.44 v1(43.81,153.3)
  IN1 w0.117: v1(43.81,153.3) 43.64,153.13 43.64,152.89 43.32,152.56 42.78,152.56 42.5,152.29 42.5,148.17 42.1,147.76 42.1,142.95 45.42,139.63 45.63,139.63 49.21,136.05 55.8,136.05 60.03,131.83 60.03,114.52 62.49,112.06 62.49,111.5 62.74,111.24 64.54,111.24 68.31,107.47 69.08,107.47 70.1,106.45 70.1,103.66 v1(70.29,103.46)
MXM_DPC_N3_C: length 3
  TOP w0.102: C530.2 40.93,153.66 40.62,153.66 v3(40.24,153.27) 39.9,152.93 39.29,152.93 39.22,153 U629.10
MXM_DPC_P0: length 66.3
  TOP w0.102: JMXM1.231 74.25,105.7 74.37,105.81 74.37,106.4 73.33,107.44 73.33,108.06 73.16,108.23 v1(73.05,108.23) ; v1(45.53,148.27) 45.29,148.51 44.82,148.51 44.71,148.4 43.75,148.4 43.4,148.05 42.46,148.05 C523.1
  IN1 w0.117: v1(73.05,108.23) 73.22,108.23 73.34,108.34 73.34,108.74 72.67,109.41 70.35,109.41 69.58,110.18 68.61,110.18 62.45,116.34 62.45,118.92 62.09,119.28 62.09,133.95 61.34,134.69 61.34,135.52 58.66,138.21 57.51,138.21 56.69,139.03 52.6,139.03 49.64,141.99 48.4,141.99 47.83,142.56 47.83,147.14 46.39,148.58 45.61,148.58 45.53,148.49 v1(45.53,148.27)
MXM_DPC_P0_C: length 3.4
  TOP w0.102: U629.1 39.24,149.4 39.3,149.46 39.5,149.46 39.95,149.02 39.95,148.72 v3(40.09,148.58) 40.62,148.04 40.93,148.04 C523.2
MXM_DPC_P1: length 65
  TOP w0.102: v1(44.26,149.08) 44.04,149.3 43.54,149.3 43,149.83 42.46,149.83 C525.1 ; JMXM1.237 72.75,105.7 72.87,105.81 72.87,106.25 71.95,107.16 71.95,108.07 71.83,108.2 v1(71.71,108.2)
  IN1 w0.117: v1(44.26,149.08) 44.26,149.31 44.33,149.38 44.61,149.38 44.73,149.26 44.73,147.92 46.98,145.67 46.98,142.2 48.54,140.64 49.13,140.64 51.72,138.05 56.49,138.05 57.93,136.6 58.78,136.6 59.64,135.74 59.64,135.08 61.31,133.41 61.31,118.95 61.66,118.6 61.66,115.94 68.48,109.12 69.52,109.12 70.02,108.63 71.9,108.63 72,108.52 72,108.31 71.89,108.2 v1(71.71,108.2)
MXM_DPC_P1_C: length 3
  TOP w0.102: C525.2 40.92,149.83 40.64,149.83 v3(40.14,150.33) 39.8,150.67 39.28,150.67 39.2,150.6 U629.4
MXM_DPC_P2: length 66.4
  TOP w0.102: v1(71.13,106.21) 71.24,106.21 71.37,106.08 71.37,105.81 71.25,105.7 JMXM1.243 ; v1(43.14,151.37) 42.9,151.61 42.46,151.61 C527.1
  IN1 w0.117: v1(43.14,151.37) 43.14,151.59 43.21,151.67 43.46,151.67 43.62,151.52 43.62,150.72 43.47,150.57 43.47,148.43 42.91,147.87 42.91,147.03 43.87,146.07 43.87,141.89 45.27,140.49 46.81,140.49 48.43,138.87 49.62,138.87 51.28,137.21 56.2,137.21 60.53,132.88 60.53,115.96 68.52,107.97 69.57,107.97 69.7,107.84 70.11,107.84 71.42,106.53 71.42,106.32 71.3,106.21 v1(71.13,106.21)
MXM_DPC_P2_C: length 2.7
  TOP w0.102: U629.6 39.23,151.4 39.3,151.46 40.49,151.46 40.64,151.61 40.92,151.61 C527.2
MXM_DPC_P3: length 72
  TOP w0.102: C529.1 42.15,153.43 42.22,153.5 42.6,153.5 42.88,153.78 43.23,153.78 43.4,153.61 43.4,153.38 43.33,153.3 v1(43.18,153.3) ; JMXM1.249 69.75,104.23 69.86,104.13 69.86,103.62 v1(69.71,103.46)
  IN1 w0.117: v1(69.71,103.46) 69.82,103.57 69.82,106.33 68.96,107.19 68.2,107.19 64.42,110.96 62.62,110.96 62.2,111.38 62.2,111.94 59.74,114.4 59.74,131.71 55.68,135.77 49.09,135.77 45.52,139.34 45.3,139.34 41.81,142.83 41.81,147.88 42.22,148.28 42.22,152.41 42.66,152.85 43.21,152.85 43.35,152.99 43.35,153.12 v1(43.18,153.3)
MXM_DPC_P3_C: length 3
  TOP w0.102: U629.9 39.21,152.6 39.28,152.66 40.01,152.66 40.73,153.39 40.92,153.39 C529.2
MXM_EDP_AUX: length 69.3
  TOP w0.102: C566.1 64.3,147.74 64.3,148.24 v1(64.28,148.25) ; JMXM1.260 66.5,95.24 66.81,94.93 67.34,94.93 v1(67.37,94.91)
  IN1 w0.117: v1(67.37,94.91) 67.31,94.97 66.92,94.97 66.59,95.3 66.59,97.22 67.99,98.62 67.99,99.48 74.29,105.79 74.29,108.91 73.01,110.19 70.67,110.19 69.85,111.01 69.02,111.01 63.23,116.8 63.23,119.24 62.91,119.57 62.91,126.04 63.24,126.37 63.24,128.21 63.05,128.39 63.05,129.32 64.06,130.33 64.06,132.33 64.89,133.16 64.89,135.3 63.05,137.14 63.05,144.58 64.32,145.85 64.32,148.22 v1(64.28,148.25)
MXM_EDP_AUX#: length 69.2
  TOP w0.102: JMXM1.258 67,95.97 66.95,95.92 66.82,95.92 66.77,95.86 66.77,95.36 66.92,95.2 67.08,95.2 v1(67.37,95.49) ; v1(64.87,148.25) 64.58,147.96 64.58,147.75 64.78,147.55 C568.1
  IN1 w0.117: v1(67.37,95.49) 67.13,95.25 67.04,95.25 66.87,95.42 66.87,97.1 68.27,98.5 68.27,99.37 74.58,105.67 74.58,109.03 73.13,110.48 70.79,110.48 69.97,111.29 69.14,111.29 63.52,116.92 63.52,119.36 63.19,119.68 63.19,125.92 63.52,126.25 63.52,128.33 63.34,128.51 63.34,129.2 64.35,130.22 64.35,132.21 65.18,133.04 65.18,135.41 63.34,137.25 63.34,144.47 64.61,145.74 64.61,147.99 v1(64.87,148.25)
MXM_EDP_AUX#_C: length 2.4
  TOP w0.102: U630.27 64.37,145.12 64.3,145.2 64.3,145.48 64.66,145.84 64.66,146.3 C568.2
MXM_EDP_AUX_C: length 2.4
  TOP w0.102: U630.28 63.97,145.16 64.03,145.22 64.03,145.59 64.4,145.96 64.4,146.34 C566.2
MXM_EDP_HPD: length 66.2
  TOP w0.102: v1(67.34,94.27) 66.61,94.27 65.5,95.38 JMXM1.264 ; U630.3 v1(68.32,137.07)
  IN1 w0.109: v1(67.34,94.27) 67.85,93.76 73.29,93.76 75.21,95.69 78.48,95.69 80.24,97.45 80.24,109.08 79.88,109.45 79.88,116.14 79.47,116.55 79.47,119.39 79.04,119.82 79.04,123.27 75.12,127.2 75.12,133.86 73.29,135.68 v1(73.29,136.18)
  IN4 w0.109: v1(68.32,137.07) 69.25,136.14 73.25,136.14 v1(73.29,136.18)
MXM_EDP_LANE_N0: length 61.9
  TOP w0.102: v1(73.17,95.6) 73.13,95.64 72.64,95.64 72.59,95.69 72.59,95.82 72.75,95.98 72.94,95.98 73,96.04 JMXM1.234 ; C556.1 71.16,135.02 71.47,134.71 71.93,134.71 72.16,134.48 72.16,134.02 v1(72.31,133.87)
  IN1 w0.117: v1(73.17,95.6) 72.86,95.6 72.77,95.69 72.77,96.26 76.62,100.11 76.62,100.66 75.46,101.82 75.46,102 75.71,102.25 75.89,102.25 76.81,101.33 77.22,101.33 77.67,101.78 77.67,102.2 77.01,102.86 77.01,103.04 77.25,103.27 77.43,103.27 78.14,102.57 78.66,102.57 79.06,102.97 79.06,103.49 78.1,104.45 78.1,104.65 78.97,105.51 78.97,109.84 76.64,112.17 76.09,112.17 73.88,114.38 73.88,114.72 72.6,116 68.86,116 66.66,118.2 66.66,120.64 66.41,120.89 66.41,124.57 66.66,124.82 66.66,126.51 72.07,131.92 72.07,133.63 v1(72.31,133.87)
MXM_EDP_LANE_N0_C: length 3.8
  TOP w0.102: U630.2 67.97,136.67 68.04,136.6 68.26,136.6 69.07,135.79 69.07,135.11 69.49,134.69 69.59,134.69 C556.2
MXM_EDP_LANE_N1: length 62.3
  TOP w0.102: v1(72.3,135.2) 72.14,135.36 72.14,135.82 71.3,136.66 71.06,136.66 C559.1 ; JMXM1.240 71.5,96 71.43,95.93 71.34,95.93 71.27,95.86 71.27,95.33 71.33,95.26 v1(71.6,95.26)
  IN1 w0.117: v1(72.3,135.2) 72.07,134.97 72.07,134.66 71.81,134.4 71.27,134.4 70.73,133.86 70.73,131.69 65.87,126.83 65.87,125.15 65.58,124.86 65.58,120.61 65.87,120.33 65.87,117.88 69.04,114.71 72.41,114.71 75.79,111.33 76.33,111.33 77.97,109.69 77.97,106.62 77.73,106.38 77.73,105.38 74.39,102.05 74.39,101.78 75.36,100.81 75.36,100.4 74.92,99.96 74.51,99.96 73.49,100.97 73.31,100.97 73.09,100.75 73.09,100.57 74.25,99.41 74.25,98.85 71.15,95.76 71.15,95.33 71.28,95.21 71.55,95.21 v1(71.6,95.26)
MXM_EDP_LANE_N1_C: length 3.5
  TOP w0.102: C559.2 69.63,136.57 69.41,136.57 69.12,136.86 69.12,137.42 68.74,137.8 68.22,137.8 68.15,137.87 U630.5
MXM_EDP_LANE_N2: length 64.5
  TOP w0.102: v1(72.3,137.59) 72.14,137.75 72.14,137.96 71.59,138.52 71.06,138.52 C571.1 ; v1(70.37,95.69) 70.3,95.63 70.05,95.63 69.86,95.82 69.86,95.91 69.91,95.96 69.95,95.96 70,96.01 JMXM1.246
  IN1 w0.117: v1(72.3,137.59) 72.03,137.32 72.03,136.96 71.55,136.48 71.55,136.35 71.27,136.07 71.13,136.07 70.86,135.8 70.86,135.67 70.65,135.46 70.52,135.46 70.3,135.24 70.3,135.11 70.07,134.88 69.95,134.88 69.8,134.73 69.8,131.86 65.09,127.15 65.09,125.49 64.79,125.19 64.79,120.3 65.09,120 65.09,117.56 69.12,113.53 71.01,113.53 71.66,112.88 72.94,112.88 75.28,110.54 76.01,110.54 77.18,109.37 77.18,107.02 76.84,106.68 76.84,105.63 71.97,100.76 71.97,100.58 73.21,99.34 73.21,98.93 72.81,98.53 72.39,98.53 71.13,99.78 70.95,99.78 70.58,99.41 70.58,99.23 71.58,98.22 71.58,97.56 71.23,97.22 70.39,97.22 70.22,97.05 70.22,95.84 v1(70.37,95.69)
MXM_EDP_LANE_N2_C: length 2.7
  TOP w0.102: C571.2 69.61,138.4 69.42,138.4 69.22,138.6 68.22,138.6 68.15,138.67 U630.7
MXM_EDP_LANE_N3: length 64.7
  TOP w0.102: v1(68.71,95.39) 68.37,95.39 68.27,95.49 68.27,95.85 68.33,95.91 68.45,95.91 68.5,95.97 JMXM1.252 ; C562.1 71.1,140.33 71.41,140.33 71.53,140.21 71.76,140.21 71.89,140.33 71.96,140.33 v1(72.26,140.64)
  IN1 w0.117: v1(68.71,95.39) 68.63,95.31 68.63,95.15 68.78,95.01 68.92,95.01 69.13,95.22 69.13,99.48 75.66,106 75.66,107.11 76.1,107.55 76.1,108.88 75.61,109.38 74.93,109.38 72.51,111.8 71.17,111.8 70.54,112.42 68.72,112.42 64.02,117.12 64.02,119.56 63.72,119.86 63.72,125.63 64.02,125.93 64.02,127.6 68.64,132.22 68.64,136.34 69.93,137.63 69.93,139.68 70.63,140.38 72,140.38 v1(72.26,140.64)
MXM_EDP_LANE_N3_C: length 2.8
  TOP w0.102: C562.2 69.58,140.23 69.39,140.23 68.93,139.78 v3(68.65,139.78) 68.22,139.78 68.12,139.87 U630.10
MXM_EDP_LANE_P0: length 61.7
  TOP w0.102: v1(71.72,133.87) 71.89,134.04 71.89,134.37 71.82,134.44 71.36,134.44 71.25,134.55 70.95,134.55 70.83,134.44 C557.1 ; JMXM1.236 72.5,96.11 72.32,95.93 72.32,95.58 72.74,95.17 v1(72.74,95.17)
  IN1 w0.117: v1(71.72,133.87) 71.78,133.81 71.78,132.04 66.37,126.63 66.37,124.94 66.12,124.69 66.12,120.77 66.37,120.52 66.37,118.08 68.74,115.72 72.48,115.72 73.59,114.61 73.59,114.26 75.97,111.88 76.53,111.88 78.69,109.73 78.69,105.63 77.82,104.76 77.82,104.33 78.78,103.37 78.78,103.09 78.54,102.85 78.25,102.85 77.55,103.56 77.13,103.56 76.73,103.16 76.73,102.74 77.39,102.08 77.39,101.9 77.11,101.62 76.93,101.62 76.01,102.53 75.6,102.53 75.18,102.11 75.18,101.7 76.34,100.54 76.34,100.23 72.48,96.37 72.48,95.57 72.74,95.32 v1(72.74,95.17)
MXM_EDP_LANE_P0_C: length 3.8
  TOP w0.102: U630.1 67.98,136.27 68.05,136.34 68.14,136.34 68.8,135.68 v3(68.8,135.29) 68.8,135 69.38,134.43 69.6,134.43 C557.2
MXM_EDP_LANE_P1: length 62.3
  TOP w0.102: JMXM1.242 71,95.22 71.17,95.05 v1(71.17,94.8) ; C561.1 70.83,136.24 70.98,136.4 71.19,136.4 71.88,135.71 71.88,135.36 v1(71.72,135.2)
  IN1 w0.117: v1(71.72,135.2) 71.79,135.13 71.79,134.78 71.7,134.69 71.15,134.69 70.44,133.98 70.44,131.81 65.58,126.95 65.58,125.26 65.29,124.97 65.29,120.5 65.58,120.21 65.58,117.76 68.92,114.42 72.29,114.42 75.67,111.04 76.22,111.04 77.68,109.58 77.68,106.74 77.44,106.5 77.44,105.5 74.11,102.16 74.11,101.66 75.07,100.69 75.07,100.51 74.8,100.24 74.62,100.24 73.61,101.26 73.19,101.26 72.81,100.87 72.81,100.46 73.97,99.3 73.97,98.97 70.87,95.87 70.87,95.21 71.17,94.92 v1(71.17,94.8)
MXM_EDP_LANE_P1_C: length 3.5
  TOP w0.102: C561.2 69.57,136.31 69.3,136.31 68.86,136.75 v3(68.86,137.02) 68.86,137.31 68.63,137.54 68.22,137.54 68.15,137.47 U630.4
MXM_EDP_LANE_P2: length 64.5
  TOP w0.102: v1(69.94,95.24) 69.94,95.36 69.59,95.71 69.59,95.95 69.5,96.04 JMXM1.248 ; C573.1 70.85,138.2 70.9,138.25 71.48,138.25 71.87,137.85 71.87,137.75 v1(71.71,137.59)
  IN1 w0.117: v1(69.94,95.24) 69.94,97.16 70.27,97.5 71.11,97.5 71.29,97.68 71.29,98.11 70.29,99.11 70.29,99.52 70.84,100.07 71.25,100.07 72.51,98.81 72.69,98.81 72.92,99.05 72.92,99.23 71.68,100.47 71.68,100.88 76.55,105.75 76.55,106.8 76.89,107.14 76.89,109.26 75.89,110.26 75.16,110.26 72.83,112.59 71.54,112.59 70.89,113.24 69,113.24 64.8,117.44 64.8,119.88 64.51,120.18 64.51,125.31 64.8,125.61 64.8,127.27 69.51,131.98 69.51,134.85 71.74,137.08 71.74,137.56 v1(71.71,137.59)
MXM_EDP_LANE_P2_C: length 2.7
  TOP w0.102: C573.2 69.61,138.14 69.31,138.14 69.11,138.34 v3(68.79,138.34) 68.22,138.34 68.15,138.27 U630.6
MXM_EDP_LANE_P3: length 64.7
  TOP w0.102: v1(68.28,94.93) 68.28,95.1 68,95.38 JMXM1.254 ; v1(72.26,140.05) 72.25,140.07 72,140.07 71.87,139.94 71.42,139.94 71.3,140.07 71.17,140.07 70.85,139.75 C564.1
  IN1 w0.117: v1(72.26,140.05) 72.22,140.09 70.75,140.09 70.22,139.56 70.22,137.51 68.92,136.22 68.92,132.1 64.3,127.48 64.3,125.82 64,125.52 64,119.98 64.3,119.68 64.3,117.23 68.84,112.7 70.66,112.7 71.28,112.08 72.63,112.08 75.05,109.66 75.72,109.66 76.39,109 76.39,107.43 75.95,106.99 75.95,105.89 69.42,99.36 69.42,95.1 69.04,94.72 68.66,94.72 68.45,94.93 v1(68.28,94.93)
MXM_EDP_LANE_P3_C: length 2.8
  TOP w0.102: C564.2 69.64,139.96 69.5,139.96 69.04,139.51 68.17,139.51 68.12,139.47 U630.9
MXM_ENVDD: length 112.9
  TOP w0.102: JMXM1.59 118.75,105.6 118.04,106.31 117.79,106.31 117.51,106.59 117.51,106.98 117.89,107.36 v2(117.89,111.55) 117.89,114.24 v1(115.68,116.44)
  IN3 w0.127: v1(115.68,116.44) 114.64,115.4 112.05,115.4 108.72,118.73 107.57,118.73 103.82,122.49 103.82,123.45 100.87,126.39 100.87,129.39 98.29,131.98 97.67,131.98 90.51,139.14 90.51,144.57 86.9,148.18 78.74,148.18 77.25,149.67 60.09,149.67 55.74,145.32 54.27,145.32 49.56,140.61 48.59,140.61 47.59,139.61 46.26,139.61 43.32,142.56 v1(43.32,142.63)
  BOTTOM w0.102: v1(43.32,142.63) 43.32,143.63 D6.3
MXM_MB_DP_AUX: length 228.7
  TOP w0.102: v1(54.94,107.35) 54.78,107.2 54.45,107.2 54.15,106.89 54.15,106.56 54.82,105.89 54.82,105.8 54.75,105.73 JMXM1.309
  IN1 w0.109: v1(240.9,78.65) 241.2,78.35 241.2,77.94 242.29,76.85 242.29,76.56 v1(242.08,76.35)
  IN4 w0.109: v5(239.76,81.13) 239.46,81.43 239.46,81.77 239.07,82.16 234.57,82.16 233.27,83.46 225.59,83.46 222.72,80.58 222.72,78.01 221.12,76.41 219.69,76.41 217.34,74.06 215.97,74.06 214.19,72.28 212.88,72.28 212.39,72.77 212.39,73.28 210.88,74.79 210.88,77.63 209.41,79.11 209.41,81.52 206.92,84.01 204.07,84.01 193.46,94.63 187.72,94.63 182.19,100.15 181.66,100.15 176.99,104.82 165.49,104.82 163.55,106.75 126.95,106.75 125.76,107.94 116.03,107.94 115.91,108.06 83.55,108.06 81.99,109.62 75.08,109.62 74.36,108.89 66.82,108.89 64.55,111.17 60.57,111.17 56.58,107.18 55.11,107.18 v1(54.94,107.35)
  BOTTOM w0.089: 239.56,81.57 239.56,81.74 239.58,81.76 U22.33
  BOTTOM w0.102: Q340.1 241.85,76.58 v1(242.08,76.35) ; 239.56,81.57 239.56,81.33 v5(239.76,81.13) 239.67,81.13 239.44,80.9 239.44,79.27 240.56,78.15 241.22,78.15 241.33,78.27 241.33,78.55 241.18,78.7 240.95,78.7 ; 240.95,78.7 v1(240.9,78.65) ; 240.95,78.7 241.19,78.94 241.19,79.09 C397.1
MXM_MB_DP_AUX#: length 229.2
  TOP w0.102: v1(54.94,106.77) 54.94,106.82 54.78,106.97 54.55,106.97 54.41,106.83 54.41,106.63 55.05,105.99 55.05,105.9 55.25,105.7 JMXM1.307
  IN1 w0.109: v1(241.73,78.65) 241.43,78.35 241.43,78.04 242.53,76.95 242.53,76.57 v1(242.72,76.38)
  IN4 w0.109: v1(54.94,106.77) 55.11,106.94 56.68,106.94 60.66,110.93 64.45,110.93 66.72,108.66 74.45,108.66 75.18,109.38 81.89,109.38 83.45,107.83 115.81,107.83 115.93,107.71 125.66,107.71 126.85,106.52 163.45,106.52 165.39,104.58 176.89,104.58 181.56,99.91 182.1,99.91 187.62,94.39 193.36,94.39 203.97,83.77 206.82,83.77 209.17,81.42 209.17,79.01 210.64,77.54 210.64,74.69 212.15,73.18 212.15,72.68 212.78,72.05 214.29,72.05 216.07,73.82 217.44,73.82 219.79,76.18 221.21,76.18 222.95,77.92 222.95,80.48 225.69,83.22 233.18,83.22 234.47,81.93 238.97,81.93 239.22,81.67 239.22,81.35 239.03,81.15 v1(238.9,81.15)
  BOTTOM w0.102: 238.98,81.15 v1(238.9,81.15) ; 238.98,81.15 239.03,81.15 239.14,81.04 239.25,81.04 239.33,81.11 239.33,81.65 239.29,81.68 239.15,81.68 239.08,81.76 U22.34 ; 238.98,81.15 238.98,81.09 239.21,80.86 239.21,79.18 240.46,77.93 v3(240.7,77.93) 241.31,77.93 241.56,78.18 241.56,78.48 v1(241.73,78.65) 241.59,78.65 241.42,78.81 241.42,79.04 C398.1 ; Q340.4 243.15,75.8 242.72,76.24 v1(242.72,76.38)
MXM_MB_DP_AUX#_C: length 2.3
  BOTTOM w0.102: U22.29 241.58,81.89 241.45,81.76 241.45,80.64 C398.2
MXM_MB_DP_AUX_C: length 2.3
  BOTTOM w0.102: C397.2 241.22,80.64 241.22,81.76 241.08,81.9 U22.30
MXM_MB_DP_HPD: length 208.6
  IN2 w0.127: v1(242.08,90.31) 241.11,91.27 230.01,91.27 228.08,89.34 218.46,89.34 217.92,89.89 209.7,89.89 206.94,92.64 205.13,92.64 199.92,97.85 199.09,97.85 196.45,100.49 188.52,100.49 182.26,106.75 177.86,106.75 175.79,108.82 158.01,108.82 157.11,107.92 119.55,107.92 118.69,108.78 118.08,108.78 117.15,107.86 84.24,107.86 83.08,106.7 80.29,106.7 79.93,107.06 73.39,107.06 71.36,105.02 71.36,103.78 68.33,100.75 67.18,100.75 66.72,100.29 60.94,100.29 59.77,101.46 v1(59.66,101.46)
  BOTTOM w0.102: D8.2 57.64,103.55 56.35,103.55 55.58,102.79 55.58,101.61 55.79,101.41 56.37,101.41 56.68,101.71 U27.2 56.68,102.7 57.05,103.08 57.48,103.08 59.01,101.55 v2(59.11,101.55) 59.57,101.55 v1(59.66,101.46) ; v1(242.08,90.31) U22.9
MXM_MB_DP_HPD_GATE: length 7.6
  TOP w0.102: JMXM1.304 55.5,97.57 55.37,97.7 55.37,99.39 55.79,99.81 v1(58.45,99.81)
  BOTTOM w0.102: U27.4 58.08,100.6 58.45,100.23 v1(58.45,99.81)
MXM_MB_DP_N0: length 6.3
  TOP w0.102: C284.1 63.36,109.89 63.36,109.48 61.13,107.26 v3(61.13,106.83) 61.13,105.87 61.25,105.75 JMXM1.283
MXM_MB_DP_N0_C: length 191.2
  TOP w0.102: v1(63.53,111.8) 63.35,111.61 63.35,111.42 C284.2
  IN4 w0.117: v5(236.13,84.03) 235.95,83.86 235.95,83.54 235.64,83.23 234.32,83.23 232.98,84.56 228.78,84.56 227.02,86.32 223.55,86.32 223.07,85.84 211.01,85.84 210.17,86.68 202.43,86.68 197.16,91.94 197.16,92.57 194.6,95.13 187.91,95.13 182.34,100.7 181.86,100.7 177.09,105.47 165.82,105.47 164.04,107.25 158.6,107.25 157.94,107.91 127.06,107.91 126.49,108.48 119.24,108.48 118.82,108.9 117.53,108.9 117.2,108.57 83.74,108.57 82.19,110.12 77.25,110.12 77.12,110.24 74.97,110.24 74.12,109.39 67.06,109.39 64.05,112.4 63.6,112.4 63.36,112.16 63.36,111.97 v1(63.53,111.8)
  BOTTOM w0.102: v5(236.13,84.03) 236.08,84.03 235.78,83.74 235.78,83.59 235.9,83.48 236.36,83.48 236.74,83.86 236.74,84.06 236.82,84.14 U22.39
MXM_MB_DP_N1: length 6.2
  TOP w0.102: JMXM1.289 59.75,105.75 59.63,105.87 59.63,107.37 v3(60.2,107.94) 61.58,109.32 61.58,109.89 C283.1
MXM_MB_DP_N1_C: length 193.2
  TOP w0.102: C283.2 61.57,111.42 61.57,111.64 v1(61.73,111.8)
  IN4 w0.117: v5(236.1,86.22) 235.92,86.04 235.92,85.71 235.64,85.43 234.58,85.43 233.81,86.2 232.62,86.2 232.04,85.62 229.13,85.62 227.62,87.13 223.04,87.13 222.61,86.7 211.54,86.7 210.68,87.56 204.79,87.56 203.17,89.18 201.03,89.18 198.28,91.94 198.28,92.63 194.25,96.66 190.51,96.66 189.8,97.37 186.8,97.37 176.97,107.2 165.87,107.2 163.89,109.18 127.39,109.18 125.65,110.92 90.03,110.92 89.59,110.48 82.97,110.48 82.53,110.92 77.62,110.92 77.51,111.03 74.65,111.03 73.8,110.18 67.54,110.18 64.52,113.19 62.59,113.19 61.58,112.18 61.58,111.95 v1(61.73,111.8)
  BOTTOM w0.102: v5(236.1,86.22) 236.05,86.22 235.73,85.9 235.73,85.74 236.07,85.4 236.63,85.4 236.69,85.46 236.69,85.56 236.77,85.64 U22.42
