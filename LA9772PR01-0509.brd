# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCI_MEC: length 148.1
  TOP w0.102: RH160.2 CH16.1 22.18,113.22 22.18,113.7 v1(22.59,114.11)
  IN1 w0.109: v1(97.04,150.61) 96.76,150.61 94.95,152.41 94.95,158.78 93.04,160.69 86.88,160.69 86.36,160.17 79.42,160.17 78.37,159.12 74,159.12 73.69,159.42 64.97,159.42 63.42,157.87 56.09,157.87 55.41,157.19 51.87,157.19 50.71,158.34 47.38,158.34 46.5,159.22 46.01,159.22 42.66,162.57 36.79,162.57 34.55,160.33 30.82,160.33 29.93,159.45 29.93,158.79 28.81,157.67 28.81,153.49 28.23,152.9 28.23,152.06 29.19,151.09 29.19,149.95 29.02,149.77 29.02,145.77 29.77,145.02 29.77,139.12 30.36,138.53 30.36,137.3 29.78,136.71 29.78,134.47 30.29,133.96 30.29,127.29 28.58,125.59 28.58,124.47 26.59,122.48 19.62,122.48 18.8,121.66 18.8,121.14 19.1,120.85 19.29,120.85 20.47,119.66 20.47,118.97 20.81,118.63 20.81,115.89 v1(22.59,114.11)
  BOTTOM w0.102: v1(97.04,150.61) 97.75,150.61 v2(98.31,150.04) 99.51,148.84 R885.1 101.5,148.9 U51.A29
CLK_PCI_TPM: length 262.1
  TOP w0.102: v1(14.82,109.1) 14.94,109.23 16.98,109.23 CH78.1 18.14,110.4 RH155.1
  IN1 w0.109: v1(165.74,118.29) 165.74,119.11 166.04,119.41 166.04,127.21 163.58,129.67 157.27,129.67 152.18,134.76 152.18,136.84 150.31,138.71 148.52,138.71 147.84,139.38 147.84,141.16 146.27,142.72 146.27,146.25 140.83,151.7 134.35,151.7 133.99,151.34 132.15,151.34 128.41,155.09 126.78,155.09 126.02,155.84 126.02,158.04 125.37,158.68 125.37,159.35 118.32,166.41 116.85,166.41 116.47,166.79 114.1,166.79 110.26,170.63 104.69,170.63 102.42,168.36 101.02,168.36 98.89,166.23 98.89,165.69 95.64,162.44 86.11,162.44 85.53,163.02 73.13,163.02 72.4,162.29 67.37,162.29 66.2,161.13 64.62,161.13 62.91,159.42 57.89,159.42 57.16,160.15 54.14,160.15 51.6,162.69 51.6,164.32 49.4,166.51 46.28,166.51 44.52,164.75 33.26,164.75 31.03,162.52 29.98,162.52 29.45,161.99 28.28,161.99 26.88,160.59 26.53,160.59 25.72,159.78 25.72,154.05 26.33,153.44 26.33,151.62 25.95,151.24 25.95,146.38 27.18,145.15 27.18,143.25 28.24,142.18 28.24,137.45 27.64,136.85 27.64,136.21 28.27,135.58 28.27,130.88 23.34,125.94 23.17,125.94 21.4,124.17 18.92,124.17 16.34,121.6 16.34,118.82 16.91,118.25 16.91,116.05 14.69,113.83 14.69,111.29 14.26,110.86 14.26,109.66 v1(14.82,109.1)
  BOTTOM w0.102: RE5.1 160.11,114 U39.21 163.06,114 163.24,113.83 163.95,113.83 165.12,115 165.12,117.66 v1(165.74,118.29) ; v2(15.9,108.7) 15.85,108.75 14.99,108.75 14.82,108.93 v1(14.82,109.1)
CLK_PCIE_CARD: length 37
  TOP w0.076: UH1.AB45 33.42,108.41 33.36,108.47 33.36,108.62 33.46,108.72 33.61,108.72 33.68,108.79 33.68,109 33.63,109.05 33.63,109.07
  TOP w0.102: 33.63,109.07 33.63,109.36 33.51,109.47 33.51,109.78 33.63,109.89 33.63,110.2 33.51,110.31 33.51,110.62 33.63,110.73 33.63,111.38 33.55,111.46 33.55,113.43 33.41,113.57 33.41,113.75 33.33,113.83 33.1,113.83 v1(33.03,113.75) ; v1(10.22,108.93) 10.06,109.09 9.63,109.09 9.35,109.37 8.86,109.37 8.69,109.2 JIO1.7
  IN3 w0.127: v1(33.03,113.75) 33.28,113.75 33.41,113.88 33.41,114.06 33.13,114.34 31.91,114.34 29.8,116.44 19.67,116.44 15.71,112.48 15.43,112.48 12.94,109.99 11.54,109.99 10.75,109.21 10.5,109.21 v1(10.22,108.93)
CLK_PCIE_CARD#: length 37.1
  TOP w0.076: 33.89,109.07 33.89,109.05 33.84,109 33.84,108.29 33.64,108.09 33.64,107.61 UH1.AB43
  TOP w0.102: v1(33.82,113.75) 33.82,111.57 33.89,111.49 33.89,109.07 ; v1(10.22,109.54) 10.06,109.38 9.71,109.38 9.46,109.64 8.85,109.64 8.69,109.8 JIO1.5
  IN3 w0.127: v1(33.82,113.75) 33.71,113.85 33.71,114.18 33.26,114.64 32.04,114.64 29.93,116.75 19.54,116.75 15.58,112.79 15.3,112.79 12.81,110.3 11.41,110.3 10.65,109.54 v1(10.22,109.54)
CLK_PCIE_EXP: length 50.7
  TOP w0.076: UH1.AF45 35.2,108.37 35.2,108.23 35.11,108.14 35.01,108.14 34.83,108.32 34.83,108.49 35.1,108.76 35.1,110.19 35.4,110.49 35.4,110.56 35.4,110.56
  TOP w0.102: v1(9.74,103.8) 9.56,103.97 8.92,103.97 8.75,103.8 JIO1.25 ; 35.4,110.56 37.23,112.39 37.23,114.68 37.17,114.74 36.94,114.74 36.84,114.84 36.84,115.02 v1(36.89,115.07)
  IN3 w0.127: v1(9.74,103.8) 9.61,103.92 9.33,103.92 8.97,104.28 8.97,110.27 10.02,111.31 11.08,111.31 14.39,114.62 15.66,114.62 18.6,117.56 31.86,117.56 33.36,116.06 35.01,116.06 36.63,114.44 36.86,114.44 36.99,114.56 36.99,114.97 v1(36.89,115.07)
CLK_PCIE_EXP#: length 50.6
  TOP w0.076: UH1.AF43 35.16,107.96 35.47,108.27 35.47,108.69 35.26,108.9 35.26,110.12 35.51,110.37 35.58,110.37 35.59,110.38
  TOP w0.102: 35.59,110.38 37.31,112.09 37.5,112.28 v1(37.5,115.07) ; JIO1.23 8.73,104.4 8.89,104.23 9.54,104.23 v1(9.74,104.43)
  IN3 w0.127: v1(9.74,104.43) 9.74,104.3 9.66,104.23 9.46,104.23 9.28,104.4 9.28,110.15 10.14,111.01 11.21,111.01 14.51,114.31 15.78,114.31 18.73,117.26 31.73,117.26 33.23,115.76 34.88,115.76 35.18,115.46 35.18,115.36 35.18,115.36 35.18,115.28 35.48,114.99 35.55,114.99 35.65,114.99 35.92,114.72 35.92,114.62 35.92,114.62 35.92,114.54 36.22,114.25 36.29,114.25 36.39,114.25 36.51,114.13 36.99,114.13 37.3,114.44 37.3,114.95 37.42,115.07 v1(37.5,115.07)
CLK_PCIE_LAN: length 124.9
  TOP w0.076: UH1.AA42 33.13,107.52 33.16,107.55 33.45,107.83 33.45,108.08 33.19,108.33 33.19,108.81 33.24,108.86 33.24,108.88
  TOP w0.102: v1(32.72,115.07) 32.52,115.07 32.4,114.96 32.4,110.95 33.24,110.11 33.24,108.88
  IN4 w0.117: v1(32.72,115.07) 32.87,115.22 33.27,115.22 34.27,116.22 34.27,117.59 36.66,119.98 36.66,128.28 40.17,131.79 42.22,131.79 43.72,133.28 53.54,133.28 54,133.74 61.32,133.74 62.52,132.54 68.23,132.54 68.55,132.21 84.62,132.21 85.14,132.73 90.05,132.73 91.21,133.9 95.96,133.9 96.75,134.69 99.03,134.69 100.87,136.53 111.23,136.53 114,139.3 114,149.09 113.79,149.29 113.79,150.85 114.75,151.81 116.58,151.81 116.68,151.71 117.77,151.71 v1(117.94,151.55)
  BOTTOM w0.102: v1(117.94,151.55) 118.1,151.71 118.78,151.71 118.85,151.64 U31.44
CLK_PCIE_LAN#: length 124.9
  TOP w0.076: 32.98,108.88 32.98,108.86 33.03,108.81 33.03,108.29 32.8,108.06 32.8,107.94 32.88,107.86 33.05,107.86 UH1.AA44
  TOP w0.102: 32.98,108.88 32.98,110 32.13,110.84 32.13,115.07 v1(32.72,115.66)
  IN4 w0.117: v1(117.94,152.15) 117.79,152 116.8,152 116.7,152.1 114.64,152.1 113.51,150.97 113.51,149.17 113.71,148.97 113.71,139.42 111.11,136.82 100.75,136.82 98.91,134.97 96.63,134.97 95.84,134.19 91.1,134.19 89.93,133.02 85.03,133.02 84.51,132.5 68.67,132.5 68.35,132.82 62.64,132.82 61.43,134.03 53.88,134.03 53.42,133.56 43.6,133.56 42.11,132.07 40.05,132.07 36.38,128.4 36.38,120.1 33.98,117.71 33.98,116.33 33.16,115.5 32.88,115.5 v1(32.72,115.66)
  BOTTOM w0.102: U31.45 118.82,152.04 118.75,151.97 118.12,151.97 v1(117.94,152.15)
CLK_PCIE_MINI1: length 317.8
  TOP w0.102: UH1.Y45 32.79,108.41 32.85,108.47 32.85,108.72 32.8,108.77 32.6,108.77 32.55,108.82 32.55,109.69 32.27,109.96 32.27,110.09 32.03,110.33 31.9,110.33 31.69,110.55 31.69,110.67 31.45,110.91 31.32,110.91 30.82,111.42 30.82,113.57 30.49,113.9 30.13,113.9 30.01,114.03 v1(30.01,114.18)
  IN4 w0.117: v1(30.01,114.18) 30.21,113.98 30.36,113.98 30.48,114.1 30.48,116.44 32.47,118.42 32.47,119.03 34.45,121.01 34.45,121.6 34.8,121.95 34.8,129.06 39.44,133.7 41.32,133.7 43.19,135.57 53.17,135.57 54.51,136.92 61.51,136.92 62.37,136.07 66.43,136.07 66.95,135.55 67.98,135.55 68.78,134.74 73.49,134.74 74.3,135.55 80.83,135.55 82.22,134.16 82.99,134.16 85.4,136.57 88.16,136.57 88.96,135.77 95.15,135.77 96.55,137.17 97.03,137.17 98.68,138.83 105.43,138.83 105.8,138.46 108.82,138.46 110.28,139.92 110.48,139.92 112.15,141.59 112.15,147.79 111.94,148 111.94,151.62 114.62,154.3 115.23,154.3 115.44,154.51 119.19,154.51 120.12,153.58 126.45,153.58 126.77,153.26 128.89,153.26 130.04,154.41 130.04,154.65 130.66,155.27 132.16,155.27 134.24,153.19 134.24,152.77 138.26,148.75 138.26,146.67 152.35,132.59 164.91,132.59 166.54,130.96 170.31,130.96 173.41,127.85 173.41,115.3 180.17,108.55 180.17,107.84 187.69,100.32 195.41,100.32 202.39,93.33 209.27,93.33 211.14,91.45 235.44,91.45 237.2,89.7 237.2,85.5 240.77,81.93 248.01,81.93 248.92,82.83 250.63,82.83 251.32,83.53 257.67,83.53 258.35,84.21 258.35,84.87 258.25,84.97 258.1,84.97 v1(258,84.87)
  BOTTOM w0.102: JMINI2.13 259.55,83.8 259.42,83.93 258.53,83.93 258.14,84.33 258.14,84.73 v1(258,84.87)
CLK_PCIE_MINI1#: length 317.9
  TOP w0.102: UH1.Y43 32.62,107.61 32.62,108.07 32.28,108.42 32.28,109.58 30.55,111.3 30.55,113.46 30.38,113.64 30.15,113.64 v1(30.01,113.5)
  IN4 w0.117: v1(258.78,84.87) 258.64,84.72 258.64,84.09 257.79,83.24 251.44,83.24 250.75,82.55 249.04,82.55 248.13,81.64 240.65,81.64 236.91,85.38 236.91,89.58 235.33,91.17 211.03,91.17 209.15,93.05 202.27,93.05 195.29,100.03 187.57,100.03 179.88,107.72 179.88,108.43 173.13,115.18 173.13,127.73 170.19,130.67 166.42,130.67 164.8,132.3 152.23,132.3 137.98,146.55 137.98,148.63 133.96,152.65 133.96,153.07 132.05,154.98 130.78,154.98 130.32,154.53 130.32,154.29 129.01,152.98 126.65,152.98 126.33,153.3 120,153.3 119.07,154.23 115.56,154.23 115.35,154.01 114.74,154.01 112.23,151.5 112.23,148.12 112.43,147.91 112.43,141.47 110.6,139.64 110.4,139.64 108.94,138.17 105.69,138.17 105.32,138.54 98.8,138.54 97.15,136.89 96.67,136.89 95.27,135.48 88.84,135.48 88.04,136.28 85.51,136.28 83.11,133.88 82.1,133.88 80.71,135.26 74.41,135.26 73.61,134.46 68.66,134.46 67.86,135.26 66.83,135.26 66.31,135.78 62.25,135.78 61.4,136.63 54.63,136.63 53.28,135.29 43.31,135.29 41.44,133.41 39.56,133.41 35.09,128.94 35.09,121.83 34.74,121.48 34.74,120.89 32.75,118.91 32.75,118.3 30.77,116.32 30.77,113.93 30.53,113.7 30.2,113.7 v1(30.01,113.5)
  BOTTOM w0.102: v1(258.78,84.87) 258.45,84.87 258.4,84.82 258.4,84.44 258.64,84.2 259.15,84.2 259.55,84.6 JMINI2.11
CLK_PCIE_MINI2: length 160.6
  TOP w0.102: v1(33.15,105.59) 33.44,105.88 UH1.AB39
  IN4 w0.117: v1(36.64,113.7) 36.51,113.57 36.51,113.27 36.1,112.86 32.91,112.86 31.27,114.5 31.27,116.1 35.59,120.42 35.59,128.73 39.73,132.87 41.74,132.87 43.22,134.35 53.06,134.35 53.55,134.83 62.44,134.83 63.55,133.72 68.96,133.72 69.28,133.4 80.11,133.4 80.39,133.68 81.59,133.68 81.94,133.32 84.16,133.32 85.12,134.29 86.37,134.29 87.05,134.97 95.51,134.97 96.38,135.84 97.72,135.84 99.49,137.61 109.09,137.61 110.62,139.14 110.81,139.14 112.93,141.26 112.93,148.32 112.73,148.52 112.73,151.3 114.78,153.35 116.77,153.35 117.1,153.02 119.05,153.02 120.32,151.76 125.73,151.76 125.88,151.6 128.83,151.6 133.28,147.15 133.28,145.88 132.52,145.12 132.52,142.94 132.95,142.51 133.49,142.51 133.62,142.64 133.62,142.85 133.49,142.99 v1(133.49,142.99)
  BOTTOM w0.102: v1(33.15,105.59) 33.28,105.71 33.52,105.71 35.24,107.43 35.24,110.38 36.48,111.62 36.48,113.55 v1(36.64,113.7) ; v1(133.49,142.99) 133.49,142.99 133.63,143.13 133.63,143.53 133.96,143.86 134.46,143.86 134.65,143.67 134.98,143.34 JMINI4.13
CLK_PCIE_MINI2#: length 160.5
  TOP w0.102: UH1.AB40 33.42,106.26 33.2,106.26 v1(33.15,106.31)
  IN4 w0.117: v1(134.31,142.99) 134.19,143.11 134.06,143.11 133.9,142.96 133.9,142.52 133.61,142.23 132.83,142.23 132.24,142.82 132.24,145.24 133,146 133,147.03 128.71,151.32 125.76,151.32 125.61,151.47 120.2,151.47 118.94,152.74 116.98,152.74 116.65,153.07 114.9,153.07 113.01,151.18 113.01,148.64 113.21,148.44 113.21,141.14 110.92,138.85 110.73,138.85 109.2,137.32 99.61,137.32 97.84,135.55 96.49,135.55 95.63,134.69 87.17,134.69 86.49,134 85.24,134 84.28,133.04 81.83,133.04 81.47,133.39 80.51,133.39 80.23,133.11 69.17,133.11 68.84,133.44 63.43,133.44 62.32,134.55 53.66,134.55 53.18,134.07 43.34,134.07 41.86,132.59 39.85,132.59 35.87,128.61 35.87,120.31 31.56,115.99 31.56,114.62 33.02,113.15 35.98,113.15 36.22,113.39 36.22,113.63 36.15,113.7 v1(36,113.7)
  BOTTOM w0.102: v1(36,113.7) 36.08,113.7 36.22,113.56 36.22,111.73 34.97,110.49 34.97,107.54 33.41,105.98 33.16,105.98 33.05,106.08 33.05,106.22 v1(33.15,106.31) ; JMINI4.11 135.08,142.54 134.88,142.73 134.88,143.06 134.83,143.12 134.47,143.48 134.35,143.6 134.07,143.6 133.89,143.42 133.89,143.09 133.99,142.99 v1(134.31,142.99)
CLK_PCIE_MINI3: length 106.2
  TOP w0.102: v1(34.93,114.58) 34.93,114.34 35.14,114.13 35.29,114.13 35.58,113.84 35.58,111.61 34.65,110.68 34.65,109.31 34.45,109.11 34.45,108.85 34.65,108.65 34.65,108.34 34.55,108.24 34.45,108.24 34.35,108.34 UH1.AD45
  IN4 w0.117: v1(34.93,114.58) 34.93,114.34 35.06,114.21 35.29,114.21 35.44,114.36 35.44,116.36 37.17,118.09 37.17,127.08 37.75,127.67 37.75,128.66 40.36,131.27 42.63,131.27 44.12,132.76 61.2,132.76 62.58,131.38 77.92,131.38 78.22,131.69 93.38,131.69 94.67,132.98 95.77,132.98 96.9,134.11 99.74,134.11 101.11,135.47 112.97,135.47 113.25,135.75 113.25,136.35 v1(113.08,136.52)
  BOTTOM w0.102: v1(113.08,136.52) 113.24,136.36 113.24,135.89 112.95,135.6 112.95,134.65 JMINI3.13
CLK_PCIE_MINI3#: length 106.2
  TOP w0.102: v1(34.93,113.75) 35.05,113.87 35.18,113.87 35.31,113.73 v3(35.31,112.41) 35.31,111.72 34.39,110.79 34.39,109.42 34.18,109.22 34.18,108.74 34.04,108.59 34.04,108.27 34.35,107.97 UH1.AD43
  IN4 w0.117: v1(113.67,136.52) 113.53,136.39 113.53,135.63 113.09,135.19 101.22,135.19 99.86,133.83 97.01,133.83 95.88,132.7 94.78,132.7 93.49,131.4 78.34,131.4 78.04,131.1 62.46,131.1 61.08,132.48 44.24,132.48 42.74,130.99 40.48,130.99 38.04,128.54 38.04,127.55 37.45,126.96 37.45,117.97 35.73,116.25 35.73,114.24 35.41,113.92 35.11,113.92 v1(34.93,113.75)
  BOTTOM w0.102: JMINI3.11 113.75,134.65 113.75,135.62 113.51,135.86 113.51,136.36 v1(113.67,136.52)
CLK_PCIE_VGA: length 68
  TOP w0.102: v1(33.15,104.36) 33.47,104.68 UH1.AB36 ; v1(75.03,108.41) 75.27,108.16 75.27,107.96 75.61,107.62 84.79,107.62 85.98,106.43 85.98,105.92 85.92,105.87 85.81,105.87 85.75,105.81 JMXM1.185
  IN3 w0.089: 42.1,102.27 42.03,102.21 41.6,102.21 41.41,102.4 37.22,102.4 36.64,101.81 34.96,101.81 34.43,102.34 34.43,103.36 33.84,103.95 33.51,103.95 33.15,104.31 v1(33.15,104.36)
  IN3 w0.127: v1(75.03,108.41) 75.18,108.25 75.18,108.05 74.99,107.86 74.51,107.86 73.03,106.38 73.03,105.62 72.04,104.63 72.04,103.44 70.82,102.22 69.33,102.22 67.91,100.81 67.53,100.81 66.12,99.4 66.12,98.7 64.11,96.68 57.07,96.68 55.05,98.7 55.05,100.14 53.02,102.17 43.7,102.17 43.59,102.27 42.1,102.27
CLK_PCIE_VGA#: length 68.1
  TOP w0.102: v1(33.16,103.77) 33.47,104.09 UH1.AB35 ; v1(75.61,108.41) 75.54,108.33 75.54,108.07 75.72,107.88 v3(83.03,107.88) 84.9,107.88 86.25,106.54 JMXM1.183
  IN3 w0.089: 42.1,101.97 42.03,102.03 41.53,102.03 41.34,102.22 37.3,102.22 36.71,101.64 34.88,101.64 34.25,102.27 34.25,103.29 33.77,103.77 v1(33.16,103.77)
  IN3 w0.127: 42.1,101.97 43.47,101.97 43.57,101.86 52.89,101.86 54.75,100.01 54.75,98.57 56.94,96.38 64.24,96.38 66.43,98.57 66.43,99.27 67.66,100.5 68.04,100.5 69.45,101.92 70.94,101.92 72.34,103.31 72.34,104.5 73.34,105.5 73.34,106.26 74.64,107.55 75.12,107.55 75.48,107.92 75.48,108.28 v1(75.61,108.41)
CLK_SIO_14M: length 320.6
  IN1 w0.109: v1(206.54,85.53) 205.49,84.49 202.27,84.49 196.09,90.67 196.09,91.15 192.26,94.99 192.26,95.84 190.7,97.39 184.43,97.39 176.04,105.78 175.21,105.78 171.09,109.9 171.09,110.25 169.92,111.41 169.92,111.71 168.66,112.97 168.66,122.51 167.51,123.67 167.51,128.04 166.16,129.39 166.16,130.92 165.38,131.7 158.59,131.7 153.65,136.65 153.65,137.45 148.29,142.81 148.29,147.05 138.36,156.98 136.1,156.98 131.6,161.48 128.61,161.48 127.83,162.26 126.11,162.26 119.35,169.01 117.64,169.01 116.74,169.91 114.02,169.91 111.2,172.73 101.81,172.73 93.61,164.53 88.17,164.53 86.92,165.78 72.96,165.78 71.59,164.4 63.56,164.4 59.8,160.64 54.34,160.64 52.1,162.88 52.1,164.5 49.59,167.02 45.5,167.02 43.73,165.24 33.06,165.24 30.83,163.01 29.78,163.01 29.24,162.48 28.08,162.48 26.7,161.1 26.35,161.1 25.23,159.98 25.23,153.84 25.84,153.24 25.84,151.82 25.46,151.45 25.46,146.18 26.69,144.95 26.69,142.76 27.74,141.71 v1(27.74,141.64)
  BOTTOM w0.102: v1(27.74,141.64) 28.61,140.76 v2(28.61,137.06) 28.61,131.94 29.68,130.87 29.68,128.08 31.61,126.15 31.61,121.02 29.8,119.21 26.41,119.21 24.87,117.66 23.06,117.66 19.59,114.19 19.59,110.3 18.42,109.13 18.42,107.02 18.65,106.79 18.91,106.79 19.8,105.9 20.99,105.9 CH79.1 RH157.1 ; v1(206.54,85.53) 206.54,84.52 206.94,84.11 209.28,84.11 209.79,84.62 R794.1 210.42,84.62 210.83,85.02 U46.A32
CLK_TP_SIO: length 150.6
  TOP w0.102: 16.11,79.03 16.87,79.79 16.87,80.58 v1(17.28,80.99) ; 16.11,79.03 v2(16.11,79.02) ; 16.11,79.03 15.08,78 JIO1.112
  IN2 w0.127: v1(88.81,114.77) 89.01,114.97 89.01,127.54 89.85,128.38 90.43,128.38 90.89,128.84 90.89,129.88 90.61,130.16 90.61,134.66 97.06,141.11 97.06,142.95 96.4,143.61 96.4,146.09 96.73,146.42 96.73,146.77 99.75,149.79 99.75,150.76 101.42,152.42 101.42,153.72 100.85,154.29 99.53,154.29 99.02,153.78 97.39,153.78 96.99,154.19 v1(96.99,154.24)
  IN3 w0.127: v1(88.81,114.77) 88.78,114.74 88.78,112.41 86.09,109.71 86.09,105.87 82.27,102.05 80.16,102.05 78.58,100.47 75.46,100.47 73.65,98.65 73.65,97.67 72.92,96.94 72.63,96.94 65.6,89.91 64.72,89.91 64.3,89.49 64.3,88.83 63.94,88.48 63.2,88.48 62.84,88.83 59.37,88.83 56.92,86.38 56.5,86.38 51.76,81.64 47.31,81.64 45.47,79.79 39.79,79.79 38.74,78.75 34.88,78.75 34.23,79.4 32.51,79.4 31.92,78.81 28.38,78.81 27.58,79.61 20,79.61 18.63,80.99 v1(17.28,80.99)
  BOTTOM w0.102: U51.A37 97.52,154.77 v1(96.99,154.24)
CLK_XDP: length 3.8
  TOP w0.102: JXDP1.40 71.2,18.79 71.31,18.91 71.31,19.18 v1(71.15,19.34)
  BOTTOM w0.102: v1(71.15,19.34) 71.33,19.16 71.33,18.96 70.7,18.33 70.7,18.08 RH107.1
CLK_XDP#: length 3.8
  TOP w0.102: v1(71.76,19.34) 71.58,19.16 71.58,18.92 71.7,18.8 JXDP1.42
  BOTTOM w0.102: v1(71.76,19.34) 71.6,19.17 71.6,18.85 70.97,18.22 70.97,18.08 RH108.1
CLKRUN#: length 307.7
  TOP w0.102: v1(38.65,92.55) 38.41,92.31 UH1.AN7
  IN1 w0.109: v1(213.99,77.99) 213.88,77.88 210.81,77.88 209.9,78.79 203.21,78.79 198.17,83.83 185.71,83.83 181.52,88.02 181.52,92.02 172.5,101.04 169.92,101.04 160.54,110.42 v1(160.54,110.98)
  IN2 w0.127: v1(38.65,92.55) 39.07,92.13 39.07,91.76 39.38,91.45 39.81,91.45 40.14,91.78 40.14,92.29 40.8,92.95 41.41,92.95 41.61,93.15 42.66,93.15 44.87,95.36 49.76,95.36 51.9,97.5 51.9,101.08 52.48,101.65 54.02,101.65 54.79,102.42 60.44,102.42 61.79,101.08 64.47,101.08 70.48,107.09 70.48,107.8 71.49,108.81 73.86,108.81 74.82,107.85 79.96,107.85 81.05,108.94 82.03,108.94 82.33,108.63 116.19,108.63 117.14,109.59 119.14,109.59 119.87,108.86 126.29,108.86 126.81,109.38 129.45,109.38 130.15,108.68 154.89,108.68 156.71,110.5 160.05,110.5 v1(160.54,110.98)
  IN3 w0.127: v1(160.54,110.98) 160.54,111.19 158.31,113.42 156.79,113.42 154.61,115.61 151.47,115.61 149.03,118.04 149.03,123.26 148.04,124.25 148.04,127.63 144.87,130.8 122.98,130.8 114.82,138.95 109.99,138.95 109.5,139.44 v1(109.5,140.66)
  IN4 w0.109: v1(99.38,151.07) 100.03,150.42 100.03,144.15 101.36,142.83 107.85,142.83 109.5,141.18 v1(109.5,140.66)
  BOTTOM w0.102: RH90.2 41.82,86.21 40.53,87.5 39.67,87.5 38.35,88.83 v2(38.35,89.24) 38.35,89.67 38.21,89.81 38.21,91.37 38.26,91.43 38.26,92.11 38.65,92.49 v1(38.65,92.55) ; v1(99.38,151.07) U51.A32 ; v1(160.54,110.98) 161.42,110.1 U39.15 ; U46.B20 213.71,78.27 v1(213.99,77.99)
CMPL_EN: length 4.3
  IN3 w0.127: v1(221.01,63.28) 221.01,64.29 v1(220.24,65.06)
  BOTTOM w0.102: R568.2 v1(221.01,63.28) 221.01,63 v2(220.77,62.76) ; U637.13 v1(220.24,65.06)
COMP: length 5
  TOP w0.203: PC525.2 56.94,21.75 56.89,21.7 PR541.2 56.42,22.13 v2(55.9,22.65) 55.15,23.4 54.14,23.4 53.93,23.61 PU500.7
CONTACTLESS_DET#: length 138.9
  TOP w0.102: JUSH1.17 v1(57.05,5.67) ; v1(21.4,94.85) 22.29,95.75 24.22,95.75 24.43,95.95 24.76,95.95 24.96,96.14 24.96,96.14 24.98,96.15 25.44,96.15 UH1.C16
  IN1 w0.109: v1(14.28,95.77) 13.71,95.19 13.71,91.86 13.35,91.5 13.35,88.18 15.11,86.42 15.98,86.42 19.77,82.63 21.38,82.63 22.19,81.83 23.3,81.83 24.73,80.4 29.07,80.4 29.57,79.9 32.86,79.9 34.67,78.09 34.67,67.26 36.84,65.1 36.84,55.75 39.19,53.4 39.19,51.65 35.66,48.13 35.66,34.3 39.19,30.77 39.19,27.78 42.35,24.61 42.35,18.59 43.9,17.03 43.9,10.39 49.67,4.63 56,4.63 v1(57.05,5.67)
  IN3 w0.127: v1(21.4,94.85) 19.8,94.85 18.42,96.23 15.78,96.23 15.38,95.82 14.33,95.82 v1(14.28,95.77)
  BOTTOM w0.102: v1(57.05,5.67) v2(57.05,5.1) ; v1(14.28,95.77) 14.08,95.56 RPH8.6
CPPE#: length 171.1
  TOP w0.102: v1(134.22,155.33) v2(134.22,156.14) ; v1(23.74,94.87) 24.01,95.13 25,95.13 UH1.B13
  IN2 w0.127: v1(23.74,94.87) 23.74,94.84 23.35,94.45 22.38,94.45 22.35,94.42 21.07,94.42 20.35,95.14 20.35,95.33 20.02,95.66 20.02,96.92 19.59,97.36 19.59,101.19 18.09,102.69 18.09,106.26 18.23,106.4 18.23,108.6 20.95,111.31 20.95,113.67 21.54,114.26 21.54,114.55 22.99,116 23.38,116 26.98,119.61 26.98,120.79 27.26,121.07 28.74,121.07 30.83,123.16 30.83,124.61 45.18,138.96 46.84,138.96 48.82,140.94 49.42,140.94 54.68,146.2 56.7,146.2 59.91,149.41 61.2,149.41 68.62,156.83 75.21,156.83 79.17,160.79 84.87,160.79 85.65,161.58 86.45,161.58 86.88,161.15 94.85,161.15 95.28,161.58 95.42,161.58 98.15,164.31 112.15,164.31 113.08,165.24 113.89,165.24 115.26,163.87 119.67,163.87 124.05,159.48 125.93,159.48 125.97,159.52 126.41,159.52 126.43,159.51 129.88,159.51 134.06,155.33 v1(134.22,155.33)
  BOTTOM w0.102: v1(134.22,155.33) 133.82,155.33 133.59,155.56 R823.1 133.84,155.87 134.78,155.87 135.06,156.14 JMINI4.37
CPU1.5V_S3_GATE: length 24.3
  TOP w0.102: v2(111.39,148.64) 111.27,148.52 v1(111.27,148.03)
  IN3 w0.127: v1(111.27,148.03) 111.27,147.55 110.94,147.22 109.92,147.22 108.65,145.95 107.1,145.95 106.82,146.23 101.06,146.23 97.71,149.58 97.47,149.58 96.58,150.47 96.58,153.22 v1(97.58,154.22)
  BOTTOM w0.102: v1(97.58,154.22) 97.63,154.27 U51.A36 ; RP7.5 111.55,147.75 v1(111.27,148.03)
CPU_B+: length 24.3
  TOP w0.203: PR526.2 v1(56.42,32.22)
  BOTTOM w0.254: v1(56.42,32.22) 52.69,32.22 51.33,33.58 45.33,33.58 42.66,36.26 42.66,42 43.72,43.06 v3(43.72,44.11)
  vias: v3(40.12,75.35) v3(40.27,68.24) v3(40.29,67.6) v3(40.78,74.66) v3(40.8,75.37) v3(40.95,67.88) v3(40.93,67.24) v3(41.56,62.52) v3(41.56,61.89) v3(41.56,61.25) v3(41.56,60.62) v3(41.56,59.88) v3(41.56,59.24) v3(41.56,58.61) v3(41.56,57.97) v3(42.15,74.28) v3(43.72,46.01) v3(43.72,45.38) v3(43.72,44.74) v4(43.18,56.89)
CPU_DETECT#: length 178.6
  TOP w0.102: v1(222.97,73.39) 221.27,75.09 v1(220.71,75.09) ; v1(75.12,73.75) JCPU1.AP32
  IN3 w0.127: v1(75.12,73.75) 74.56,74.31 74.56,76.52 75.57,77.53 81.27,77.53 88.4,84.66 92.35,84.66 98.68,90.98 109.22,90.98 109.84,91.6 109.84,92.47 111.24,93.88 121.08,93.88 122.89,92.06 130.99,92.06 136.35,97.42 152.09,97.42 152.47,97.04 164.66,97.04 176.45,85.25 183.41,85.25 187.95,80.71 202.79,80.71 204.67,78.83 208.63,78.83 211.04,76.41 219.39,76.41 v1(220.71,75.09)
  BOTTOM w0.102: U46.A3 220.67,75.13 v1(220.71,75.09) ; RP2.8 221.96,70.81 222.97,71.82 v1(222.97,73.39) 223.38,73.8 223.91,73.8 v2(224.19,73.52)
CPU_EDP_AUX: length 120.1
  TOP w0.089: JCPU1.N27 v1(80.12,52.75)
  TOP w0.102: C570.1 62.65,147.86 62.65,148.36 63.32,149.03 70.13,149.03 70.3,148.85 71.38,148.85 v1(71.48,148.96)
  IN1 w0.089: v1(80.12,52.75) 80.12,52.48 80.02,52.38 79.85,52.38 79.72,52.51 79.72,52.99 79.89,53.16 83.49,53.16 83.74,53.41 83.74,53.68 83.75,53.69 83.75,53.71
  IN1 w0.117: 83.75,53.71 83.75,76.75 83.48,77.02 82.67,77.02 82.55,77.15 82.55,77.49 82.67,77.62 83.33,77.62 83.59,77.89 83.59,78.41 83.33,78.68 82.69,78.68 82.59,78.77 82.59,98.11 82.91,98.44 82.91,104.51 82.3,105.13 82.3,109.39 81.51,110.18 81.51,116.67 81.65,116.81 81.65,117.8 81.3,118.15 81.3,121.98 81.61,122.29 81.61,124.8 80.09,126.32 79.63,126.32 78.41,127.54 78.41,136.62 77.39,137.64 77.39,138.36 72.54,143.22 72.54,148.26 71.97,148.83 71.62,148.83 v1(71.48,148.96)
CPU_EDP_AUX#: length 120.1
  TOP w0.089: JCPU1.M27 v1(80.12,51.75)
  TOP w0.102: C569.1 62.86,147.9 62.86,148.27 63.41,148.82 70.04,148.82 70.21,148.64 71.22,148.64 v1(71.48,148.38)
  IN1 w0.089: v1(80.12,51.75) 80.27,51.9 80.27,52.09 80.2,52.17 79.76,52.17 79.51,52.42 79.51,53.08 79.8,53.36 83.4,53.36 83.53,53.5 83.53,53.66 83.51,53.68 83.51,53.71
  IN1 w0.117: 83.51,53.71 83.51,76.66 83.38,76.78 82.57,76.78 82.31,77.05 82.31,77.59 82.57,77.86 83.23,77.86 83.36,77.98 83.36,78.31 83.23,78.44 82.59,78.44 82.36,78.67 82.36,98.21 82.68,98.53 82.68,104.41 82.06,105.03 82.06,109.29 81.28,110.08 81.28,116.77 81.42,116.91 81.42,117.7 81.07,118.05 81.07,122.08 81.38,122.39 81.38,124.7 79.99,126.08 79.53,126.08 78.17,127.45 78.17,136.53 77.15,137.54 77.15,138.27 72.3,143.12 72.3,148.16 71.87,148.59 71.7,148.59 v1(71.48,148.38)
CPU_EDP_AUX#_C: length 2.5
  TOP w0.102: C569.2 62.9,146.32 62.9,145.98 63.51,145.37 63.51,145.17 63.57,145.11 U630.29
CPU_EDP_AUX_C: length 2.5
  TOP w0.102: C570.2 62.68,146.28 62.68,145.89 63.29,145.29 63.29,145.21 63.17,145.09 U630.30
CPU_EDP_HPD: length 204.8
  TOP w0.102: U630.13 68.33,141.07 v1(68.37,141.11)
  IN1 w0.109: v1(73.72,20.79) 75.08,20.79 83.77,29.47 84.42,29.47 84.81,29.86 86.94,29.86 91.55,34.48 91.55,44.94 86.24,50.25 86.24,69.07 86.65,69.48 86.65,79.31 90.94,83.61 90.94,88.86 93.7,91.62 93.7,93.33 94.34,93.98 94.34,104.63 95.44,105.73 95.44,107.05 97.09,108.7 97.09,109.89 96.16,110.82 96.16,114.7 v1(98,116.55)
  IN3 w0.127: v1(68.37,141.11) 68.37,141.43 72.21,145.26 73.96,145.26 75.94,143.27 84.36,143.27 97.67,129.97 97.67,127.61 96.4,126.34 96.4,118.15 v1(98,116.55)
  BOTTOM w0.102: v1(73.72,20.79) 73.21,20.79 71.83,22.17 66.29,22.17 65.62,22.85 65.62,29.42 63.25,31.79 v2(63.25,37.5) 63.25,39.79 62.11,40.93 62.11,41.29 64.47,43.65 64.47,47.15 RC75.1 65.24,47.36 QC6.2
CPU_EDP_LANE_N0: length 120.4
  TOP w0.089: v1(72.12,53.75) JCPU1.P35
  TOP w0.102: v1(74.48,143.73) 74.38,143.63 73.97,143.63 72.52,142.18 71.11,142.18 C563.1
  IN1 w0.089: v1(72.12,53.75) 72.12,53.92 72.22,54.02 72.44,54.02 72.51,53.95 72.51,52.52 73.79,51.24 78.17,51.24 78.53,50.88 78.53,50.5 78.87,50.16 81.1,50.16 81.12,50.14 81.18,50.14 81.2,50.13 81.21,50.13
  IN1 w0.117: 81.21,50.13 81.84,50.13 81.87,50.1 83.39,50.1 85.28,52 85.28,69.23 85.79,69.74 85.79,93.94 84.42,95.31 84.42,105.67 84.11,105.98 84.11,111.64 84.22,111.75 84.22,116.92 83.26,117.87 83.26,125.54 81.54,127.26 81.54,131.49 80.7,132.33 80.7,135.81 81.59,136.7 81.59,137.98 80.7,138.86 79.62,138.86 79.14,139.34 78.86,139.34 75.48,142.72 75.48,143.14 74.98,143.64 74.57,143.64 v1(74.48,143.73)
CPU_EDP_LANE_N0_C: length 3.9
  TOP w0.102: C563.2 69.57,142.07 69.24,142.07 69.03,141.87 v3(69.03,141.39) 69.03,140.87 68.74,140.58 68.22,140.58 68.12,140.67 U630.12
CPU_EDP_LANE_N1: length 120.2
  TOP w0.089: v1(73.12,52.75) JCPU1.N34
  TOP w0.102: v1(73.07,144.15) 72.98,144.05 71.12,144.05 C567.1
  IN1 w0.089: v1(73.12,52.75) 73.12,52.93 73.23,53.04 73.47,53.04 73.53,52.97 73.53,52.5 74.1,51.94 78.65,51.94 79.44,51.15 83.25,51.15 83.25,51.14 83.27,51.14
  IN1 w0.117: 83.27,51.14 83.54,51.14 84.52,52.12 84.52,70.17 84.77,70.41 84.77,79.35 84.5,79.62 83.8,79.62 83.68,79.73 83.68,80.2 83.8,80.32 84.79,80.32 85.05,80.57 85.05,81.24 84.79,81.49 83.8,81.49 83.68,81.61 83.68,82.11 83.8,82.23 84.75,82.23 85.02,82.5 85.02,83.02 84.75,83.29 83.8,83.29 83.68,83.4 83.68,83.89 83.8,84.01 84.35,84.01 84.61,84.27 84.61,84.8 84.35,85.06 83.8,85.06 83.68,85.18 83.68,92.11 83.9,92.33 83.9,94.47 83.68,94.69 83.68,105.18 83.07,105.79 83.07,112.85 83.23,113 83.23,116.86 82.45,117.64 82.45,125.19 79.94,127.7 79.94,131.44 79.71,131.67 79.71,137.69 78.8,138.6 78.27,138.6 73.84,143.03 73.84,143.81 73.58,144.07 73.15,144.07 v1(73.07,144.15)
CPU_EDP_LANE_N1_C: length 4.2
  TOP w0.102: U630.15 68.03,141.87 68.12,141.78 68.25,141.78 68.33,141.86 68.33,142.21 68.8,142.68 v3(68.8,143.11) 68.8,143.38 69.36,143.94 69.64,143.94 C567.2
CPU_EDP_LANE_P0: length 120.4
  TOP w0.089: JCPU1.R35 v1(72.12,54.75)
  TOP w0.102: v1(74.48,143.15) 74.2,143.42 74.06,143.42 72.61,141.96 71.29,141.96 C565.1
  IN1 w0.089: v1(72.12,54.75) 71.88,54.5 71.88,54.35 72,54.23 72.53,54.23 72.72,54.04 72.72,52.6 73.87,51.45 78.25,51.45 78.74,50.96 78.74,50.58 78.96,50.36 81.21,50.36
  IN1 w0.117: v1(74.48,143.15) 74.74,143.41 74.88,143.41 75.25,143.04 75.25,142.62 78.76,139.11 79.04,139.11 79.53,138.62 80.61,138.62 81.35,137.88 81.35,136.79 80.46,135.9 80.46,132.23 81.31,131.39 81.31,127.17 83.03,125.44 83.03,117.77 83.98,116.82 83.98,111.85 83.87,111.74 83.87,105.89 84.18,105.57 84.18,95.21 85.56,93.84 85.56,69.84 85.05,69.33 85.05,52.09 83.29,50.34 81.97,50.34 81.94,50.36 81.21,50.36
CPU_EDP_LANE_P0_C: length 3.9
  TOP w0.102: C565.2 69.6,141.86 69.33,141.86 69.26,141.79 69.26,141.04 69.25,141.03 69.25,140.78 68.83,140.36 68.22,140.36 68.12,140.27 U630.11
CPU_EDP_LANE_P1: length 120.2
  TOP w0.089: JCPU1.P34 v1(73.12,53.75)
  TOP w0.102: C572.1 71.33,143.84 72.79,143.84 v1(73.07,143.56)
  IN1 w0.089: v1(73.12,53.75) 72.92,53.54 72.92,53.33 73,53.25 73.55,53.25 73.74,53.06 73.74,52.58 74.18,52.14 78.74,52.14 79.52,51.36 83.22,51.36 83.25,51.38 83.27,51.38
  IN1 w0.117: 83.27,51.38 83.45,51.38 84.29,52.22 84.29,70.27 84.53,70.51 84.53,79.25 84.4,79.38 83.7,79.38 83.45,79.64 83.45,80.3 83.7,80.55 84.69,80.55 84.81,80.67 84.81,81.14 84.69,81.26 83.7,81.26 83.45,81.51 83.45,82.21 83.7,82.47 84.65,82.47 84.78,82.59 84.78,82.92 84.65,83.05 83.7,83.05 83.45,83.31 83.45,83.99 83.7,84.24 84.25,84.24 84.37,84.37 84.37,84.7 84.25,84.83 83.7,84.83 83.45,85.08 83.45,92.21 83.67,92.43 83.67,94.38 83.45,94.6 83.45,105.08 82.84,105.69 82.84,112.94 83,113.1 83,116.76 82.22,117.54 82.22,125.09 79.71,127.6 79.71,131.34 79.48,131.57 79.48,137.59 78.71,138.36 78.17,138.36 73.61,142.93 73.61,143.71 73.49,143.83 73.34,143.83 v1(73.07,143.56)
CPU_EDP_LANE_P1_C: length 4.2
  TOP w0.102: U630.14 67.99,141.47 68.08,141.56 68.34,141.56 68.55,141.77 68.55,142.12 69.03,142.61 69.03,143.3 69.45,143.72 69.66,143.72 C572.2
CPU_PLTRST#: length 133.6
  TOP w0.102: UH1.AU4 39.63,90.65 39.92,90.36 39.92,90.11 39.73,89.92 39.73,89.63 v1(40.06,89.29) ; v1(81.12,75.75) JCPU1.AT26 81.59,76.05 85.82,80.29 86.43,80.29 v1(86.88,80.73)
  IN4 w0.109: v1(71.66,21.73) 72.52,21.73 80.22,29.43 80.22,33.28 84.41,37.47 84.41,39.72 84.53,39.84 84.53,41.97 84.17,42.33 79.92,42.33 79.54,42.71 79.54,63.92 79.21,64.25 77.86,64.25 77.71,64.4 77.71,73.9 79.03,75.22 80.59,75.22 v1(81.12,75.75)
  BOTTOM w0.102: v1(86.88,80.73) 86.42,81.19 v2(83.75,81.19) 74.4,81.19 69.39,86.19 59.65,86.19 58.5,87.34 53.09,87.34 52.81,87.62 48.09,87.62 46.64,89.06 42.99,89.06 42.73,89.32 41.26,89.32 41.23,89.29 v1(40.06,89.29) ; RC8.1 73.4,19.25 71.66,20.99 v1(71.66,21.73)
CPU_PWR_DEBUG: length 62.6
  TOP w0.102: v1(80.12,46.75) 80.59,47.22 JCPU1.H27
  BOTTOM w0.102: v1(80.12,46.75) 79.67,47.2 78.98,47.2 78.72,46.94 78.72,45.16 78.52,44.97 78.52,37.96 v2(80.88,35.6) RC71.1 82.33,33.13 82.33,31.61 RC69.2 77.85,26.11 66.25,26.11 65.85,25.7 65.85,23.05 66.39,22.5 71.82,22.5 72.73,21.59 75.78,21.59 76.81,20.56 76.81,19.21 76.2,18.6 76.2,14.04 75.73,13.57 RC7.1
CPU_PWR_DEBUG_R: length 5.9
  TOP w0.102: v1(73.19,9.82) 72.75,10.25 72.75,10.68 72.7,10.74 JXDP1.45
  BOTTOM w0.102: RC7.2 75.73,11.62 v2(74.97,10.86) 73.92,9.82 v1(73.19,9.82)
CPU_VTT_ON: length 21.7
  TOP w0.102: v1(226.86,69.76) 226.5,69.4 219.19,69.4 216.94,71.65 216.94,72.39 215.43,73.9 214.28,73.9 213.44,74.74 v1(213.44,74.79)
  BOTTOM w0.102: U46.B17 213.92,76.27 213.44,75.8 v1(213.44,74.79) ; v2(227,67.4) 226.86,67.54 v1(226.86,69.76) 227.05,69.95 RP4.1
CRT_11: length 6.4
  TOP w0.102: T61.1 70.77,166.43 70.77,172.08 JCRT1.11
CRT_IREF: length 2.7
  TOP w0.254: v1(31.2,105.57) 31.2,105.99 UH1.U40
  BOTTOM w0.254: v1(31.2,105.57) 31.39,105.57 31.66,105.84 v2(31.66,105.97) RH97.2
CRT_SWITCH: length 213.1
  IN1 w0.109: v1(89.98,165.54) 89.95,165.54 90.08,165.67 93.64,165.67 101.47,173.5 111.45,173.5 114.28,170.67 117,170.67 117.94,169.74 121.41,169.74 122.02,170.34 126.81,170.34 127.75,169.4 127.75,165.14 130.19,162.69 134.85,162.69 137.83,159.7 141.42,159.7 146.26,154.87 148.68,154.87 149.36,154.19 149.36,152.51 151.32,150.55 152.01,150.55 152.96,149.59 152.96,146.05 152.27,145.36 152.27,143.38 153.56,142.09 154.99,142.09 156.97,140.1 156.97,137.31 159.28,135 160.1,135 160.7,134.4 165.65,134.4 166.87,135.62 173.35,135.62 174.19,134.78 174.19,127.29 171.87,124.98 171.87,123.72 173.52,122.08 173.52,113.4 174.66,112.26 175.64,112.26 187.66,100.24 193.46,100.24 199.55,94.14 199.55,91.1 202.38,88.27 211.21,88.27 212.5,86.98 219.34,86.98 220.53,85.79 v1(223.88,85.79)
  BOTTOM w0.102: U19.38 84.6,162.15 84.84,162.39 85.4,162.39 85.58,162.22 ; U46.B52 222.94,85.27 223.33,85.66 223.76,85.66 v1(223.88,85.79) ; 85.58,162.22 86.27,162.22 v2(86.55,162.49) 89.59,165.54 v1(89.98,165.54) ; 85.58,162.22 85.58,161.53 85.4,161.35 U19.40
CS_1.35V: length 7.1
  TOP w0.203: v1(179.59,78.55) 179.59,78.06 v1(180.76,76.9)
  BOTTOM w0.102: v2(181.5,81.14) 181.19,80.82 PR201.2
  BOTTOM w0.203: PR201.2 180.88,80.17 179.59,78.88 v1(179.59,78.55) ; PU200.13 180.42,77.1 180.63,76.9 v1(180.76,76.9)
CSON_1: length 56.5
  IN2 w0.127: v1(177.22,56.45) 177.39,56.61 177.39,60.02 178.3,60.93 188.63,60.93 189.68,61.99 202.12,61.99 206.88,57.22 207.84,57.22 v1(208.06,57.44)
  BOTTOM w0.102: PC792.2 176.82,55.47 177.4,56.05 177.4,56.27 v1(177.22,56.45) ; v1(208.06,57.44) 208.26,57.24 208.66,57.24 211.58,54.32 v2(211.58,53.93) 211.58,53.48 213.17,51.9 213.17,47.35 212.63,46.81 211.74,46.81 211.53,46.59 211.53,45.63
  BOTTOM w0.254: PC792.2 176.95,55.34 PR761.2 175.69,54.2 PC786.1
CSOP_1: length 53.9
  IN2 w0.127: v1(208.06,56.81) 207.89,56.97 206.75,56.97 201.99,61.73 189.79,61.73 188.73,60.68 178.41,60.68 177.64,59.91 177.64,56.61 v1(177.81,56.45)
  BOTTOM w0.102: PC792.1 177.63,56.05 177.63,56.27 v1(177.81,56.45) ; PR723.2 211.53,47.27 211.76,47.04 212.53,47.04 212.94,47.45 212.94,51.8 211.25,53.49 211.25,54.33 208.57,57.01 208.26,57.01 v1(208.06,56.81)
  BOTTOM w0.254: PC792.1 178.22,55.47 PR759.2
CSS_GC: length 155.9
  TOP w0.254: PR703.2 v1(18.75,78.27)
  IN3 w0.254: v1(64.58,88.14) 63.6,87.16 59.77,87.16 54.16,81.54 52.79,81.54 51.11,79.87 48.03,79.87 46.87,78.71 40.23,78.71 39.19,77.67 34.86,77.67 34,78.53 32.74,78.53 31.69,77.48 19.54,77.48 v1(18.75,78.27)
  BOTTOM w0.254: PU1001.10 148.36,118.28 147.95,117.88 147.95,117.09 147.46,116.6 145.86,116.6 141.57,112.3 132.49,112.3 127.91,116.88 122.94,116.88 117.31,111.24 117.31,109.09 115.39,107.17 113.4,107.17 110.91,104.68 99.37,104.68 v2(94.31,99.62) 87.71,93.03 86.47,93.03 85.73,92.29 82.12,92.29 79.95,94.46 75.26,94.46 68.94,88.14 v1(64.58,88.14)
CSSN_1: length 91
  TOP w0.102: v1(88.05,112.46) 88.05,112.55 PR712.1 88.6,113.13 PQ703.2
  IN3 w0.102: v1(62.62,88.07) 62.54,88 59.75,88 53.74,81.98 52.8,81.98 50.99,80.17 46.84,80.17 45.76,79.09 40.07,79.09 39.24,78.26 34.71,78.26 34.12,78.84 32.62,78.84 31.56,77.79 28.3,77.79 v1(27.92,78.17)
  BOTTOM w0.102: v1(62.62,88.07) 62.72,88.17 62.72,91.17 65.18,93.62 67.89,93.62 69.38,95.11 69.38,95.41 71.08,97.11 71.08,100.7 75.61,105.23 76.61,105.23 78.55,107.17 79.69,107.17 84.97,112.46 v2(85.47,112.46) v1(88.05,112.46) ; PQ702.3 26.86,79.33 27.92,78.27 v1(27.92,78.17) 28.02,78.27 29.38,78.27 29.92,77.73 31.78,77.73 32.11,78.06 32.11,78.75 PR707.1 31.73,79.28 PR711.1
CSSN_2: length 242.2
  IN3 w0.102: v1(179.23,42.58) 179.03,42.38 179.03,41.55 178.66,41.18 172.86,41.18 171.79,40.12 171.79,33.59 169.66,31.46 169.66,26.73 166.99,24.06 152.62,24.06 149.54,20.99 136.13,20.99 133,24.12 113.8,24.12 111.29,26.63 96.45,26.63 94.22,28.87 84.4,28.87 74.86,19.32 74.86,15.38 73.43,13.94 71.98,13.94 69.17,11.14 67.6,11.14 65.72,9.26 60.87,9.26 58.43,11.69 58.43,12.79 55.43,15.78 50.91,15.78 45.73,20.97 45.73,25.99 42.88,28.84 42.88,33.11 41.18,34.81 41.18,43.98 42.25,45.04 42.25,54.8 39.95,57.1 39.95,66.32 34.65,71.61 34.65,73.01 33.42,74.24 32.14,74.24 v1(31.96,74.06)
  IN4 w0.109: v1(32.95,78.05) 32.95,75.3 31.96,74.31 v1(31.96,74.06)
  BOTTOM w0.102: PR706.1 32.45,75.92 PU701.5 32.45,74.56 v1(31.96,74.06) ; v1(179.23,42.58) 179,42.81 179,43.06 PC704.1 179.31,43.37 PC703.2 178.96,44.57 178.96,45.04 179.08,45.15 179.08,46.11 179.23,46.26 PU700.1 ; PR711.2 33.51,79.27 32.95,78.71 v1(32.95,78.05)
CSSP_1: length 79.1
  TOP w0.102: v1(83.52,112.69) 83.42,112.69 82.97,113.14 PR709.1 84.01,113.18 84.06,113.13 PQ703.5
  IN3 w0.102: v1(62.11,88.4) 60.82,88.4 60.64,88.22 59.65,88.22 53.64,82.21 52.7,82.21 50.89,80.4 46.74,80.4 45.66,79.32 39.98,79.32 39.14,78.48 34.8,78.48 34.22,79.07 32.52,79.07 31.68,78.23 v1(31.21,78.23)
  BOTTOM w0.102: v1(31.21,78.23) 31.21,78.26 PQ700.3 30.59,79.77 31.3,79.77 PR707.2 31.71,80.17 PR710.1 ; v1(62.11,88.4) 62.49,88.78 62.49,91.26 65.08,93.85 67.8,93.85 69.15,95.2 69.15,95.51 70.85,97.21 70.85,100.79 75.62,105.56 v2(75.85,105.56) 76.61,105.56 78.45,107.4 79.59,107.4 84.13,111.94 84.13,112.41 83.85,112.69 v1(83.52,112.69)
CSSP_2: length 239.1
  IN3 w0.102: v1(33.5,75.52) 33.5,74.49 34.88,73.11 34.88,71.71 40.18,66.41 40.18,57.19 42.48,54.89 42.48,44.95 41.41,43.88 41.41,34.9 43.11,33.2 43.11,28.93 45.96,26.09 45.96,21.07 51.01,16.01 55.53,16.01 58.66,12.88 58.66,11.79 60.96,9.48 65.62,9.48 67.5,11.36 69.08,11.36 71.88,14.17 73.33,14.17 74.63,15.47 74.63,19.42 84.31,29.09 94.31,29.09 96.55,26.86 111.38,26.86 113.9,24.34 133.09,24.34 136.22,21.21 149.44,21.21 152.52,24.29 166.89,24.29 169.43,26.83 169.43,31.55 171.56,33.68 171.56,40.21 172.76,41.41 178.57,41.41 178.8,41.64 178.8,42.38 v1(178.6,42.58)
  BOTTOM w0.102: PU700.2 178.73,46.26 178.85,46.14 178.85,45.25 178.74,45.13 178.74,44.57 PC703.1 178.39,43.37 PC702.2 178.77,42.99 178.77,42.76 v1(178.6,42.58) ; v1(33.5,75.52) v2(33.5,76.24) 33.32,76.41 33.07,76.41 PR708.1 33.36,77.7 33.36,78.34 33.94,78.93 33.94,79.74 PR710.2
D_CLKRUN#: length 131.2
  IN3 w0.127: v1(102.7,117.03) 102.68,117.03 102.27,116.62 102.27,115.74 106.67,111.34 123.95,111.34 126.16,109.13 143.37,109.13 148.93,103.57 159.57,103.57 176.13,87.01 178.67,87.01 178.86,87.2 184.55,87.2 189.43,82.31 204.71,82.31 205.36,81.67 207.22,81.67 210.79,78.1 211.3,78.1 v1(211.75,78.55)
  BOTTOM w0.102: RP3.8 210.26,78.66 210.78,78.14 211.31,78.14 211.75,78.58 v1(211.75,78.55) 211.77,78.52 U46.A19 ; JDOCK1.111 v1(102.7,117.03)
D_DLDRQ1#: length 133.6
  TOP w0.102: v2(102.98,115.63) 103.72,116.37 v1(103.72,116.44) ; v1(214.64,79.77) 214.17,80.25 213.67,80.25 213.29,79.87 211.54,79.87 v1(211.11,79.44)
  IN3 w0.127: v1(103.72,116.44) 108.31,111.85 124.16,111.85 125.61,110.4 142.92,110.4 149.22,104.1 159.75,104.1 171.63,92.22 175.23,88.62 182.32,88.62 182.85,89.15 184.22,89.15 184.9,88.48 184.9,87.79 189.84,82.85 204.97,82.85 205.64,82.18 207.73,82.18 210.47,79.44 v1(211.11,79.44)
  BOTTOM w0.102: JDOCK1.117 104.2,116.93 v1(103.72,116.44) ; U46.B24 214.14,80.27 v1(214.64,79.77) ; v1(211.11,79.44) 210.88,79.66 RP3.6
D_LAD0: length 139.2
  TOP w0.102: v2(101.81,120.95) 101.6,120.74 v1(101.23,120.74)
  IN3 w0.127: v1(214.89,80.71) 214.46,80.27 213.85,80.27 212.78,81.34 210.28,81.34 207.92,83.7 190.06,83.7 185.85,87.91 185.85,88.6 183.52,90.93 179.9,90.93 179.35,91.48 178.96,91.48 177.25,93.19 171.74,93.19 160.07,104.86 149.58,104.86 143.28,111.16 129.76,111.16 128.26,112.66 108.58,112.66 104.64,116.6 104.64,117.4 101.31,120.74 v1(101.23,120.74)
  BOTTOM w0.102: v1(101.23,120.74) 100.77,120.74 99.2,119.17 JDOCK1.97 ; v1(214.89,80.71) 215.05,80.86 215.05,81.75 214.36,82.43 214.36,82.69 214.11,82.94 213.7,82.94 213.53,82.77 U46.B29
D_LAD1: length 131.7
  TOP w0.102: v1(106.21,116.42) v2(106.21,115.73)
  IN3 w0.127: v1(213.93,82.54) 212.91,82.54 212.68,82.76 209.94,82.76 208.24,84.46 190.38,84.46 186.94,87.9 186.94,88.59 183.17,92.37 179.21,92.37 177.63,93.95 172.06,93.95 160.38,105.62 151.14,105.62 144.36,112.41 130.75,112.41 129.73,113.42 109.2,113.42 v1(106.21,116.42)
  BOTTOM w0.102: U46.B28 213.67,82.27 v1(213.93,82.54) ; v1(106.21,116.42) 105.83,116.04 101.02,116.04 99.7,117.36 JDOCK1.99
D_LAD2: length 129.5
  IN3 w0.127: v1(206,82.92) 205.47,83.45 189.96,83.45 185.48,87.92 185.48,88.61 183.93,90.17 180.3,90.17 179.25,91.22 177.44,91.22 175.73,92.94 171.63,92.94 159.96,104.61 149.48,104.61 143.18,110.91 129.65,110.91 128.18,112.38 108.5,112.38 104.39,116.49 104.39,117.3 102.12,119.57 v1(101.2,119.57)
  BOTTOM w0.102: JDOCK1.103 100.7,119.07 v1(101.2,119.57) ; v1(206,82.92) 206,82.74 207.22,81.52 v2(211.12,81.52) U46.A25
D_LAD3: length 129.7
  TOP w0.102: v1(101.2,117.03) 101.2,117.27 v2(100.87,117.6)
  IN3 w0.127: v1(101.2,117.03) 101.66,117.49 103.84,117.49 104.14,117.19 104.14,116.38 108.42,112.1 124.26,112.1 125.71,110.65 143.03,110.65 149.33,104.35 159.86,104.35 171.53,92.68 173.85,92.68 177.12,89.41 184.33,89.41 185.15,88.59 185.15,87.9 189.85,83.19 204.99,83.19 205.74,82.45 207.82,82.45 209.56,80.71 v1(210.98,80.71)
  BOTTOM w0.102: v1(210.98,80.71) 211.3,81.02 U46.A24 ; JDOCK1.105 v1(101.2,117.03)
D_LFRAME#: length 133.5
  TOP w0.102: v2(100.77,115.81) 101.2,116.24 v1(101.2,116.44)
  IN3 w0.127: v1(214.01,79.77) 212.08,77.85 210.69,77.85 207.12,81.42 205.25,81.42 204.61,82.06 189.32,82.06 184.44,86.94 178.97,86.94 178.78,86.75 176.02,86.75 159.46,103.31 148.78,103.31 143.9,108.19 126.74,108.19 123.84,111.08 106.56,111.08 v1(101.2,116.44)
  BOTTOM w0.102: JDOCK1.109 102.2,117.44 v1(101.2,116.44) ; U46.B23 v1(214.01,79.77)
D_SERIRQ: length 130.2
  TOP w0.102: v1(103.7,117.03) 103.7,117.82 v2(103.81,117.93)
  IN3 w0.127: v1(211.03,78.57) 210.75,78.57 207.4,81.93 205.54,81.93 204.9,82.57 189.58,82.57 183.78,88.36 175.13,88.36 159.66,103.83 149.12,103.83 143.52,109.43 126.21,109.43 124.05,111.59 106.77,111.59 103.29,115.08 103.29,116.61 v1(103.7,117.03)
  BOTTOM w0.102: JDOCK1.115 v1(103.7,117.03) ; RP3.7 210.44,79.16 v1(211.03,78.57) 211.48,79.02 U46.A20
DAI_12MHZ#: length 122
  TOP w0.102: JIO1.48 12.22,97.2 10.32,95.3 10.32,93.52 11.03,92.81 11.03,91.43 10.09,90.49 10.09,89.42 9.97,89.29 9.94,89.29 v1(9.43,88.78)
  IN3 w0.127: v1(66.51,91.79) 66.51,91.6 65.92,91.02 57.76,91.02 57.11,90.36 57.11,89.52 53.26,85.67 52.26,85.67 50.65,84.06 46.57,84.06 46.53,84.02 42.01,84.02 41.54,84.49 38.49,84.49 38.05,84.94 36.02,84.94 34.15,86.8 31.27,86.8 28.96,84.49 17.32,84.49 17.04,84.77 13.42,84.77 9.43,88.76 v1(9.43,88.78)
  BOTTOM w0.102: v1(66.51,91.79) 68.73,91.79 70.63,93.7 72.09,93.7 74,95.6 74,99.87 75.2,101.08 76.89,101.08 81.78,105.96 82.48,105.96 87.42,110.91 93.94,110.91 v2(94.57,111.54) RE11.1 96.2,113.17 JDOCK1.89
DAI_BCLK#: length 112.8
  TOP w0.102: v1(11.77,88.78) 11.24,89.32 11.24,90.34 11.95,91.05 11.95,93.19 11.25,93.89 11.25,94.89 11.49,95.13 12.01,95.13 12.34,94.8 JIO1.56
  IN3 w0.127: v1(11.77,88.78) 13.34,87.21 18.48,87.21 19.09,86.6 20.85,86.6 21.86,85.58 28.61,85.58 31.15,88.12 34.27,88.12 35.72,86.68 37.75,86.68 38.74,85.68 41.79,85.68 42.43,85.04 46.11,85.04 46.15,85.08 48.68,85.08 49.79,86.19 49.79,86.27 50.33,86.8 52.79,86.8 54.92,88.94 54.92,90.35 56.05,91.48 56.79,91.48 57.34,92.03 64.42,92.03 v1(64.74,92.35)
  BOTTOM w0.102: JDOCK1.77 93.2,116.82 91.09,114.72 RE12.1 90.86,112.91 89.28,112.91 88.39,112.02 86.74,112.02 v2(84.81,110.1) 81.66,106.94 81.47,106.94 79.53,105.01 76.28,105.01 73.08,101.81 73.08,97.77 68.63,93.32 65.7,93.32 v1(64.74,92.35)
DAI_DI: length 116.8
  TOP w0.102: JIO1.52 11.7,96 10.79,95.1 10.79,93.7 11.49,93 11.49,91.24 10.6,90.35 v1(10.6,88.78)
  IN3 w0.127: v1(65.3,91.7) 65.12,91.53 57.55,91.53 56.6,90.58 56.6,89.73 53.05,86.18 52.05,86.18 50.44,84.57 46.36,84.57 46.32,84.53 42.22,84.53 41.75,85 38.71,85 38.26,85.44 36.23,85.44 34.36,87.31 31.06,87.31 28.75,85 17.53,85 16.57,85.96 13.39,85.96 10.6,88.76 v1(10.6,88.78)
  BOTTOM w0.102: v1(65.3,91.7) 66.14,92.54 v2(67.37,92.54) 68.83,92.54 70.44,94.16 71.48,94.16 72.06,94.73 72.06,95.77 73.54,97.25 73.54,100.06 75.22,101.74 76.91,101.74 81.62,106.46 82.14,106.46 87.25,111.57 92.46,111.57 94.75,113.86 94.75,118.25 JDOCK1.83
DAI_DO#: length 118.7
  TOP w0.102: JIO1.50 11.97,96.6 10.55,95.18 10.55,93.61 11.26,92.9 11.26,91.33 10.32,90.39 10.32,89.09 v1(10.02,88.78)
  IN3 w0.127: v1(65.9,91.72) 65.9,91.67 65.5,91.27 57.66,91.27 56.85,90.47 56.85,89.63 53.15,85.93 52.16,85.93 50.54,84.31 46.46,84.31 46.42,84.28 42.12,84.28 41.65,84.75 38.6,84.75 38.16,85.19 36.12,85.19 34.26,87.05 31.16,87.05 28.85,84.75 17.43,84.75 16.46,85.71 13.06,85.71 10.02,88.76 v1(10.02,88.78)
  BOTTOM w0.102: v1(65.9,91.72) 65.9,91.77 66.33,92.2 68.81,92.2 70.54,93.93 71.57,93.93 72.28,94.64 72.28,95.67 73.77,97.16 73.77,99.97 75.16,101.36 76.85,101.36 81.68,106.19 82.38,106.19 87.43,111.24 v2(88.3,111.24) 92.45,111.24 95.2,113.99 JDOCK1.85
DAI_LRCK#: length 114.9
  TOP w0.102: v1(11.18,88.78) 11.01,88.96 11.01,90.43 11.72,91.14 11.72,93.09 11.02,93.79 11.02,94.99 11.43,95.4 JIO1.54
  IN3 w0.127: v1(65.32,92.35) 65.32,92.34 64.77,91.78 57.44,91.78 56.35,90.68 56.35,89.84 52.94,86.44 51.95,86.44 50.33,84.82 46.25,84.82 46.21,84.78 42.33,84.78 41.86,85.25 38.82,85.25 37.65,86.42 35.61,86.42 34.47,87.56 30.95,87.56 28.64,85.25 21.83,85.25 20.74,86.35 18.99,86.35 18.38,86.95 12.99,86.95 11.18,88.76 v1(11.18,88.78)
  BOTTOM w0.102: JDOCK1.79 93.7,113.13 92.36,111.8 87.15,111.8 82.04,106.68 81.53,106.68 79.4,104.56 v2(78.62,104.56) 76.15,104.56 73.31,101.72 73.31,97.68 68.57,92.94 65.91,92.94 v1(65.32,92.35)
DAT_DDC2_CRT: length 26.6
  BOTTOM w0.102: JCRT1.12 73.54,172.35 74.33,171.56 75.95,171.56 76.31,171.21 76.31,170.22 v3(76.59,169.94) 78.04,168.49 78.48,168.06 86.02,168.06 86.85,167.22 86.85,164.32 86.38,163.84 84.39,163.84 83.09,162.54 83.09,161.17 83,161.08 U19.34
DAT_DDC2_DOCK: length 36.1
  IN1 w0.109: v1(79.92,157.85) 80.16,158.09 80.29,158.09 81.16,157.21 81.16,155.69 81.04,155.57 81.04,149.14 82.14,148.04 82.14,135.93 81.83,135.62 81.83,132.07 82.35,131.54 82.35,130.51 v1(82.05,130.21)
  BOTTOM w0.102: JDOCK1.46 84.2,127.28 84.26,127.34 84.43,127.34 84.47,127.39 84.47,127.54 82.3,129.71 82.3,129.96 v1(82.05,130.21) ; U19.25 80.62,157.95 80.54,158.04 80.11,158.04 v1(79.92,157.85)
DAT_KBD: length 45.1
  TOP w0.102: RP6.8 93.8,156.49 94.22,156.91 v2(96.01,156.91) 96.66,156.91 97.21,156.35 99.86,156.35 v1(100.62,155.59)
  IN1 w0.109: v1(94.88,129.47) 95.13,129.72 95.13,139.5 93.73,140.89 93.73,143.07 93.42,143.39 93.42,146.2 94.09,146.87 94.24,146.87 97.7,150.32 97.7,151.06 96.53,152.23 96.53,153.1 97.21,153.78 97.72,153.78 99.09,155.15 100.19,155.15 v1(100.62,155.59)
  BOTTOM w0.102: v1(94.88,129.47) 93.7,128.3 JDOCK1.80 ; v1(100.62,155.59) 100.21,155.18 99.7,155.18 99.36,155.52 U51.B41
DAT_MSE: length 55.1
  TOP w0.102: v1(99.93,155.59) 99.64,155.88 98.75,155.88 v2(98.53,155.67) 97.74,154.87 96.68,154.87 96.17,155.38 95.41,155.38 94.9,154.87 94.13,154.87 94.01,154.99 RP6.5
  IN2 w0.127: v1(99.93,155.59) 100.39,156.04 101.02,156.04 102.52,154.54 102.52,152.36 101.73,151.57 101.41,151.57 100.29,150.45 100.29,149.61 97.24,146.56 97.24,146.21 96.91,145.88 96.91,143.82 97.57,143.16 97.57,140.9 91.78,135.11 91.78,132.67 92.82,131.63 92.82,127.39 90.71,125.28 90.71,121.3 v1(90.97,121.04)
  BOTTOM w0.102: JDOCK1.73 92.2,119.81 v1(90.97,121.04) ; U51.B42 99.5,156.02 v1(99.93,155.59)
DAT_TP_SIO: length 178
  TOP w0.102: v1(99.78,154.72) 99.6,154.9 98.99,154.9 97.9,153.81 97.11,153.81 96.99,153.68 96.99,152.89 96.66,152.56 94.41,152.56 93.32,153.66 92.16,153.66 90.74,155.08 90.74,158.74 89.54,159.93 v2(89.54,164.41) 89.54,166.56 v1(89.8,166.81) ; JIO1.110 15.02,78.6 16.65,80.22 16.65,80.85 16.1,81.39 14.78,81.39 v1(14.7,81.47)
  IN2 w0.127: v1(14.7,81.47) 14.7,81.48 17.08,83.86 17.08,84.7 14.72,87.06 14.72,89.77 14.28,90.21 14.28,91.15 13.32,92.12 13.32,94.78 12.73,95.36 12.73,100.56 12.02,101.27 12.02,104.15 11.33,104.84 11.33,107.46 12.45,108.59 12.45,109.81 14.11,111.47 14.11,113.62 15.5,115.01 15.74,115.01 17.1,116.37 17.1,118.11 15.68,119.54 15.68,125.25 17.46,127.04 20.98,127.04 27.44,133.5 27.44,134.36 33.99,140.92 33.99,144.72 35,145.73 38.92,145.73 41.61,148.43 41.61,149.03 46.57,153.99 49.19,153.99 49.73,154.52 49.73,155.32 50.63,156.22 52.11,156.22 52.97,157.08 54.87,157.08 56.72,158.94 61.42,158.94 69.07,166.58 70.66,166.58 72.24,168.16 87.76,168.16 89.11,166.81 v1(89.8,166.81)
  BOTTOM w0.102: v1(99.78,154.72) 99.48,155.02 U51.B40
DC_BLOCK_GC: length 2.7
  BOTTOM w0.254: PR700.1 150.7,115.48 v2(150.7,115.95) PU1001.7
DDR3_DRAMRST#_CPU: length 41.8
  TOP w0.102: v1(123.4,83.22) 123.4,83.22 124.58,82.04 124.58,75.26 125.31,74.53 RD5.2 RD12.1 ; v1(105.12,72.75) JCPU1.AN3
  BOTTOM w0.102: v1(105.12,72.75) 105.7,72.17 106.31,72.17 106.61,71.87 106.61,71.54 106.96,71.19 v2(111.22,71.19) 114.44,71.19 120.48,77.24 120.48,83.4 120.94,83.86 122.76,83.86 v1(123.4,83.22)
DDR3_DRAMRST#_R: length 52.8
  TOP w0.102: v1(143.95,83.45) 144.59,82.81 144.59,82.1 144.84,81.85 JDIMM1.30 ; v1(133.82,83.22) 133.82,82.03 132.65,80.87 132.65,77.59 RD12.2 ; v1(156.98,83.19) 156.99,83.2 157.2,83.2 158.53,81.86 JDIMM3.30
  IN4 w0.109: v1(133.82,83.22) 134.25,82.79 143.29,82.79 v1(143.95,83.45) 144.63,82.76 156.56,82.76 v1(156.98,83.19)
  BOTTOM w0.102: v1(133.82,83.22) 133.82,82.56 v2(134.11,82.26) 134.52,81.85 JDIMM2.30 ; JDIMM4.30 151.21,81.85 152.41,81.85 152.98,82.42 156.22,82.42 v1(156.98,83.19)
DDR_1.35V_CNTRL0: length 89.5
  IN3 w0.127: v1(171.36,80.25) 171.71,80.6 181.14,80.6 185.2,76.54 190.48,76.54 191.88,77.94 202.68,77.94 207.2,73.42 207.2,71.97 207.5,71.66 207.86,71.66 208.29,72.1 208.29,73.76 209.34,74.81 209.98,74.81 211.45,73.34 214.18,73.34 214.71,72.81 215.15,72.81 216.67,71.28 216.92,71.28 220.93,67.28 221.2,67.28 221.83,67.9 221.83,70.55 225.33,74.05 225.33,76.42 228.08,79.16 228.08,83.55 226.22,85.41 224.87,85.41 224.7,85.23 v1(224.14,85.23)
  BOTTOM w0.102: U46.A49 223.94,85.02 v1(224.14,85.23) ; v1(171.36,80.25) 171.36,79.16 170.54,78.34 PR216.2 170.54,78.09 PR219.1
DDR_1.35V_CNTRL1: length 56.9
  IN3 w0.127: v1(170.02,85.77) 175.56,85.77 177.5,83.83 178.88,83.83 179.31,84.26 183.22,84.26 187.57,79.92 202.5,79.92 206.89,75.52 208.62,75.52 208.92,75.83 210.4,75.83 211.87,74.36 213.72,74.36 214.11,74.74 v1(214.11,74.83)
  BOTTOM w0.102: v2(170.82,85.75) 170.8,85.77 v1(170.02,85.77) 169.71,85.46 PR222.2 170.16,84.36 170.16,81.51 PR223.1 ; U46.A16 214.17,74.95 214.11,74.89 v1(214.11,74.83)
DDR_A_BS0: length 64.6
  TOP w0.102: v1(103.03,56.86) 102.62,57.28 JCPU1.V5 ; JDIMM1.109 138.35,55.75 139.21,54.89 143.61,54.89 v1(144.04,55.31)
  IN1 w0.089: v1(103.03,56.86) 103.32,56.86 103.71,56.47 103.71,55.59 103.96,55.34 107.48,55.34 107.57,55.44 109.89,55.44
  IN1 w0.208: 109.89,55.44 120.65,55.44 121.37,54.71 122.06,54.71 122.37,54.41 127.72,54.41 128.53,55.21 134.81,55.21 135.31,55.72 137.24,55.72 137.34,55.81 141.37,55.81 141.57,56.02 145.03,56.02 145.16,55.89 145.16,55.42 145.29,55.3 148.04,55.3 148.17,55.17 148.17,54.72 148.04,54.6 144.99,54.6 144.27,55.31 v1(144.04,55.31)
  BOTTOM w0.102: JDIMM2.109 145.79,55.75 144.71,55.75 144.67,55.72 144.67,55.46 144.6,55.38 144.51,55.38 144.41,55.48 144.41,55.81 144.34,55.88 143.52,55.88 143.46,55.82 143.46,55.71 143.69,55.48 143.69,55.38 143.86,55.2 143.93,55.2 v1(144.04,55.31)
