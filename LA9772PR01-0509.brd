# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
REGCTL_PNP10: length 3.9
  TOP w0.102: v2(124.04,156.31) 123.99,156.26 L29.1
  TOP w0.508: v1(122.56,154.9) 122.39,155.08 122.39,156.05 L29.1
  BOTTOM w0.203: v1(122.56,154.9) 122.54,154.88 U31.7
REM_DIODE1_N: length 120.4
  TOP w0.254: Q26.3 90.03,54.29 C339.2 v1(90.03,52.87) ; v1(107.04,154.04) 107.3,154.29 108.21,154.29 C1343.1
  IN1 w0.254: v1(90.03,52.87) 89.77,53.12 89.77,54.03 87.56,56.24 87.56,67.9 88.65,69 88.65,79.08 92.79,83.22 92.79,88.4 96.49,92.1 96.49,94.44 95.89,95.03 95.89,104.28 97.27,105.65 97.27,106.82 98.92,108.47 98.92,114.56 99.65,115.3 99.65,126.83 98.76,127.72 98.76,130.13 99.39,130.76 99.39,134.57 98.74,135.21 98.74,146.92 100.16,148.35 100.16,150.41 101.53,151.78 102.24,151.78 102.7,152.23 102.7,153.93 103.54,154.77 103.54,154.77 103.59,154.82 106.52,154.82 107.04,154.3 v1(107.04,154.04)
  BOTTOM w0.254: v1(107.04,154.04) 107.04,154.14 107.43,154.52 U51.B13
REM_DIODE1_N_4021: length 100.3
  TOP w0.254: U29.23 170.32,129 C271.2 170.14,128.79 170.42,128.51 170.42,128 v1(170.26,127.85) ; Q16.3 91.29,112.92 C273.2 90.81,113.12 v1(90.46,113.47)
  IN4 w0.254: v1(90.46,113.47) 90.59,113.6 120.51,113.6 123.19,116.28 126.99,116.28 129.67,113.6 139.68,113.6 142.6,116.52 145.02,116.52 146.06,117.56 146.06,127.04 148.27,129.25 164.12,129.25 164.93,128.43 170.19,128.43 170.39,128.23 170.39,127.98 v1(170.26,127.85)
REM_DIODE1_P: length 124.4
  TOP w0.254: v1(89.11,52.87) C339.1 89.11,54.29 Q26.2 88.92,55.68 Q26.1 ; v1(109.91,154.24) 109.89,154.21 C1343.2
  IN1 w0.254: v1(89.11,52.87) 89.42,53.17 89.42,53.88 87.21,56.09 87.21,68.05 88.3,69.14 88.3,79.23 92.44,83.37 92.44,88.55 96.13,92.25 96.13,94.29 95.54,94.88 95.54,104.42 96.91,105.8 96.91,106.96 98.56,108.62 98.56,114.71 99.3,115.45 99.3,126.69 98.41,127.57 98.41,130.28 99.03,130.9 99.03,134.42 98.38,135.07 98.38,147.07 99.81,148.49 99.81,150.56 101.38,152.13 102.1,152.13 102.35,152.38 102.35,154.08 103.44,155.18 106.66,155.18 107.45,154.39 109.76,154.39 109.89,154.26 109.9,154.26 109.91,154.25 v1(109.91,154.24)
  BOTTOM w0.254: U51.A13 109.88,154.27 109.89,154.26 109.9,154.26 109.91,154.25 v1(109.91,154.24)
REM_DIODE1_P_4021: length 102.9
  TOP w0.254: v1(170.9,127.85) 170.77,127.98 170.77,128.53 C271.1 170.82,129.05 U29.24 ; Q16.1 92.85,113.57 Q16.2 91.29,114.22 C273.1 90.97,114.16 v1(90.46,114.16)
  IN4 w0.254: v1(90.46,114.16) 90.66,113.96 120.37,113.96 123.05,116.63 127.14,116.63 129.82,113.96 139.53,113.96 142.45,116.88 144.87,116.88 145.7,117.71 145.7,127.18 148.12,129.6 164.27,129.6 165.08,128.79 170.34,128.79 170.75,128.38 170.75,128 v1(170.9,127.85)
REM_DIODE2_N: length 110.7
  TOP w0.254: v1(107.7,153.79) 107.7,153.78 108.16,153.33 C1350.1 ; v1(113.19,91.98) 113.32,91.86 113.82,91.86 118.97,86.71 118.97,72.47 119.19,72.25 C340.2 119.3,71.67 Q17.3
  IN1 w0.254: v1(113.19,91.98) 113.37,91.81 113.88,91.81 114.08,91.6 114.69,91.6 114.97,91.88 114.97,92.6 113.55,94.02 110.83,94.02 107.5,97.35 107.5,98.41 102.83,103.08 102.83,106.69 105.11,108.97 105.11,111.12 104.35,111.88 104.35,117.74 102.93,119.17 102.93,125.05 102.5,125.48 102.5,129.45 103.01,129.96 103.01,136.16 100.11,139.06 100.11,146.26 101.97,148.12 103.87,148.12 104.99,149.23 104.99,149.87 105.95,150.84 107.35,150.84 107.76,151.24 109.21,151.24 110.45,152.48 110.45,152.85 110.12,153.17 109.23,153.17 108.61,153.79 v1(107.7,153.79)
  BOTTOM w0.254: v1(107.7,153.79) 107.93,154.02 U51.B14
REM_DIODE2_N_4021: length 133.2
  TOP w0.254: v1(173.26,131.51) 173.68,131.51 C315.1 173.61,132.01 U29.26
  IN4 w0.254: v1(173.26,131.51) 173.26,131.94 173.06,132.14 172.61,132.14 171.56,133.19 171.56,134.64 170.5,135.7 167.12,135.7 163.25,139.56 154.5,139.56 151.77,142.28 151.77,148.25 149.56,150.45 149.56,151.7 149.06,152.21 147.33,152.21 146.67,151.55 140.17,151.55 133.97,157.74 133.13,157.74 132.34,158.53 132.34,158.77 130.93,160.18 128.02,160.18 127.01,161.2 116.29,161.2 114.9,162.6 112.07,162.6 110.75,161.27 96.58,161.27 93.89,158.58 93.89,151.42 93.4,150.94 93.4,146.48 91.44,144.51 91.44,141.4 91.75,141.08 92.24,141.08 v1(92.35,141.2)
  BOTTOM w0.254: Q27.3 84.14,142.42 84.34,142.23 C291.2 85.27,141.95 85.87,141.95 v2(86.3,141.51) 86.71,141.11 92.26,141.11 v1(92.35,141.2)
REM_DIODE2_P: length 109.4
  TOP w0.254: Q17.2 118,70.16 Q17.1 118.27,71.19 C340.1 118.27,72.25 118.55,72.53 118.55,86.62 113.67,91.5 113.42,91.5 v1(113.22,91.3) ; C1350.2 109.76,153.33 v1(110.09,153.66)
  IN1 w0.254: v1(113.22,91.3) 113.37,91.45 113.73,91.45 113.93,91.25 114.84,91.25 115.32,91.74 115.32,92.75 113.7,94.37 110.98,94.37 107.86,97.5 107.86,98.56 103.18,103.23 103.18,106.54 105.47,108.82 105.47,111.26 104.71,112.02 104.71,117.89 103.29,119.31 103.29,125.2 102.85,125.63 102.85,129.31 103.36,129.81 103.36,136.31 100.47,139.2 100.47,146.11 102.12,147.76 104.02,147.76 105.34,149.08 105.34,149.72 106.1,150.48 107.5,150.48 107.91,150.89 109.36,150.89 110.8,152.33 110.8,152.99 110.14,153.66 v1(110.09,153.66)
  BOTTOM w0.254: v1(110.09,153.66) 109.98,153.77 U51.A14
REM_DIODE2_P_4021: length 134.7
  TOP w0.254: v1(173.26,133.01) 173.53,133.01 C315.2 173.77,132.51 U29.27
  IN4 w0.254: v1(173.26,133.01) 173.26,132.62 173.14,132.5 172.75,132.5 171.92,133.34 171.92,134.78 170.65,136.05 167.26,136.05 163.4,139.91 154.64,139.91 152.13,142.43 152.13,148.39 149.92,150.6 149.92,151.85 149.2,152.56 147.18,152.56 146.52,151.9 140.31,151.9 134.12,158.1 133.28,158.1 132.7,158.68 132.7,158.91 131.07,160.54 128.17,160.54 127.16,161.55 116.44,161.55 115.05,162.95 111.93,162.95 110.6,161.63 96.43,161.63 93.53,158.73 93.53,151.57 93.05,151.08 93.05,146.63 91.08,144.66 91.08,141.25 91.61,140.73 92.24,140.73 v1(92.35,140.61)
  BOTTOM w0.254: v1(92.35,140.61) 92.23,140.73 86.49,140.73 85.63,141.59 85.28,141.59 C291.1 84.47,141.31 Q27.1 82.82,141.77 Q27.2
REM_DIODE3_N: length 123.5
  TOP w0.254: C1351.1 109.69,152.44 v1(109.91,152.66)
  IN1 w0.254: v1(118.37,91.07) 118.19,90.89 116.63,90.89 116.42,90.69 106.28,90.69 105.6,91.37 105.6,96.05 104.94,96.71 104.94,100.19 101.61,103.52 101.61,106.89 103.41,108.7 103.41,112.48 102.09,113.8 102.09,124.57 101.15,125.51 101.15,134.14 100.3,134.99 100.3,137.93 99.6,138.63 99.6,146.52 101.56,148.48 101.56,150.56 101.86,150.86 104.12,150.86 104.68,151.42 107.07,151.42 107.4,151.75 108.62,151.75 108.92,152.06 108.92,152.49 109.1,152.66 v1(109.91,152.66)
  BOTTOM w0.254: Q14.3 124.66,62.17 124.54,62.29 124.54,63 C272.2 124.82,63.74 124.54,64.02 124.54,84.13 123.68,84.99 v2(123.68,86.85) 123.68,87.94 122.89,88.73 122.89,90.58 122.1,91.37 120.07,91.37 119.57,90.87 118.58,90.87 v1(118.37,91.07) ; U51.A15 109.59,153.27 109.91,152.94 v1(109.91,152.66)
REM_DIODE3_P: length 125.2
  TOP w0.254: v1(107.65,152.66) 107.88,152.44 C1351.2
  IN1 w0.254: v1(118.4,90.36) 118.22,90.54 116.77,90.54 116.57,90.33 106.13,90.33 105.24,91.22 105.24,95.9 104.58,96.56 104.58,100.04 101.25,103.37 101.25,107.04 103.06,108.84 103.06,112.33 101.74,113.66 101.74,124.42 100.8,125.36 100.8,133.99 99.94,134.84 99.94,137.79 99.25,138.48 99.25,146.67 101.2,148.63 101.2,150.71 101.71,151.22 103.98,151.22 104.53,151.78 106.92,151.78 107.25,152.11 108.47,152.11 108.57,152.2 108.57,152.54 108.44,152.66 v1(107.65,152.66)
  BOTTOM w0.254: v1(107.65,152.66) 107.76,152.66 108.11,153.02 U51.B16 ; Q14.1 124.37,61.52 Q14.2 124.07,62.17 124.19,62.29 124.19,63.05 123.96,63.28 C272.1 123.91,63.74 124.19,64.02 124.19,83.98 123.27,84.9 123.27,87.84 122.54,88.58 122.54,90.43 121.95,91.02 120.22,91.02 119.71,90.51 118.55,90.51 v1(118.4,90.36)
REM_DIODE4_N: length 220.1
  TOP w0.254: v1(121.12,92.95) 120.94,92.77 120.94,90.59 120.3,89.96 120.3,46.14 111.13,36.97 95.96,36.97 92.92,33.92 92.92,29.25 94.55,27.62 94.55,24.15 93.87,23.47 87.85,23.47 85.85,21.46 79.22,21.46 75.45,25.23 69.46,25.23 61.5,33.19 61.5,34.45 61.95,34.89 62.4,34.89 v1(62.54,35.03)
  IN1 w0.254: v1(121.12,92.95) 120.9,93.17 120.9,94.23 118.55,96.58 118.55,103.66 117.43,104.78 117.43,108.52 121.01,112.1 121.01,125.74 111.54,135.21 111.54,137.02 112.68,138.16 112.68,143.32 113.93,144.57 113.93,148.8 114.69,149.57 114.69,149.85 v1(114.84,150)
  BOTTOM w0.254: U51.A16 109.2,152.49 109.58,152.11 111.77,152.11 C1346.1 112.35,152.08 113.01,152.08 114.69,150.4 114.69,150.15 v1(114.84,150) ; v1(62.54,35.03) 62.44,34.94 62.16,34.94 62.01,35.08 62.01,40.04 60.1,41.95 56.82,41.95 C288.2 C335.2 56.82,43.28 Q15.3
REM_DIODE4_P: length 219.9
  TOP w0.254: v1(62.54,34.4) 62.41,34.54 62.1,34.54 61.86,34.3 61.86,33.34 69.6,25.59 75.59,25.59 79.37,21.82 85.7,21.82 87.71,23.82 93.72,23.82 94.19,24.29 94.19,27.44 92.57,29.07 92.57,34.07 95.82,37.32 110.99,37.32 119.95,46.28 119.95,90.1 120.58,90.74 120.58,92.72 v1(120.35,92.95)
  IN1 w0.254: v1(114.21,150) 114.33,149.87 114.33,149.71 113.57,148.95 113.57,144.71 112.33,143.47 112.33,138.31 111.18,137.17 111.18,135.07 120.66,125.59 120.66,112.25 117.08,108.67 117.08,104.63 118.19,103.52 118.19,96.43 120.54,94.08 120.54,93.14 v1(120.35,92.95)
  BOTTOM w0.254: v1(62.54,34.4) 62.37,34.58 62.01,34.58 61.65,34.94 61.65,39.89 59.95,41.59 56.26,41.59 C288.1 C335.1 56.17,43.55 Q15.1 55.52,44.82 Q15.2 ; v1(114.21,150) 114.33,150.12 114.33,150.25 112.86,151.72 112.3,151.72 C1346.2 111.77,151.75 109.43,151.75 108.66,152.52 U51.B17
RES_BIAS: length 3.5
  BOTTOM w0.102: U31.12 124.54,154.38 124.75,154.6 v2(126.4,154.6) R562.1
RESET_OUT#: length 383.3
  TOP w0.102: UH1.F10 26.56,93.59 v1(26.75,93.41) ; RH27.1 19.85,113.58 18.11,111.85 14.72,111.85 14.18,112.38 v1(13.67,112.38) ; v1(90.38,166.81) 90.38,159.42 90.97,158.84 90.97,155.23 92.31,153.88 95.75,153.88 Q52.2 96.44,153.89 R843.2 96.3,154.65 97.83,154.65 98.37,155.18 99.93,155.18 v1(100.39,154.72)
  IN1 w0.109: v1(90.38,166.81) 89.24,167.96 72.22,167.96 69.53,165.26 63.23,165.26 59.33,161.37 55.21,161.37 52.84,163.74 52.84,164.79 49.8,167.83 45.28,167.83 44.87,167.41 27.97,167.41 26.25,165.69 25.31,165.69 25.03,165.97 21.6,165.97 20.97,165.34 18.68,165.34 14.47,161.13 14.47,155.93 12.97,154.42 12.97,143.63 14.54,142.05 14.54,133.7 13.34,132.5 13.34,125.44 15.85,122.93 15.85,118.62 16.42,118.05 16.42,116.26 14.16,113.99 14.16,112.86 v1(13.67,112.38) ; v1(52.92,19.29) 52.15,20.05 50.46,20.05 46.2,24.3 46.2,26.2 45.59,26.81 45.59,28 46.62,29.03 46.62,32.84 39.65,39.81 39.65,47.54 42.42,50.3 42.42,54.77 40.1,57.09 40.1,66.42 38.05,68.47 38.05,74.96 38.64,75.54 38.64,78.4 39.84,79.6 39.84,82.99 v1(39.53,83.3)
  IN2 w0.127: v1(26.75,93.41) 26.45,93.12 26.45,92.24 26.98,91.7 26.98,91.4 26.96,91.37 26.96,90.89 28.28,89.57 28.28,88.36 29.35,87.29 30.14,87.29 30.81,87.96 35.42,87.96 36.03,87.35 38.31,87.35 v1(38.82,86.84)
  IN4 w0.109: v1(13.67,112.38) 13.66,112.38 13.12,111.84 13.12,111.48 12.67,111.03 12.67,108.49 11.32,107.13 11.32,104.04 12.12,103.23 12.12,101.3 12.85,100.57 12.85,93.68 13.84,92.7 14.64,92.7 15.06,93.11 16.1,93.11 16.87,92.35 16.87,91.16 18.54,89.5 18.54,88.99 21.74,85.79 24.65,85.79 24.91,85.53 25.53,85.53 25.95,85.11 31.43,85.11 31.67,84.87 34.79,84.87 35.14,84.52 38.79,84.52 39.53,83.78 v1(39.53,83.3)
  BOTTOM w0.102: v4(39.91,81.07) 39.91,82 39.53,82.38 v1(39.53,83.3) 39.85,83.3 40.24,83.69 40.24,85.41 40.12,85.53 39.98,85.53 38.82,86.69 v1(38.82,86.84) ; v1(52.92,19.29) 58.75,13.46 58.75,10.86 61.11,8.49 73.38,8.49 76.07,11.19 76.65,11.19 77.16,11.69 77.16,18.2 78.61,19.64 78.61,22.73 84.37,28.5 84.69,28.5 87.74,31.55 87.74,31.61 89.26,33.13 RC73.1 ; v1(100.39,154.72) 100.39,154.67 100.01,154.29 99.63,154.29 99.4,154.52 U51.B39
RESET_OUT#_R: length 3.1
  TOP w0.102: JXDP2.46 21.3,116.02 19.95,114.67 RH27.2
REXT3: length 2.9
  TOP w0.102: U9.27 18.23,154.93 18.2,154.9 17.61,154.9 v2(17.24,155.27) 17.03,155.48 R74.2
RF_+1.05VSP: length 2.8
  BOTTOM w0.102: PR305.1 24.04,147.76 v2(23.57,148.23)
  BOTTOM w0.254: PR305.1 24.02,147.17 PU300.5
RSMRST#: length 8
  TOP w0.102: v2(141.3,140.52) 141.56,140.79 R1622.1 R1630.1 142.35,141.69 144.19,141.69 144.34,141.54 U7.2 144.34,139.98 143.96,139.6 143.96,138.61 U4.3
RSMRST#_XDP: length 8
  TOP w0.102: JXDP2.39 22.8,124.4 v1(23.3,124.9)
  BOTTOM w0.102: v2(20.62,121.78) 20.99,122.15 RH26.2 21.5,122.26 22.31,122.26 22.69,122.64 22.69,124.29 v1(23.3,124.9)
RUN_ON: length 526.6
  TOP w0.102: v1(226.83,70.35) 225.39,71.79 222.11,71.79 221.2,72.71 219.06,72.71 v1(216.67,75.09) ; v1(59.98,79.31) 59.98,81.75 58.33,83.4 58.33,90.26 55.31,93.28 55.15,93.28 52.36,96.07 52.36,97.5 52.94,98.08 53.98,98.08 55.14,99.25 55.14,99.49 55.94,100.28 55.94,102.11 52.15,105.9 52.13,105.9 49.14,108.89 49.14,110.22 49.34,110.41 49.34,111.98 48.47,112.85 48.47,114.45 49.02,115 53.1,115 57.33,119.23 57.33,132.11 Q304.2 54.83,130.44 47.34,130.44 v1(47.09,130.69) ; JIO1.87 7.12,85.2 v1(5.93,86.4)
  IN1 w0.109: v1(137.84,142.78) 137.84,142.74 151.35,129.23 151.35,127.09 151.95,126.5 152.38,126.5 155.15,123.73 155.15,119.62 155.88,118.89 155.88,117.71 156.04,117.55 156.04,115.95 158.91,113.08 158.91,110.56 172.14,97.33 174.55,97.33 179.75,92.14 179.75,88.25 185.34,82.66 197.52,82.66 203.46,76.72 208.59,76.72 209.08,76.24 212.48,76.24 213.04,75.67 216.09,75.67 v1(216.67,75.09) ; v1(89.19,136.59) 89.19,136.8 88.48,137.5 88.48,140.95 v1(86.72,142.71)
  IN2 w0.127: v1(12.66,123.28) 13.14,122.79 13.14,117.18 10.45,114.49 9.2,114.49 7.63,112.91 7.63,89.04 6.87,88.28 5.98,88.28 5.5,87.79 5.5,86.83 v1(5.93,86.4) ; v1(91.97,151.66) 92.79,150.84 92.79,149.15 90.84,147.19 90.84,146.71 86.84,142.71 v1(86.72,142.71) 86.2,142.19 76.13,142.19 73.3,139.36 70.86,139.36 69.25,137.74 68.26,137.74 66.49,135.98 64.46,135.98 60.69,132.2 49.72,132.2 48.21,130.69 v1(47.09,130.69)
  IN3 w0.127: v1(87.59,160.28) 89.77,158.1 89.77,153.86 v1(91.97,151.66) 93.35,150.28 93.35,149.67 94.95,148.07 96.86,148.07 97.76,147.17 98.26,147.17 101.12,144.31 103.56,144.31 103.95,144.7 108.49,144.7 108.76,144.42 113.8,144.42 114.06,144.69 118.77,144.69 120.28,143.18 131.84,143.18 133.67,145.01 135.62,145.01 v1(137.84,142.78) ; v1(12.66,123.28) 12.66,124.39 14.46,126.2 15.99,126.2 18.35,123.84 21.01,123.84 23.55,126.38 27.14,126.38 27.49,126.02 33.54,126.02 34.63,127.11 39.68,127.11 39.84,127.26 39.84,129.86 40.19,130.22 46.61,130.22 v1(47.09,130.69) ; v1(226.83,70.35) 226.35,69.86 226.35,68.95 229.5,65.8 243.92,65.8 244.99,64.73 249.82,64.73 251.34,63.21 253.7,63.21 255.67,65.17 258.69,65.17 259.34,64.53 268.77,64.53 270.66,62.63 270.66,45.78 263.8,38.92 261.5,38.92 v1(261.45,38.87)
  BOTTOM w0.102: RP4.2 228.26,70.57 228.08,70.75 227.23,70.75 v1(226.83,70.35) ; U37.3 50.94,73.9 50.55,73.52 49.77,73.52 49.28,74 49.28,77.35 49.67,77.73 49.67,78.9 49.92,79.16 51.7,79.16 52.31,78.55 57.16,78.55 57.92,79.31 v1(59.98,79.31) ; v1(89.19,136.59) 88.87,136.59 87.54,135.25 R15.1 ; PR406.1 260.66,37.58 261.45,38.36 v1(261.45,38.87) ; U46.A11 216.67,75.09 v1(216.67,75.09) ; U19.2 86.6,159.55 86.7,159.65 86.95,159.65 v2(87.23,159.92) v1(87.59,160.28)
RUN_ON_ENABLE#: length 73.1
  TOP w0.102: v1(45.12,134.86) 45.12,133.18 46.29,132.01 47.33,132.01 47.93,131.42 52.51,131.42 R909.2 55.52,134.42 Q304.6 Q304.5
  IN2 w0.127: v1(87.07,144.37) 86.41,144.37 85.24,143.2 76.07,143.2 74.51,141.64 71.15,141.64 69.71,140.19 69.71,139.38 68.83,138.5 67.94,138.5 66.18,136.74 64.14,136.74 61.02,133.61 46.26,133.61 45.12,134.76 v1(45.12,134.86)
  BOTTOM w0.102: Q45.2 94.11,144.67 93.89,144.89 v2(89.82,144.89) 87.59,144.89 v1(87.07,144.37)
RUNPWROK: length 204.3
  TOP w0.102: v1(101.08,145.02) 102.85,146.8 102.85,147.32 104.05,148.52 104.05,151.59 103.97,151.66 103.97,152.99 v1(104.07,153.1)
  IN1 w0.109: v1(101.08,145.02) 101.2,144.89 101.2,143.8 102.79,142.21 102.79,137.87 104.4,136.26 104.4,129.07 105.29,128.18 105.29,124.69 104.35,123.75 104.35,119.46 106.78,117.03 106.78,108.82 104.68,106.72 104.68,102.83 109.2,98.31 109.2,97.62 111.64,95.18 113.88,95.18 117,92.06 118.4,92.06 118.86,91.6 123.03,91.6 125.09,93.66 158.09,93.66 158.56,93.2 165.6,93.2 177.13,81.68 181.23,81.68 183.42,79.49 195.29,79.49 204.69,70.09 216.8,70.09 218.42,71.71 219.77,71.71 220.28,72.22 v1(220.28,72.25)
  BOTTOM w0.102: U51.B26 103.75,152.77 v1(104.07,153.1) ; Q45.1 100.77,145.32 v1(101.08,145.02) ; Q45.1 v4(95.45,145.32) 92.49,145.32 92.24,145.58 U50.2 ; Q45.1 98.79,145.37 R799.2 ; v1(220.28,72.25) 220.28,72.12 220.24,72.16 220.24,75.25 220.17,75.32 U46.A4
S3_1.35V: length 3.8
  BOTTOM w0.102: PU200.7 177.49,79.12 176.82,79.79 176.31,79.79 v2(176.02,80.08) 175.8,80.3 175.8,81.24 PR208.2
S5_1.35V: length 3.8
  BOTTOM w0.102: PR206.2 PR240.1 177.91,81.32 PC215.1 177.91,79.41 177.89,79.39 PU200.8
SATA_ACT#: length 139.5
  TOP w0.102: UH1.AP3 38.41,90.49 38.46,90.43 38.46,90.43 38.51,90.38 38.51,90.13 38.69,89.95 38.69,89.94 38.72,89.91 38.72,89.11 42.51,85.31 42.51,84.77 42.66,84.63 42.66,81.75 43.81,80.59 44.33,80.59 46.39,78.53 46.39,77.79 45.75,77.15 41.21,77.15 38.51,79.84 35.29,79.84 34.98,79.54 v2(32.56,79.54) 31.9,79.54 v1(30.62,78.26) ; Q74.4 v1(8.06,150.03)
  IN1 w0.109: v1(8.06,150.03) 8.06,144.83 11.85,141.04 11.85,134.91 10.58,133.64 10.58,132.04 9.64,131.1 9.64,130.52 10.42,129.73 10.42,129.07 9.08,127.73 9.08,125.69 12.86,121.9 12.86,117.09 8.14,112.37 8.14,99.86 5.67,97.39 5.67,93.68 3.65,91.66 3.65,90.55 3.15,90.06 3.15,85.5 3.88,84.78 5.64,84.78 6.35,85.49 12.21,85.49 12.93,84.77 16.63,84.77 21.46,79.94 24.19,79.94 24.44,79.69 28.78,79.69 29.27,79.19 29.68,79.19 v1(30.62,78.26)
SATA_COMP: length 2
  TOP w0.254: v1(41.23,91.27) 41.23,91.24 40.94,91.53 UH1.AY5
  BOTTOM w0.254: RH57.1 41.11,91.16 41.23,91.28 v1(41.23,91.27)
SATA_LED: length 79.4
  TOP w0.102: v1(16.06,84.01) 14.25,82.2 JIO1.98 ; v2(7.55,146.07) 7.58,146.05 R934.2 8.53,145.43 v1(8.54,145.41)
  IN2 w0.127: v1(8.54,145.41) 8.63,145.41 12.86,141.18 12.86,135.35 11.06,133.55 11.06,126.29 13.9,123.44 13.9,116.79 10.84,113.73 9.56,113.73 9.05,113.22 9.05,111.31 8.39,110.65 8.39,96.81 10.38,94.82 10.38,93.58 11.29,92.67 11.29,91.63 12.48,90.44 12.48,84.51 13.92,83.07 15.15,83.07 16.06,83.98 v1(16.06,84.01)
SATA_ODD_PRX_DTX_N1: length 3.6
  TOP w0.102: JODD1.5 37.37,45.5 37.95,44.92 39.05,44.92 39.23,45.1 C432.1
SATA_ODD_PRX_DTX_N1_C: length 66.4
  TOP w0.102: v1(40.83,45.5) 41.03,45.3 41.03,45.1 40.85,44.91 40.6,44.91 C432.2 ; UH1.BC10 42.45,93.91 42.92,93.91 43.13,94.12 43.57,94.12 43.66,94.03 45.26,94.03 46.59,92.7 46.95,92.7 49.17,90.47 49.17,89.77 v1(49.27,89.67)
  IN4 w0.117: v1(40.83,45.5) 41.02,45.31 41.02,45.12 40.88,44.98 40.34,44.98 40.12,45.19 40.12,45.81 40.92,46.61 41.23,46.61 42.21,47.58 42.21,50.23 42.38,50.4 42.38,54.57 40,56.94 40,66.39 37.45,68.95 37.45,75.8 39.56,77.91 41.69,77.91 46.59,82.81 46.59,86.98 48.5,88.89 48.8,88.89 49.09,89.17 49.09,89.49 v1(49.27,89.67)
SATA_ODD_PRX_DTX_P1: length 3.5
  TOP w0.102: JODD1.6 37.47,44.23 37.95,44.71 39.05,44.71 39.23,44.53 C430.1
SATA_ODD_PRX_DTX_P1_C: length 66.3
  TOP w0.102: v1(41.46,45.5) 41.25,45.29 41.25,45.01 40.94,44.7 40.6,44.7 C430.2 ; UH1.BE10 43.35,93.91 43.48,93.91 43.57,93.81 45.17,93.81 46.5,92.48 46.86,92.48 48.95,90.38 48.95,89.93 48.7,89.67 v1(48.68,89.67)
  IN4 w0.117: v1(41.46,45.5) 41.26,45.3 41.26,45.02 40.98,44.74 40.24,44.74 39.89,45.1 39.89,45.91 40.83,46.85 41.13,46.85 41.97,47.68 41.97,50.33 42.14,50.5 42.14,54.47 39.76,56.85 39.76,66.3 37.21,68.85 37.21,75.9 39.46,78.15 41.59,78.15 46.36,82.91 46.36,87.08 48.4,89.12 48.7,89.12 48.85,89.27 48.85,89.57 48.75,89.67 v1(48.68,89.67)
SATA_ODD_PTX_DRX_N1: length 3.6
  TOP w0.102: C434.1 39.23,48.37 39.03,48.57 37.97,48.57 37.45,48.04 JODD1.3
SATA_ODD_PTX_DRX_N1_C: length 57.6
  TOP w0.102: UH1.AV10 40.13,93.77 v1(40.48,93.41) ; C434.2 40.14,48.3 40.45,48.61 40.82,48.61 41.03,48.4 41.03,48.17 v1(40.83,47.97)
  IN3 w0.127: v1(40.48,93.41) 40.64,93.41 40.75,93.3 40.75,92.95 41.05,92.65 41.44,92.65 41.84,93.06 42.17,93.06 43.9,91.32 43.9,87.13 v1(43.72,86.95)
  IN4 w0.117: v1(43.72,86.95) 43.92,86.76 43.92,85.08 44.36,84.64 44.36,82.34 41.89,79.88 40.14,79.88 36.48,76.21 36.48,68.52 39.03,65.97 39.03,56.52 41.39,54.16 41.39,50.79 41.02,50.43 41.02,48.16 v1(40.83,47.97)
SATA_ODD_PTX_DRX_P1: length 3.5
  TOP w0.102: JODD1.2 37.48,49.31 38,48.78 39.05,48.78 39.23,48.96 C433.1
SATA_ODD_PTX_DRX_P1_C: length 57.6
  TOP w0.102: UH1.AW10 40.72,93.82 v1(41.14,93.41) ; C433.2 40.5,48.82 40.91,48.82 41.25,48.49 41.25,48.18 v1(41.46,47.97)
  IN3 w0.127: v1(41.14,93.41) 41,93.28 41,93.05 41.15,92.9 41.33,92.9 41.74,93.3 42.27,93.3 44.15,91.43 44.15,87.16 v1(44.35,86.95)
  IN4 w0.117: v1(44.35,86.95) 44.15,86.76 44.15,85.18 44.59,84.74 44.59,82.24 41.99,79.64 40.24,79.64 36.71,76.11 36.71,68.62 39.26,66.07 39.26,56.62 41.62,54.26 41.62,50.69 41.26,50.33 41.26,48.17 v1(41.46,47.97)
SATA_PRX_DKTX_N2: length 4.8
  TOP w0.102: C698.2 88.34,127.07 88.34,127.37 87.56,128.15 87.56,128.37 v1(87.77,128.57)
  BOTTOM w0.102: v1(87.77,128.57) 87.56,128.36 87.56,127.37 87.7,127.23 JDOCK1.56
SATA_PRX_DKTX_N2_C: length 74.2
  TOP w0.076: UH1.BB9 42.36,93.41 42.68,93.09 42.93,93.09 43.15,93.31 43.39,93.31 43.41,93.29 43.43,93.29
  TOP w0.102: C698.1 88.34,125.48 88.34,124.92 87.93,124.51 83.36,124.51 80.98,122.13 80.22,122.13 v1(80.04,121.96) ; v1(45.58,91.78) 45.78,91.98 45.78,92.21 44.7,93.29 43.43,93.29
  IN3 w0.127: v1(80.04,121.96) 80.2,122.11 80.42,122.11 80.56,121.98 80.56,119.82 78.29,117.56 78.29,107.19 74.38,103.28 74.38,102.28 71.91,99.8 70.84,99.8 69.47,98.42 69.47,97.87 68.17,96.57 67.43,96.57 65.15,94.29 63.21,94.29 62.78,93.86 57.34,93.86 56.98,94.22 54.34,94.22 52.71,95.84 51.98,95.84 51.42,95.29 51.42,94.93 49.41,92.92 46.15,92.92 45.7,92.46 45.7,91.9 v1(45.58,91.78)
SATA_PRX_DKTX_P2: length 4.8
  TOP w0.102: C697.2 88.13,127.07 88.13,127.28 87.35,128.06 87.35,128.38 v1(87.16,128.57)
  BOTTOM w0.102: JDOCK1.54 87.2,127.2 87.34,127.34 87.34,128.39 v1(87.16,128.57)
SATA_PRX_DKTX_P2_C: length 74.1
  TOP w0.076: 43.43,93.51 43.41,93.51 43.39,93.48 43.17,93.48 43.04,93.61 42.81,93.61 42.73,93.53 42.73,93.46 UH1.BD9
  TOP w0.102: 43.43,93.51 44.79,93.51 46,92.3 46,91.86 46.07,91.79 v1(46.19,91.79) ; C697.1 88.13,125.48 88.13,125.01 87.84,124.72 83.27,124.72 80.89,122.35 80.16,122.35 80.04,122.46 v1(80.04,122.57)
  IN3 w0.127: v1(80.04,122.57) 80.04,122.49 80.17,122.36 80.53,122.36 80.81,122.08 80.81,119.72 78.54,117.46 78.54,107.08 74.63,103.18 74.63,102.17 72.01,99.55 70.95,99.55 69.72,98.32 69.72,97.76 68.27,96.32 67.53,96.32 65.25,94.04 63.31,94.04 62.88,93.61 57.23,93.61 56.87,93.97 54.24,93.97 52.61,95.6 52.08,95.6 51.67,95.18 51.67,94.82 49.51,92.67 46.26,92.67 45.95,92.36 45.95,91.99 46.16,91.79 v1(46.19,91.79)
SATA_PRX_DTX_N3: length 3.3
  TOP w0.102: C673.2 43.36,167.34 43.36,167.75 44.12,168.5 44.12,169.14 43.98,169.27 JESA1.9
SATA_PRX_DTX_P3: length 3.2
  TOP w0.102: JESA1.10 44.48,169.27 44.33,169.12 44.33,168.41 43.58,167.66 43.58,167.34 C674.2
SATA_PTX_DKRX_N2: length 6.4
  TOP w0.102: v1(90.33,129.09) 90.12,128.88 90.12,128.52 89.65,128.05 89.65,127.7 90.12,127.23 90.12,126.95 90.33,126.73 C700.1
  BOTTOM w0.102: JDOCK1.62 89.2,127.19 89.06,127.33 89.06,127.57 90.12,128.62 90.12,128.88 v1(90.33,129.09)
SATA_PTX_DKRX_N2_C: length 74.5
  TOP w0.102: C700.2 90.13,125.49 90.13,125.33 90.34,125.12 90.34,124.58 89.49,123.73 89.11,123.73 89.1,123.72 88.57,123.72 88.55,123.73 84.59,123.73 81.23,120.37 80.26,120.37 v1(80.04,120.15) ; UH1.AY13 41.32,94.55 v1(41.11,94.34)
  IN3 w0.089: v1(41.11,94.34) 41.04,94.34 40.88,94.5 40.88,94.63 40.98,94.73 41.43,94.73 41.46,94.69 41.49,94.69
  IN3 w0.127: v1(80.04,120.15) 79.87,120.33 79.58,120.33 77.27,118.03 77.27,116.72 77.61,116.38 77.61,107.24 73.87,103.5 73.87,102.5 71.69,100.32 70.61,100.32 68.96,98.67 68.96,98.08 67.95,97.08 67.21,97.08 64.93,94.8 54.5,94.8 52.94,96.36 51.75,96.36 50.91,95.51 50.91,95.15 49.54,93.79 44.51,93.79 43.61,94.69 41.49,94.69
SATA_PTX_DKRX_P2: length 6.4
  TOP w0.102: C699.1 89.72,126.73 89.9,126.91 89.9,127.14 89.43,127.61 89.43,128.14 89.9,128.61 89.9,128.89 v1(89.7,129.09)
  BOTTOM w0.102: v1(89.7,129.09) 89.9,128.89 89.9,128.71 88.85,127.66 88.85,127.33 88.7,127.18 JDOCK1.60
SATA_PTX_DKRX_P2_C: length 74.5
  TOP w0.102: v1(40.48,94.34) 40.72,94.58 UH1.AW13 ; C699.2 89.91,125.47 89.91,125.24 90.13,125.03 90.13,124.67 89.4,123.95 v3(88.83,123.95) 84.5,123.95 81.14,120.58 80.25,120.58 v1(80.04,120.79)
  IN3 w0.089: v1(40.48,94.34) 40.54,94.34 40.7,94.5 40.7,94.7 40.9,94.91 41.43,94.91 41.46,94.94 41.49,94.94
  IN3 w0.127: 41.49,94.94 43.71,94.94 44.61,94.04 49.44,94.04 50.66,95.25 50.66,95.62 51.65,96.61 53.04,96.61 54.6,95.05 64.83,95.05 67.11,97.33 67.85,97.33 68.71,98.19 68.71,98.77 70.51,100.57 71.59,100.57 73.62,102.61 73.62,103.61 77.37,107.35 77.37,116.27 77.03,116.61 77.03,118.13 79.47,120.58 79.83,120.58 v1(80.04,120.79)
SATA_PTX_DRX_N3: length 2.9
  TOP w0.102: C672.2 40.53,167.34 40.53,169.12 40.67,169.27 JESA1.7
SATA_PTX_DRX_P3: length 3
  TOP w0.102: JESA1.6 40.17,169.27 40.31,169.13 40.31,167.34 C671.2
SATA_SIDE_LED: length 70
  TOP w0.102: JIO1.90 14.37,84.6 v1(14.97,85.2) ; v2(16.89,143.95) 16.53,143.6 v1(16.04,143.6)
  IN2 w0.127: v1(16.04,143.6) 14.99,143.6 14.13,142.73 14.13,141.78 14.74,141.17 14.74,138.57 14.23,138.06 14.23,133.18 13.37,132.32 13.37,127.75 15.17,125.94 15.17,119.33 16.59,117.9 16.59,116.59 15.53,115.52 15.29,115.52 13.6,113.83 13.6,113.44 11.13,110.98 11.13,108.19 10.82,107.88 10.82,104.63 11.26,104.19 11.26,101.31 12.23,100.34 12.23,95.15 12.81,94.57 12.81,91.91 13.78,90.94 13.78,87.64 14.97,86.45 v1(14.97,85.2)
  BOTTOM w0.102: R943.2 v1(16.04,143.6)
SB#: length 21
  IN2 w0.127: v1(258.71,104.87) 259.14,104.44 259.14,103.08 258.59,102.54 255.21,102.54 253.98,101.31 253.98,100.65 v1(254.48,100.15)
  BOTTOM w0.102: U2.8 254.55,105.91 253.32,104.68 253.32,101.31 v2(253.7,100.92) v1(254.48,100.15) ; R1626.2 258.23,104.87 v1(258.71,104.87) 260.11,104.87 Q338.2
SCLK: length 4.8
  TOP w0.102: PR508.2 48.87,22.13 v1(48.93,22.2) 48.93,22.21 v2(49.37,22.65) 49.42,22.71 49.46,22.71 50.92,24.16 PU500.1
  BOTTOM w0.102: PR504.1 48.99,22.13 v1(48.93,22.2)
SDA: length 5.1
  TOP w0.102: PU500.31 50.34,25.2 49.78,24.64 49.4,24.64 48.93,24.17 v1(48.93,23.98) 48.31,23.98 PR505.2
  BOTTOM w0.102: PR500.1 48.99,23.91 v1(48.93,23.98) 48.93,24.74 v2(48.71,24.95)
SEL: length 6.2
  BOTTOM w0.102: R1614.1 259.56,105.58 Q338.1 259.03,105.45 v2(257.92,106.55) 257.81,106.55 256.97,107.39 256.97,107.49 256.66,107.79 U2.4
SIO_14M: length 3.9
  TOP w0.102: UH1.F38 v1(26.56,105.78)
  BOTTOM w0.102: RH157.2 23.63,105.6 25.21,105.6 25.41,105.8 26.54,105.8 v1(26.56,105.78)
SIO_A20GATE: length 140.1
  TOP w0.102: UH1.AN10 38.34,93.51 38.59,93.26 v1(38.64,93.26)
  IN2 w0.127: v1(97.57,158.85) 98.74,160.02 100.86,160.02 101.56,159.32 102.07,159.32 104.99,156.4 104.99,155.79 106.26,154.52 106.26,152.41 105.9,152.06 103.89,152.06 102.47,150.63 102.47,150.18 102.22,149.92 101.96,149.92 98.71,146.67 98.71,140.43 94.17,135.88 94.17,132.45 93.58,131.87 93.58,126.65 92.19,125.25 92.19,114.19 91.01,113.02 89.93,113.02 89.49,113.46 82.75,113.46 81.54,112.25 71.46,112.25 68.39,109.18 68.39,107.81 67.52,106.95 67.52,105.21 64.15,101.84 62.1,101.84 60.43,103.52 54.66,103.52 53.3,102.16 52.27,102.16 51.39,101.29 51.39,97.72 50.18,96.51 45.12,96.51 43.44,94.83 38.46,94.83 38.16,94.52 38.16,94.22 38.59,93.79 38.59,93.3 v1(38.64,93.26)
  BOTTOM w0.102: v1(38.64,93.26) 38.24,92.86 38.24,92.49 38.24,92.35 38.06,92.17 38.06,91.6 37.98,91.53 37.98,88.87 39.59,87.26 40.44,87.26 40.93,86.78 v2(40.93,86.05) RH202.1 ; v1(97.57,158.85) 97.65,158.77 U51.A45
SIO_EXT_SCI#: length 116.4
  TOP w0.102: v1(97.6,152.33) v2(97.6,151.74)
  IN1 w0.109: v1(92.19,102.7) 92.46,102.98 92.46,106.59 93.6,107.73 93.6,109.85 93.25,110.2 93.25,110.86 94.79,112.39 94.79,117.8 93.91,118.68 93.91,122.22 92.89,123.24 92.89,124.96 94.92,126.99 94.92,128.53 95.36,128.97 95.36,139.66 94.61,140.41 94.61,141.76 94.44,141.93 94.44,146.73 97.93,150.23 97.93,151.16 97.6,151.5 v1(97.6,152.33)
  IN2 w0.127: v1(43.14,86.95) 43.14,86.96 43.55,87.37 45.42,87.37 49.06,91.02 54.17,91.02 54.85,91.7 64.29,91.7 65.03,90.97 66.63,90.97 69.3,93.64 69.3,95.26 71.76,97.72 72.3,97.72 73.49,98.92 73.49,99.33 74.7,100.54 79.58,100.54 81.4,102.36 91.84,102.36 v1(92.19,102.7)
  BOTTOM w0.102: v1(97.6,152.33) 98.03,152.77 U51.A33 ; RPH10.8 44.47,85.75 44.03,86.19 43.9,86.19 v1(43.14,86.95) RH195.1
SIO_EXT_SMI#: length 257
  TOP w0.102: UH1.M1 29.47,89.55 29.27,89.34 29.27,88.35 27.8,86.88 26.94,86.88 25.83,85.77 RPH7.4 25.83,85.09 25.36,84.62 25.36,82.21 v1(26.17,81.39)
  IN1 w0.109: v1(17.64,125.87) 15.55,125.87 13.6,127.82 13.6,132.37 14.78,133.55 14.78,142.15 13.2,143.72 13.2,154.32 14.71,155.83 14.71,161.04 18.76,165.09 25.98,165.09 28.01,167.12 44.9,167.12 45.33,167.55 49.75,167.55 52.6,164.69 52.6,163.41 54.88,161.13 59.53,161.13 63.41,165.01 69.88,165.01 71.38,166.5 89.29,166.5 89.71,166.08 93.72,166.08 101.37,173.74 112.95,173.74 115.77,170.91 117.37,170.91 v1(118.09,170.19)
  IN4 w0.109: v1(17.64,125.87) 17.64,122.61 13.09,118.07 13.09,116.68 9.46,113.05 9.46,111.16 8.02,109.72 8.02,89.6 11.66,85.96 15.46,85.96 17.33,84.1 17.89,84.1 19.57,82.41 23.89,82.41 24.11,82.19 25.37,82.19 v1(26.17,81.39)
  BOTTOM w0.102: U51.A6 109.69,157.77 109.81,157.9 110.83,157.9 111.08,158.15 113.19,158.15 115.27,160.23 115.27,167.7 116.11,168.54 116.52,168.54 v2(117.33,169.35) 118.09,170.11 v1(118.09,170.19) ; v1(17.64,125.87) 20.1,125.87 20.33,126.1 23.33,126.1 23.73,125.69 23.73,123.23 RH10.1
SIO_EXT_WAKE#: length 368
  TOP w0.102: UH1.Y1 32.65,89.71 32.65,87.4 32.21,86.97 31.79,86.97 30.31,85.49 30.31,82.46 RH210.1 v1(30.77,81.39) ; v1(220.96,85.2) 220.96,85.81 220.6,86.17 220.6,88.24 221.22,88.86 v1(221.22,92.7) ; v1(38.52,118.5) v2(38.52,117.82) RH24.1
  IN2 w0.127: v1(38.52,118.5) 38.52,120.74 38.22,121.03 38.22,130.63 44.79,137.2 45.43,137.2 48.92,140.69 49.53,140.69 54.79,145.95 56.81,145.95 60.02,149.16 61.31,149.16 68.73,156.58 75.32,156.58 79.28,160.54 84.97,160.54 85.76,161.33 86.34,161.33 86.78,160.89 94.95,160.89 95.39,161.33 96.69,161.33 97.57,162.21 97.57,163.37 98.26,164.06 113.11,164.06 113.2,164.15 114.14,164.15 114.91,163.38 114.91,162.86 116.46,161.3 119.54,161.3 120.46,160.38 120.46,159.96 123.04,157.38 125.12,157.38 126.03,156.46 126.03,154.84 126.63,154.24 126.93,154.24 128.73,152.44 133.21,152.44 134.18,151.46 134.18,149.28 135.34,148.13 144.07,148.13 147.81,144.38 147.81,142.71 155.93,134.59 155.93,131.4 157.24,130.08 164.58,130.08 166.01,128.66 171.26,128.66 171.74,128.18 171.74,125.87 176.95,120.66 176.95,108.96 178.39,107.52 182.57,107.52 187.84,102.25 196.27,102.25 199.65,98.87 200.19,98.87 205.55,93.51 220.4,93.51 v1(221.22,92.7)
  IN3 w0.127: v1(30.77,81.39) 29.83,82.33 13.49,82.33 7.5,88.33 6.03,88.33 4.81,89.55 4.81,90.33 4.94,90.46 4.94,96.44 6.69,98.19 6.69,113.6 8.09,115 10.24,115 17.84,122.6 24.87,122.6 25.51,123.25 31.24,123.25 33.76,120.74 36,120.74 36.36,121.09 38.11,121.09 38.52,120.69 v1(38.52,118.5)
  BOTTOM w0.102: v1(220.96,85.2) 220.96,85.23 220.92,85.18 U46.B49
SIO_PWRBTN#: length 339.1
  TOP w0.102: v1(23.38,81.09) 23.1,81.37 23.1,83.04 23.61,83.55 v1(23.71,83.55) 23.71,85.22 24.37,85.89 24.97,85.89 26.65,87.57 27.52,87.57 28.58,88.63 28.58,89.71 UH1.K1
  IN1 w0.109: v1(95.72,114.44) 95.72,117.88 95.25,118.34 95.25,123.39 96.16,124.3 96.16,127.94 96.02,128.08 96.02,128.51 96.09,128.58 96.09,136.83 v1(97.01,137.75)
  IN2 w0.127: v1(97.01,137.75) 100.01,140.75 100.01,146.75 101.28,148.02 102.1,148.02 102.74,148.66 102.74,150.54 104,151.8 106,151.8 106.51,152.31 106.51,154.62 105.24,155.89 105.24,156.51 102.24,159.5 v1(102.24,159.85)
  IN3 w0.127: v1(23.38,81.09) 24.11,81.82 28.25,81.82 29.69,80.39 31.01,80.39 31.25,80.63 31.25,81.54 31.63,81.93 34.85,81.93 35.37,81.4 36.2,81.4 36.65,80.96 37.83,80.96 38.21,81.34 38.21,81.42 38.79,82 42.3,82 42.93,81.37 44.82,81.37 47.26,83.81 50.75,83.81 52.37,85.42 53.36,85.42 57.36,89.42 57.36,90.26 57.87,90.76 66.09,90.76 72.53,97.2 72.81,97.2 73.39,97.78 73.39,98.76 75.36,100.72 78.47,100.72 80.05,102.3 82.16,102.3 85.84,105.97 85.84,109.99 87.13,111.29 87.13,114.31 88.43,115.61 91.32,115.61 91.9,115.02 95.13,115.02 v1(95.72,114.44)
  IN4 w0.109: v1(72.17,13.45) 72.17,13.34 71.1,12.27 48.53,12.27 43.29,17.51 43.29,24.83 39.68,28.44 39.68,30.94 39.17,31.45 39.17,37.21 36.73,39.66 36.73,48.86 39.45,51.59 39.45,53.34 37.06,55.73 37.06,65.19 34.5,67.76 34.5,77.41 35.18,78.1 35.18,80.47 33.46,82.19 26.78,82.19 26.07,82.9 24.41,82.9 23.75,83.55 v1(23.71,83.55) 23.28,83.12 19.87,83.12 18.17,84.82 17.61,84.82 15.05,87.38 14.43,87.38 12.12,89.69 11.5,89.69 8.49,92.7 8.49,109.53 10.12,111.15 10.12,111.19 11.21,112.28 11.21,113.96 13.56,116.31 13.56,117.87 18.14,122.44 18.14,124.92 v1(18.68,125.46)
  BOTTOM w0.102: U51.B58 102.75,160.36 v1(102.24,159.85) ; RH28.1 21.48,123.29 21.48,125.25 v2(21.31,125.42) 20.86,125.87 20.42,125.87 20.02,125.46 v1(18.68,125.46) ; RC6.1 v1(72.17,13.45)
SIO_RCIN#: length 120.8
  TOP w0.102: UH1.AT6 39.36,91.72 39.55,91.91 v1(39.63,91.91)
  IN2 w0.127: v1(102.14,149.49) 102,149.49 98.97,146.45 98.97,140.32 94.42,135.77 94.42,132.34 93.84,131.76 93.84,126.54 92.44,125.15 92.44,114.08 91.12,112.76 89.82,112.76 89.38,113.2 82.85,113.2 81.65,112 71.56,112 68.64,109.08 68.64,107.71 67.78,106.84 67.78,105.11 64.26,101.59 62,101.59 60.32,103.26 54.77,103.26 53.41,101.9 52.37,101.9 51.65,101.18 51.65,97.61 50.29,96.25 45.22,96.25 42.68,93.71 41.56,93.71 41.36,93.91 39.53,93.91 39.12,93.51 39.12,92.41 v1(39.63,91.91)
  BOTTOM w0.102: RPH10.7 43.97,85.74 43.16,86.55 42.45,86.55 40.55,88.45 39.69,88.45 39.2,88.94 39.2,89.93 v2(39.38,90.1) 39.51,90.23 39.51,91.79 v1(39.63,91.91) ; U51.A27 102.5,150.73 102.45,150.68 102.45,150.18 102.14,149.87 v1(102.14,149.49)
SIO_SLP_A#: length 528.4
  TOP w0.102: v1(19.67,80.6) 19.19,81.09 v2(19.19,83.87) 19.19,85.52 19.75,86.09 20.54,86.09 21.05,86.6 22.67,86.6 22.92,86.85 22.92,87.43 24.35,88.86 26.17,88.86 26.59,89.28 v1(26.59,89.28) 26.64,89.28 26.79,89.43 26.79,89.92 26.99,90.12 UH1.F3 ; v1(86.15,25.13) 86.15,26.66 85.01,27.8 85.01,28.33 84.98,28.36 JAPS1.6 ; UH2.1 v1(9.99,129.52) ; PR303.1 v1(17.36,146.39)
  IN1 w0.109: v1(9.99,129.52) 9.99,128.97 8.84,127.82 8.84,125.59 12.63,121.8 12.63,117.19 7.9,112.47 7.9,99.98 5.43,97.51 5.43,93.77 3.41,91.76 3.41,90.65 2.92,90.16 2.92,85.41 3.78,84.54 5.74,84.54 6.45,85.25 12.12,85.25 12.84,84.53 16.15,84.53 19.67,81.01 v1(19.67,80.6) ; v1(221.83,79.77) 223.71,79.77 223.88,79.94 225.46,79.94 228.26,77.14 237.08,77.14 238.38,75.85 244.13,75.85 246.58,78.3 251.13,78.3 253.48,80.66 261.31,80.66 271.94,70.03 271.94,46.57 262.51,37.13 261.38,37.13 260.65,37.87 257.9,37.87 257.08,37.05 251.73,37.05 250.56,35.87 236.87,35.87 222.64,21.64 200.37,21.64 199.56,20.84 132.02,20.84 131.43,21.43 107.05,21.43 103.69,24.79 86.49,24.79 v1(86.15,25.13)
  IN4 w0.109: v1(86.15,25.13) 85.31,24.29 85.31,23.39 85.28,23.35 85.28,22.24 74.74,11.69 74.74,10.58 72.89,8.73 54.45,8.73 54.01,9.17 50.6,9.17 42.56,17.21 42.56,24.4 38.96,28.01 38.96,30.66 38.46,31.16 38.46,36.92 36.02,39.36 36.02,49.16 38.73,51.87 38.73,53.06 36.34,55.46 36.34,64.9 33.77,67.46 33.77,71.51 31.47,73.81 31.47,76.09 28.01,79.55 20.72,79.55 v1(19.67,80.6) ; v1(9.99,129.52) 12.52,132.04 12.52,133.36 16.67,137.51 16.67,145.71 v1(17.36,146.39)
  BOTTOM w0.102: U46.B63 v1(221.83,79.77)
SIO_SLP_LAN#: length 360.5
  TOP w0.102: U63.3 126.76,164.84 127.07,164.53 v1(127.07,163.4) 127.68,163.4 v2(127.69,163.38) ; UH1.G5 26.78,91.35 v1(26.58,91.55)
  IN1 w0.109: v1(219.77,75.09) 219.77,75.14 220.41,75.78 222.33,75.78 222.44,75.67 223.13,75.67 224.54,77.09 224.54,78.19 224.29,78.45 223.02,78.45 222.97,78.4 221.65,78.4 221.4,78.65 221.4,78.98 219.52,80.86 219.52,85.53 218.54,86.51 212.17,86.51 211.03,87.64 202.35,87.64 198.94,91.04 198.94,93.91 193.2,99.65 186.29,99.65 177.21,108.74 177.21,109.45 175.68,110.98 175.27,110.98 172.86,113.4 172.86,120.13 171.28,121.7 171.28,124.72 173.95,127.39 173.95,134.68 173.25,135.38 166.97,135.38 165.75,134.16 160.59,134.16 160.03,134.72 159.23,134.72 156.73,137.21 156.73,140 154.89,141.85 153.47,141.85 152,143.31 152,145.43 152.72,146.15 152.72,149.5 151.91,150.31 151.2,150.31 149.06,152.46 149.06,154.16 148.58,154.63 146.16,154.63 141.32,159.47 137.74,159.47 134.76,162.45 129.01,162.45 128.06,163.4 v1(127.07,163.4)
  IN2 w0.127: v1(26.58,91.55) 26.5,91.55 26.07,91.12 26.07,90.59 25.84,90.36 24.9,90.36 22.67,92.59 20.53,92.59 19.08,94.03 19.08,94.81 18.69,95.2 18.18,95.2 17.94,95.44 17.94,97.08 17.43,97.58 17.43,100.74 16.16,102.02 16.16,106.12 16.96,106.93 16.96,109.14 19.67,111.85 19.67,114.19 20.27,114.78 20.27,115.07 22.46,117.27 22.85,117.27 25.07,119.49 25.07,123.59 26.09,124.62 26.09,128.29 29.18,131.38 35.8,131.38 40.04,135.62 40.04,137.22 41.7,138.89 41.7,139.17 44.2,141.67 45.86,141.67 47.73,143.54 47.73,145.44 50.03,147.74 50.03,150.95 53.87,154.79 54.66,154.79 56.69,156.82 65.5,156.82 69,160.31 69.99,160.31 73.74,164.07 73.74,165.13 74.49,165.87 78.37,165.87 79.09,165.15 81.64,165.15 82.34,164.45 87.08,164.45 88.22,163.31 93.51,163.31 98.35,168.16 102.65,168.16 103.29,168.79 105.8,168.79 106.63,169.63 112.87,169.63 116.11,166.39 117.39,166.39 117.82,166.83 121.52,166.83 125.28,163.07 126.74,163.07 v1(127.07,163.4)
  BOTTOM w0.102: v1(26.58,91.55) 26.53,91.55 26.02,91.04 26.02,90.61 25,89.6 25,88.55 24.42,87.97 22.73,87.97 22.43,88.28 20.15,88.28 RH80.2 ; v1(219.77,75.09) 219.67,75.19 U46.A5
SIO_SLP_S3#: length 467.1
  TOP w0.102: v1(27.72,89.29) 27.85,89.42 27.85,89.78 ; JAPS1.2 82.98,26.6 v1(84.4,25.18) ; JIO1.85 8.73,85.8 9.03,86.09 9.03,89.27 v1(9.69,89.93)
  IN1 w0.109: v1(84.4,25.18) 84.4,25.39 84.81,25.8 88.82,25.8 89.16,25.45 103.7,25.45 107.25,21.9 131.63,21.9 132.22,21.31 195.3,21.31 196.1,22.12 222.45,22.12 236.68,36.34 250.36,36.34 251.54,37.52 256.89,37.52 259.03,39.66 261.3,39.66 262.21,38.75 262.21,37.96 v1(262.31,37.86) 262.53,37.86 271.47,46.79 271.47,69.83 261.11,80.18 253.68,80.18 251.32,77.83 246.78,77.83 244.19,75.25 227.92,75.25 224.34,78.83 221.83,78.83 v1(221.83,78.83)
  IN3 w0.127: v1(9.69,89.93) 9.89,89.72 11.87,89.72 13.42,91.27 14.99,91.27 15.47,90.79 17.48,90.79 17.86,90.41 18.42,90.41 20.38,88.45 22.82,88.45 23.23,88.86 24.82,88.86 25.64,89.67 27.34,89.67 v1(27.72,89.29)
  IN4 w0.109: v1(9.69,89.93) 10.16,89.45 12.02,89.45 14.33,87.14 14.95,87.14 17.51,84.58 18.07,84.58 19.77,82.88 24.09,82.88 24.31,82.66 25.97,82.66 26.68,81.96 33.36,81.96 34.32,80.99 34.32,77.93 34.01,77.61 34.01,67.56 36.57,64.99 36.57,55.55 38.96,53.16 38.96,51.77 36.25,49.06 36.25,39.46 38.7,37.01 38.7,31.25 39.19,30.76 39.19,28.11 42.8,24.5 42.8,17.31 50.7,9.41 72.04,9.41 72.75,10.12 72.75,10.61 77.16,15.01 77.71,15.01 83.36,20.65 83.36,24.85 83.69,25.18 v1(84.4,25.18)
  BOTTOM w0.102: v1(262.31,37.86) 262.04,37.58 PR403.1 ; v1(221.83,78.83) 221.88,78.77 U46.B65
SIO_SLP_S4#: length 504.8
  TOP w0.102: JAPS1.5 84.48,28.35 84.78,28.05 84.78,27.7 85.52,26.96 v1(85.52,25.1) ; UH1.C6 24.97,92.15 24.75,91.93 24.37,91.93 22.97,90.53 22.97,88.35 22.64,88.02 20.36,88.02 20.02,88.36 20.02,89.2 T118.1 19.3,89.93 16.34,89.93 15.58,89.16 15.58,88.44 v1(15.28,88.14)
  IN1 w0.109: v1(49.41,14.84) 49.23,14.67 49.23,12.36 50.22,11.36 50.63,11.36 53.25,8.75 72.71,8.75 73.64,9.68 73.64,11.5 77.03,14.89 77.03,17.41 82.05,22.44 82.22,22.44 83.3,23.51 83.3,23.92 84.14,24.77 85.19,24.77 v1(85.52,25.1) 85.98,25.55 88.72,25.55 89.06,25.22 103.6,25.22 107.15,21.66 131.53,21.66 132.12,21.07 195.39,21.07 196.2,21.88 222.55,21.88 236.78,36.11 250.46,36.11 251.64,37.29 256.98,37.29 257.81,38.11 260.74,38.11 261.48,37.37 262.41,37.37 271.7,46.66 271.7,69.93 261.21,80.42 253.58,80.42 251.23,78.06 246.68,78.06 244.23,75.61 238.28,75.61 236.98,76.91 227.15,76.91 224.73,79.33 v1(224.73,79.52)
  IN3 w0.127: v1(178.62,84.26) 178.62,84.24 178.9,84.52 183.42,84.52 187.74,80.2 202.58,80.2 205.68,77.1 208.16,77.1 209.18,76.08 210.65,76.08 210.83,75.91 217.2,75.91 219.29,73.82 221.14,73.82 224.73,77.41 v1(224.73,79.52)
  IN4 w0.109: v1(49.41,14.84) 49.02,14.84 43.53,20.34 43.53,24.93 39.92,28.53 39.92,31.04 39.41,31.55 39.41,37.31 36.96,39.75 36.96,48.76 39.69,51.49 39.69,53.44 37.3,55.83 37.3,65.29 34.73,67.86 34.73,77.32 35.42,78 35.42,80.57 33.56,82.43 26.88,82.43 26.17,83.13 24.5,83.13 24.24,83.4 24.24,83.62 23.57,84.29 19.07,84.29 18.31,85.05 17.71,85.05 15.26,87.51 15.26,88.11 v1(15.28,88.14)
  BOTTOM w0.102: U46.A61 224.23,79.02 v1(224.73,79.52) ; v1(178.62,84.26) 178.47,84.26 176.95,82.74 PR206.1
SIO_SLP_S5#: length 271.6
  TOP w0.102: v1(32.24,92.64) 32.24,92.64 32.28,92.6 32.37,92.6 UH1.Y7 ; v1(84.37,27.65) 83.98,28.04 JAPS1.4
  IN1 w0.109: v1(107.25,149.49) 107.25,149.46 105.48,147.7 105.48,145.23 104.68,144.43 104.68,143.17 104.24,142.73 104.24,137.4 105.17,136.48 105.17,135.62 107.32,133.47 107.32,130.36 108.19,129.5 108.19,127 104.77,123.58 104.77,119.63 107.2,117.2 107.2,112.58 108.38,111.39 108.38,108.99 106.05,106.67 v1(105.55,106.67)
  IN2 w0.127: v1(32.24,92.64) 32.67,92.2 32.67,91.68 32.9,91.45 36.23,91.45 36.89,90.79 37.83,90.79 38.64,89.98 40.45,89.98 40.58,89.84 42.68,89.84 43.6,90.76 43.6,92.33 45.61,94.35 51.04,94.35 52.23,95.54 56.42,95.54 57.76,96.89 64.52,96.89 66.65,99.01 67.89,99.01 73.86,104.99 80.35,104.99 81.05,105.69 84.13,105.69 85.11,106.67 v1(105.55,106.67)
  IN4 w0.109: v1(34.76,79.94) 34.76,78.01 34.26,77.52 34.26,67.64 36.81,65.09 36.81,55.65 39.2,53.26 39.2,51.67 36.49,48.96 36.49,39.56 38.94,37.11 38.94,31.35 39.43,30.86 39.43,28.21 43.04,24.6 43.04,17.43 48.43,12.04 71.5,12.04 74.6,15.13 75.25,15.13 76.4,16.28 76.4,17.44 78.85,19.89 78.85,22.37 84.12,27.65 v1(84.37,27.65)
  BOTTOM w0.076: v1(32.24,92.64) 31.87,92.26 31.87,91.66
  BOTTOM w0.102: v1(34.76,79.94) 34.76,80.58 34.25,81.09 34.25,84.4 34.37,84.52 34.37,86.23 32.38,88.22 T146.1 32.38,90.4 31.76,91.02 31.76,91.55 31.87,91.66 ; U51.A18 107,150.71 107.25,150.45 v1(107.25,149.49)
SIO_SLP_SUS#: length 236.8
  TOP w0.102: v1(26.59,88.69) 26.98,89.09 26.98,89.65 UH1.F1
  IN2 w0.127: v1(26.59,88.69) 27.23,88.05 28.23,88.05 29.25,87.03 30.24,87.03 30.91,87.7 35.31,87.7 35.92,87.09 37.49,87.09 38.16,86.42 39.88,86.42 40,86.54 45.11,86.54 46.57,87.99 46.57,88.17 49.17,90.76 55.05,90.76 55.74,91.45 64.19,91.45 64.92,90.71 66.74,90.71 70.34,94.32 70.34,95.03 71.2,95.9 71.2,96.27 73.74,98.81 73.74,99.22 74.79,100.26 79.69,100.26 81.53,102.11 91.83,102.11 91.98,101.95 107.16,101.95 108.05,102.84 120.84,102.84 122.3,101.38 127.2,101.38 129.49,103.67 129.89,103.67 131.39,105.17 141.39,105.17 143.02,103.54 182.94,103.54 189.22,97.27 191.93,97.27 192.61,96.59 195.09,96.59 196.03,95.65 199.09,95.65 201.86,92.88 201.86,84.63 205.24,81.25 205.24,73.81 208.28,70.76 215.75,70.76 216.98,71.99 216.98,72.87 218.47,74.37 218.47,77.56 v1(218.92,78)
  BOTTOM w0.102: T145.1 26.58,88.68 v1(26.59,88.69) ; v1(218.92,78) 219.42,77.5 U46.B6
SIO_SLP_WLAN#: length 384.2
  TOP w0.102: R815.1 123.49,170.1 v1(122.25,168.86) ; UH1.D2 26.06,90.38 v1(26.55,90.38)
  IN1 w0.109: v1(66.79,158.8) 67.69,157.9 74.11,157.9 77.24,154.77 v1(77.24,147.95)
  IN2 w0.127: v1(26.55,90.38) 26.25,90.08 24.82,90.08 22.57,92.33 20.42,92.33 18.83,93.92 18.83,94.7 18.59,94.94 18.08,94.94 17.68,95.34 17.68,96.97 17.18,97.48 17.18,100.64 15.91,101.91 15.91,106.23 16.71,107.03 16.71,109.24 19.42,111.95 19.42,114.3 20.01,114.89 20.01,115.18 22.36,117.52 22.74,117.52 24.81,119.59 24.81,123.7 25.84,124.72 25.84,128.4 29.08,131.63 35.32,131.63 38.6,134.92 38.6,136.02 39.52,136.94 39.52,137.06 41.45,138.99 41.45,139.27 44.1,141.92 45.75,141.92 47.48,143.65 47.48,145.54 49.78,147.85 49.78,151.06 53.76,155.04 54.56,155.04 56.59,157.07 65.4,157.07 66.79,158.46 v1(66.79,158.8) 68.65,160.67 69.83,160.67 73.49,164.32 73.49,165.23 74.38,166.13 78.47,166.13 79.2,165.4 81.75,165.4 82.44,164.7 87.19,164.7 88.32,163.57 93.4,163.57 98.33,168.49 102.62,168.49 103.18,169.05 105.69,169.05 106.53,169.89 112.98,169.89 116.21,166.65 117.29,166.65 117.72,167.08 120.47,167.08 v1(122.25,168.86)
  IN3 w0.127: v1(77.24,147.95) 77.52,147.67 86.28,147.67 89.98,143.98 89.98,138.86 98.46,130.37 98.46,128.08 103.26,123.28 103.26,121.09 106.56,117.79 108.87,117.79 112.33,114.34 124.01,114.34 124.58,114.91 129.93,114.91 130.5,114.34 144.65,114.34 150.28,108.71 159.63,108.71 173.63,94.71 178.15,94.71 179.74,93.13 192.24,93.13 199.37,85.99 v1(204.48,85.99)
  BOTTOM w0.102: v1(204.48,85.99) 204.91,85.56 204.91,80.88 205.42,80.37 205.42,79.42 204.86,78.86 204.86,73.98 207.74,71.09 v2(208.89,71.09) 210.22,71.09 210.46,70.85 211.9,70.85 213.57,72.53 213.57,73.06 215.17,74.66 U46.A14
SL_BAT_PRES#: length 5.2
  BOTTOM w0.102: v2(150.05,127.67) 150.33,127.39 150.33,126.25 PR1023.1
  BOTTOM w0.254: PR1023.1 149.77,125.07 150.7,124.13 PU1001.21
SLICE_BAT_ON: length 130.9
  TOP w0.102: v1(211.14,84.13) 211.14,89.09 210.3,89.93 210.3,91.7 209.81,92.19 v1(209.41,92.19)
  IN2 w0.127: v1(151.98,149.46) 151.6,149.08 151.6,143.76 158.47,136.88 v1(158.47,131.25)
  IN3 w0.127: v1(158.47,131.25) 160.42,129.3 163.99,129.3 166,127.29 166,122.72 167.06,121.66 168.87,121.66 173.33,117.21 173.33,107.65 181.24,99.73 196.91,99.73 203.01,93.64 207.96,93.64 v1(209.41,92.19)
  BOTTOM w0.102: v1(209.41,92.19) 209.77,92.56 212.91,92.56 v2(212.94,92.59) 213.28,92.92 216.21,92.92 216.57,92.57 216.57,90.89 217,90.46 217.36,90.46 217.59,90.69 RP8.3 ; PQ1082.2 151.56,148.21 152.05,148.7 152.58,148.7 PU1080.2 152.56,148.88 v1(151.98,149.46) ; R761.1 208.16,83.63 209.48,83.63 209.83,83.98 210.99,83.98 v1(211.14,84.13) 211.53,84.52 U46.A31 ; v1(158.47,131.25) 155.8,128.59 155.8,127.56 PR1016.2
SLICE_BAT_PRES#: length 382.7
  TOP w0.102: v1(214,85.2) 214.08,85.2 214.69,84.59 214.87,84.59 215.53,83.93 215.93,83.93 220.58,79.28 221.95,79.28 225,76.24 225,75.3 227.92,72.38 236.33,72.38 236.56,72.6 241.59,72.6 243.52,70.67 243.52,65.82 244.65,64.68 247.19,64.68 247.44,64.93 254.16,64.93 256.02,63.08 v1(257.67,63.08)
  TOP w0.254: v1(110.42,119.62) 109.66,118.86 R784.1
  IN2 w0.254: v1(146.95,134.96) 147.1,134.81 v1(147.1,127.21) 146.49,127.21 145.5,126.22 145.5,118.2 142.22,114.92 131.88,114.92 127.91,118.9 118.11,118.9 116.32,117.1 111.49,117.1 110.47,118.12 110.47,119.57 v1(110.42,119.62)
  IN3 w0.127: v1(147.1,127.21) 146.41,127.21 146.03,126.83 146.03,124.93 148.27,122.69 148.27,117.72 151.15,114.84 152.86,114.84 155.83,111.87 v1(156.45,111.87) 156.73,111.87 158.54,110.06 159.73,110.06 170.05,99.73 174.31,99.73 180.16,93.89 192.64,93.89 199.55,86.98 210.98,86.98 212.78,85.18 213.98,85.18 v1(214,85.2) ; v1(257.67,63.08) 259.72,63.08 260.23,63.59 268.18,63.59 269.76,62.01 269.76,46.22 264.29,40.75 252.25,40.75 248.17,36.66 237.87,36.66 228.33,27.13 199.46,27.13 196.05,23.71 189.9,23.71 186.6,27.01 186.6,27.93 v1(186.01,28.51)
  BOTTOM w0.102: v1(214,85.2) 213.58,84.77 U46.B33 ; v1(186.01,28.51) 185.66,28.15 184.43,28.15 183.06,26.78 178.32,26.78 177.33,27.78 177.33,28.99 176.95,29.37 PR33.1 ; v1(147.1,127.21) 147.71,127.82 148.75,127.82 149.77,126.81 PR1023.2
  BOTTOM w0.254: v1(156.45,111.87) 156.45,111.88 161.85,106.48 PD1100.1 ; v1(146.95,134.96) 150.75,134.96 156.07,140.27 v2(156.07,145.17) 154.67,146.57 153.04,146.57 152.75,146.86 PU1080.1 ; JDOCK1.141 110.2,119.4 v1(110.42,119.62) 110.7,119.34 JDOCK1.143
SLICE_BST_CHG_EN: length 73.7
  TOP w0.102: v1(214.84,77.99) 214.99,77.99 215.5,78.5 215.93,78.5 216.09,78.65 217.2,78.65 217.44,78.41 218.13,78.41 218.45,78.09 218.45,75.26 220.55,73.16 221.39,73.16 222.3,72.25 225.88,72.25 226.6,71.54 230.39,71.54 v1(230.69,71.84)
  IN4 w0.109: v1(214.84,77.99) 214.87,77.99 215.3,78.42 215.3,79.72 214.71,80.3 213.72,80.3 212.56,81.47 210.75,81.47 207.63,84.59 206.82,84.59 205.9,85.51 v1(205.9,85.53)
  IN4 w0.254: v1(230.69,71.84) 230.67,71.82 230.67,68.74 228.51,66.58 227.62,66.58 222.33,61.3 216.75,61.3 213.19,57.74 213.19,54.93 215.86,52.26 v1(216.14,52.26)
  BOTTOM w0.102: v1(205.9,85.53) 205.9,84.47 v2(206.17,84.2) 206.77,83.6 R761.2 ; U46.B16 214.42,77.57 v1(214.84,77.99)
  BOTTOM w0.254: v1(216.14,52.26) 216.37,52.03 PR1098.1 PR1033.2 ; v1(230.69,71.84) 231.17,71.36 PQ1071.5
SLP_ME_CSW_DEV#: length 228.7
  TOP w0.102: v1(34.71,93.67) 34.66,93.67 34.25,94.09 UH1.AD11
  IN2 w0.127: v1(34.71,93.67) 35.05,93.67 35.39,94.02 35.39,94.63 35.62,94.85 36.08,94.85 36.23,94.7 36.23,93 37.14,92.09 37.14,91.86 38.72,90.28 40.65,90.28 40.84,90.09 42.57,90.09 43.32,90.84 43.32,92.41 45.51,94.6 50.93,94.6 52.12,95.79 56.31,95.79 57.66,97.14 64.29,97.14 67.39,100.24 68.54,100.24 71.87,103.57 71.87,104.81 73.59,106.54 76.26,106.54 77.3,105.5 80.14,105.5 80.84,106.2 83.66,106.2 84.82,107.35 115.38,107.35 116.99,105.74 119.6,105.74 119.82,105.95 119.82,106.77 120.46,107.41 126.07,107.41 126.79,106.69 156.6,106.69 158.23,108.32 175.58,108.32 177.65,106.25 182.04,106.25 188.43,99.86 195.38,99.86 198,97.24 199.82,97.24 204.92,92.14 206.58,92.14 212.81,85.91 219.26,85.91 219.59,85.58 219.59,83.48 220.35,82.71 220.76,82.71 220.8,82.75 v1(220.99,82.75)
  BOTTOM w0.102: v1(220.99,82.75) 221.46,82.27 U46.B58 ; RH222.1 RH223.1 36.86,85.27 v2(36.01,86.12) 33.26,88.87 33.26,91.16 33.82,91.72 33.82,92.86 34.63,93.67 v1(34.71,93.67)
SM_RCOMP0: length 9.8
  TOP w0.254: JCPU1.AP3 104.65,73.28 v1(105.12,73.75)
  BOTTOM w0.33: v1(105.12,73.75) 104.62,74.25 104.62,76.2
  BOTTOM w0.508: RC42.1 107.63,80.86 v2(106.6,79.83) 104.62,77.85 104.62,76.2
SM_RCOMP1: length 8.6
  TOP w0.305: v1(105.12,74.75) JCPU1.AR3
  BOTTOM w0.457: v1(105.12,74.75) v2(107.8,77.42) 108.06,77.69 108.06,79.61 109.3,80.86 RC55.1
SM_RCOMP2: length 8
  TOP w0.305: JCPU1.AP2 v1(106.12,73.75)
  BOTTOM w0.254: 107.81,74.28 107.93,74.41 ; 107.81,74.28 107.81,73.77 107.3,73.26 106.61,73.26 v1(106.12,73.75) 106.12,73.97 106.43,74.28 107.81,74.28
  BOTTOM w0.508: 107.93,74.41 v2(108.7,74.41) RC49.1
SML1_SMBCLK: length 158.7
  TOP w0.102: UH1.K6 28.43,91.72 v1(28.2,91.95)
  IN1 w0.109: v1(28.2,91.95) 28.43,91.72 28.43,91.4 26.94,89.91 25.64,89.91 25.21,89.47 25.21,88.61 23.99,87.39 23.8,87.39 v1(23.63,87.56) ; v1(107.1,158.51) 107.27,158.33 107.27,158.26 107.07,158.06 106.46,158.06 104.52,156.11 102.61,156.11 101.1,154.6 101.1,153.66 100.87,153.43 99.75,153.43 98.55,152.23 98.55,148.57 97.04,147.05 97.04,139.13 97.44,138.73 97.44,137.4 97.04,137 97.04,131.1 97.47,130.66 97.47,128.03 96.52,127.08 96.52,123.81 96.17,123.45 96.17,117.98 96.88,117.26 96.88,116.74 v1(96.71,116.57)
  IN3 w0.127: v1(23.63,87.56) 23.82,87.37 24.07,87.37 24.72,86.73 25.07,86.73 26.01,87.67 28.1,87.67 30.38,89.95 31.31,89.95 32.25,89.01 34.28,89.01 35.98,87.31 37.37,87.31 37.58,87.51 40.88,87.51 42.71,85.68 45.42,85.68 46.69,86.95 49.38,86.95 49.87,87.44 52.51,87.44 54.29,89.22 54.29,90.64 55.88,92.24 56.55,92.24 56.98,92.67 63.89,92.67 64.35,93.13 67.37,93.13 69.15,94.91 69.15,95.68 70.96,97.5 71.91,97.5 72.57,98.15 72.57,98.83 75.11,101.37 78.23,101.37 79.84,102.98 81.88,102.98 85.13,106.24 85.13,110.56 86.04,111.47 86.04,114.8 87.48,116.24 91.58,116.24 91.86,115.96 96.73,115.96 96.94,116.17 96.94,116.34 v1(96.71,116.57)
  BOTTOM w0.102: v1(107.1,158.51) 107.58,158.02 U51.B6 ; v1(23.63,87.56) 23.45,87.39 23.22,87.39 22.92,87.08 22.92,86.8 22.65,86.52 21.93,86.52 21.8,86.65 RPH5.3
