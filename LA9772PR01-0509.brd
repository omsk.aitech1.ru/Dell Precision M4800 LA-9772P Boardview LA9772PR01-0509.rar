# Allegro board LA9772PR01-0509.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_ALW on TOP (solid shape): 68.23,163.43 68.23,157.9 67.98,157.64 65.06,157.64 64.8,157.9 64.8,158.83 66.43,158.83 66.43,158.77 66.44,158.72 66.45,158.67 66.48,158.62 66.51,158.58 66.54,158.54 66.58,158.5 66.63,158.48 66.68,158.46 66.73,158.45 66.79,158.44 66.84,158.45 66.89,158.46 66.94,158.48 66.99,158.5 67.03,158.54 67.06,158.58 67.09,158.62 67.12,158.67 67.13,158.72 67.14,158.77 67.14,158.83 67.13,158.88 67.12,158.93 67.09,158.98 67.06,159.02 67.03,159.06 66.99,159.09 66.94,159.12 66.89,159.14 66.84,159.15 66.79,159.16 66.73,159.15 66.68,159.14 66.63,159.12 66.58,159.09 66.54,159.06 66.51,159.02 66.48,158.98 66.45,158.93 66.44,158.88 66.43,158.83 64.8,158.83 64.8,162.09 65.06,162.34 67.09,162.34 67.41,162.66 67.41,163.37 67.52,163.49 68.18,163.49
+5V_ALW on TOP (solid shape): 4.73,84.64 4.73,83.9 5.03,83.6 6.38,83.6 7,84.22 7.85,84.22 7.91,84.22 7.97,84.24 8.67,84.24 8.92,83.98 8.92,78.65 8.67,78.4 5.24,78.4 5.03,78.61 5.03,78.63 4.93,78.95 4.62,79.05 4.59,79.05 4.48,79.16 4.48,79.79 4.76,80.07 4.78,80.06 5.24,80.34 4.91,80.76 4.87,80.77 4.86,80.81 4.86,82.46 4.61,82.71 4.1,82.71 3.84,82.97 3.84,83.48 4.23,83.86 4.23,84.66 4.34,84.77 4.6,84.77
+5V_ALW on TOP (solid shape): 123.48,27.34 123.48,23.91 123.73,23.66 131.48,23.66 134.78,20.36 134.78,15.78 134.57,15.57 131.82,15.57 131.61,15.78 131.61,19.05 130.17,20.48 120.56,20.48 120.3,20.74 120.3,24.55 120.05,24.8 102.81,24.8 102.63,24.81 102.45,24.8 102.32,24.8 102.32,24.81 102.21,24.81 101.89,24.8 101.86,24.77 101.84,24.77 99.61,23.64 98.48,21.41 98.48,21.39 98.46,21.37 98.43,20.8 98.46,20.1 98.21,19.85 96.82,19.85 96.7,19.98 96.7,21.39 95.28,22.8 95.28,25.69 96.6,27.01 96.63,27 98.79,26.83 100.82,27.6 123.22,27.6
+5V_ALW on BOTTOM (solid shape): 120.2,107.91 120.2,106.61 119.41,105.83 117.89,105.83 117.64,106.08 117.64,107.73 117.89,107.99 120.12,107.99
+5V_ALW on BOTTOM (solid shape): 181.44,78.27 182.91,78.27 183.17,78.01 183.17,77.51 182.93,77.26 180.76,77.26 180.37,77.65 180.37,78.27 180.58,78.47 181.24,78.47
+5V_ALW on BOTTOM (solid shape): 220.25,58.58 220.25,57.82 220.13,57.69 218.09,57.69 217.38,56.98 216.77,56.98 216.7,57.06 216.7,57.57 216.57,57.69 215.81,57.69 215.55,57.95 215.55,58.46 215.81,58.71 220.13,58.71
+5V_ALW on BOTTOM (solid shape): 230.62,42.38 230.62,41.87 230.64,41.84 231.35,41.84 231.38,41.87 231.38,42.38 231.4,42.4 231.81,42.4 231.83,42.38 231.83,41.87 231.86,41.84 232.57,41.84 232.6,41.87 232.6,42.38 232.62,42.4 236.28,42.4 236.28,41.84 237.04,41.84 237.04,42.4 237.5,42.4 237.5,41.84 238.24,41.84 238.24,42.4 239.86,42.4 240.06,42.2 240.06,40.3 239.81,40.04 229.78,40.04 229.52,40.3 229.52,42.35 229.57,42.4 230.59,42.4
+5V_ALW on BOTTOM (solid shape): 257.46,99.22 257.46,98.33 257.84,97.95 257.84,93.76 257.59,93.51 255.81,93.51 255.56,93.76 255.56,94.91 255.05,95.41 255.05,96.83 255.34,97.12 255.84,97.12 256.06,97.35 256.43,97.35 256.51,97.42 256.52,97.43 256.69,97.67 256.55,97.93 256.5,98 256.53,98.09 256.57,98.13 256.57,98.29 256.58,98.3 256.58,98.53 256.59,98.57 256.59,98.61 256.59,99.12 256.83,99.35 257.34,99.35
+5V_ALW on BOTTOM (solid shape): outline of 102 points within 49.18,68.49 53.89,75.09
+5V_ALW on IN2 (solid shape): 265.08,25.18 265.08,22.52 264.83,22.26 256.07,22.26 255.81,22.52 255.81,25.18 256.07,25.44 264.83,25.44
+5V_ALW on IN2 (solid shape): 260.57,97.52 260.54,97.46 260.52,97.41 260.51,97.35 260.51,97.3 260.52,97.24 260.53,97.19 260.56,97.14 260.59,97.09 260.62,97.05 260.66,97.01 260.71,96.98 260.76,96.96 260.82,96.94 260.87,96.94 260.93,96.94 260.98,96.95 261.03,96.96 261.09,96.99 264.58,93.51 264.58,90.14 263.56,89.13 261.97,89.13 261.27,89.83 260,89.83 255.43,94.4 255.43,95.67 260,95.67 260.01,95.61 260.02,95.56 260.04,95.5 260.07,95.46 260.1,95.41 260.14,95.37 260.19,95.34 260.23,95.32 260.29,95.3 260.34,95.29 260.4,95.29 260.45,95.29 260.51,95.31 260.56,95.33 260.61,95.36 260.65,95.39 260.69,95.43 260.72,95.48 260.74,95.53 260.76,95.58 260.77,95.64 260.77,95.69 260.76,95.75 260.74,95.8 260.72,95.85 260.69,95.9 260.65,95.94 260.61,95.98 260.56,96.01 260.51,96.03 260.45,96.04 260.4,96.05 260.34,96.05 260.29,96.04 260.23,96.02 260.19,95.99 260.14,95.96 260.1,95.92 260.07,95.88 260.04,95.83 260.02,95.78 260.01,95.72 260,95.67 255.43,95.67 255.43,96.15 257.32,98.04 257.32,98.07 257.59,98.33 259.75,98.33
+5V_ALW on IN4 (solid shape): 108.62,24.29 135.16,24.29 135.42,24.04 135.42,15.78 135.21,15.57 131.82,15.57 131.61,15.78 131.61,18.96 131.6,18.97 131.6,19.14 130.26,20.48 106.59,20.48 103.67,23.4 100.62,23.4 99.22,22.01 99.22,21.37 97.89,20.04 97.89,20.04 97.67,19.81 96.85,19.81 96.69,19.97 96.69,21.77 95.47,22.99 95.47,24.23 98.46,27.21 105.7,27.21
+5V_ALW on VCC: outline of 1842 points within 1.02,9.56 274.53,163.99
+5V_ALW2 on BOTTOM (solid shape): 246.71,58.29 246.71,57.03 246.71,57.03 246.71,56.81 246.25,56.35 246.25,55.87 246.21,55.83 245.36,55.83 245.32,55.87 245.32,56.5 245.5,56.68 246.13,56.68 246.19,56.73 246.2,56.73 246.29,56.79 246.36,56.87 246.4,56.92 246.45,57 246.46,57.05 246.48,57.08 246.48,58.02 246.48,58.08 246.45,58.16 246.45,58.27 246.53,58.35 246.65,58.35
+5V_ESATA_PWR on TOP (solid shape): 67.44,167.58 67.41,167.54 67.37,167.3 67.53,167.11 67.54,167.11 67.61,167.04 67.98,167.04 68.23,166.79 68.23,165.64 68.11,165.52 67.53,165.52 67.41,165.64 67.41,166.34 67.21,166.53 66.2,166.53 65.95,166.28 65.95,165.39 65.69,165.14 64.3,165.14 64.04,165.39 64.04,167.68 64.3,167.93 67.09,167.93
+5V_ESATA_PWR on BOTTOM (solid shape): outline of 130 points within 62.52,159.37 66.96,167.93
+5V_ESATA_PWR on IN3 (solid shape): outline of 796 points within 42.71,155.74 67.85,172.5
+5V_HDD on TOP (solid shape): 172.88,71.41 172.88,68.49 172.63,68.24 169.33,68.24 168.95,68.62 168.95,71.21 169.4,71.66 172.63,71.66
+5V_HDD on BOTTOM (solid shape): 170.65,71.77 170.65,71.18 171.1,71.18 171.1,70.9 170.65,70.9 170.65,70.39 171.1,70.39 171.1,70.11 170.65,70.11 170.65,68.67 170.34,68.36 168.69,68.36 168.44,68.62 168.44,70.39 168.18,70.65 167.55,70.65 167.29,70.9 167.29,71.54 167.55,71.79 170.62,71.79
+5V_MOD on TOP (solid shape): 42.88,36.05 42.88,34.91 43.6,34.2 43.6,32.93 43.47,32.8 42.91,32.8 42.83,32.8 42.58,33.06 42.58,33.31 42.07,33.82 41.06,33.82 40.67,34.2 38.64,34.2 38.41,34.43 35.3,34.43 35.12,34.61 35.12,35.96 35.39,36.23 38.13,36.23 38.39,36.49 42.45,36.49
+5V_MXM on TOP (solid shape): 124.37,107.61 124.37,104.3 124.24,104.18 122.21,104.18 122.08,104.3 122.08,106.34 121.83,106.59 121.83,107.86 121.95,107.99 123.99,107.99
+5V_MXM on BOTTOM (solid shape): outline of 209 points within 122.03,105.14 127.73,108.53
+5V_MXM_U35 on BOTTOM (solid shape): 127.72,111.02 127.74,110.99 127.74,108.19 127.66,108.1 127.28,108.1 127.28,108.65 126.72,108.65 126.72,108.1 126.48,108.1 126.48,108.65 125.92,108.65 125.92,108.11 125.92,108.1 125.49,108.1 124.67,107.29 121.6,107.29 121.47,107.42 121.47,107.91 121.57,108.01 124.4,108.01 124.45,108.06 124.47,108.06 124.47,108.08 125.41,109.02 125.41,110.86 125.7,111.15 127.59,111.15
+5V_RUN on TOP (solid shape): 184.06,113.57 184.06,113.32 183.8,113.07 176.06,113.07 175.8,113.32 175.8,113.57 176.06,113.83 183.8,113.83
+5V_RUN on TOP (solid shape): 93,156.63 93,155.1 92.74,154.85 91.73,154.85 91.22,155.36 91.22,156.5 91.6,156.88 92.74,156.88
+5V_RUN on TOP (solid shape): 174.66,143.29 174.66,141.62 174.66,140.75 174.28,140.37 172.42,140.37 172.11,140.68 172.11,142.34 172.33,142.56 172.33,143.54 172.46,143.67 174.28,143.67
+5V_RUN on TOP (solid shape): 6.04,72.81 8.67,72.81 8.92,72.55 8.92,71.41 8.67,71.16 6.26,71.16 6,70.9 4.35,70.9 3.59,71.66 3.59,72.43 3.84,72.68 4.48,72.68 4.7,72.9 5.94,72.9
+5V_RUN on TOP (solid shape): outline of 95 points within 11.56,127.16 16.29,134.28
+5V_RUN on BOTTOM (solid shape): 56.51,76.52 56.51,73.04 56.38,72.91 54.8,72.91 54.46,73.25 54.46,76.17 54.91,76.62 56.42,76.62
+5V_RUN on BOTTOM (solid shape): 174.02,73.19 174.02,71.79 173.9,71.66 173.77,71.66 172.25,70.14 172.25,68.36 172.12,68.24 170.87,68.24 170.77,68.34 170.77,68.61 170.77,68.61 170.77,69.99 171.23,69.99 171.31,69.99 171.31,70.52 171.23,70.52 170.77,70.52 170.77,70.77 171.23,70.77 171.31,70.78 171.31,71.31 170.77,71.31 170.77,71.82 170.77,71.82 170.77,72.98 171.1,73.32 173.9,73.32
+5V_RUN on BOTTOM (solid shape): 81.31,161.96 81.31,161.07 80.43,160.18 80.43,159.93 80.68,159.68 80.99,159.68 81.06,159.65 81.13,159.65 81.47,159.65 81.62,159.5 81.62,159.47 81.57,159.42 80.68,159.42 80.55,159.55 79.76,159.55 79.5,159.28 79.49,159.28 79.26,159.07 79.28,158.75 79.28,158.53 78.77,158.02 78.52,158.02 78.39,158.15 78.39,160.31 78.52,160.44 79.66,160.44 79.79,160.56 79.79,161.83 80.02,162.06 81.21,162.06
+5V_RUN on BOTTOM (solid shape): 175.44,145.45 175.44,145.07 175.18,144.82 174.04,144.82 173.71,144.49 173.71,141.03 173.71,140.48 173.47,140.24 172.98,140.24 171.28,140.24 171.11,140.41 171.11,143.61 171.29,143.61 171.29,143.56 171.3,143.5 171.32,143.45 171.34,143.41 171.37,143.36 171.41,143.32 171.45,143.29 171.49,143.26 171.54,143.24 171.6,143.23 171.65,143.23 171.7,143.23 171.75,143.24 171.8,143.26 171.85,143.29 171.89,143.32 171.93,143.36 171.96,143.41 171.98,143.45 172,143.5 172,143.56 172,143.61 172,143.66 171.98,143.71 171.96,143.76 171.93,143.81 171.89,143.85 171.85,143.88 171.8,143.91 171.75,143.92 171.7,143.94 171.65,143.94 171.6,143.94 171.54,143.92 171.49,143.91 171.45,143.88 171.41,143.85 171.37,143.81 171.34,143.76 171.32,143.71 171.3,143.66 171.29,143.61 171.11,143.61 171.11,145.36 171.46,145.71 175.18,145.71
+5V_RUN on BOTTOM (solid shape): 10.36,154.84 10.39,154.76 10.34,154.68 10.18,154.53 10.12,154.32 10.12,154.27 10.28,153.94 10.64,153.88 10.67,153.89 10.91,153.66 10.91,152.9 10.85,152.83 10.81,152.74 10.81,152.73 10.7,152.63 9.29,152.63 8.83,153.09 8.8,153.18 8.85,153.25 9.02,153.4 9.08,153.62 9.08,153.67 8.98,153.94 8.73,154.07 8.68,154.08 8.68,154.62 9.05,154.99 10.22,154.99
+5V_RUN on BOTTOM (solid shape): outline of 95 points within 81.57,157.39 96.43,173.65
+5V_RUN on BOTTOM (solid shape): outline of 247 points within 24.42,163.23 37.5,166.28
+5V_RUN on BOTTOM (solid shape): outline of 291 points within 173.26,89.06 184.06,123.1
+5V_RUN on BOTTOM (solid shape): outline of 351 points within 3.97,93.64 16.66,132.62
+5V_RUN on VCC (solid shape): outline of 1460 points within 91.96,137.85 179,174.58
+5V_RUN on VCC (solid shape): outline of 7259 points within 53.88,69.63 160.44,95.54
+5V_RUN on IN2 (solid shape): outline of 199 points within 156.63,88.05 175.93,93.64
+5V_RUN on IN2 (solid shape): outline of 388 points within 172.46,121.32 179.87,143.8
+5V_RUN on IN2 (solid shape): outline of 637 points within 7.15,154.34 96.55,174.28
+5V_RUN on IN2 (solid shape): outline of 739 points within 78.14,155.48 91.98,159.8
+5V_RUN on IN2 (solid shape): outline of 6048 points within 1.69,34.96 57.18,94.78
+5V_RUN on IN3 (solid shape): outline of 471 points within 7.27,127.16 15.66,155.23
+5V_RUN on IN4 (solid shape): outline of 206 points within 1.18,71.54 6.53,95.29
+5V_RUN on IN3: 172.5,71.16 172.25,71.41 172.25,73.82 170.34,75.73 170.34,76.74 169.83,77.25 167.69,77.25 167.39,77.4 167.1,77.25 161.71,77.25 161.16,77.8 161.17,77.82 161.07,78.14 160.75,78.24 160.72,78.23 159.05,79.9 159.05,82.06 158.66,82.45 158.66,89.95 158.29,90.31 158.29,90.33 158.22,90.51 158.1,90.67 157.13,91.65 156.96,91.65 156.63,91.98 156.63,93.51 156.88,93.76 159.55,93.76 163.36,89.95 163.36,83.19 163.31,83.18 163.03,82.69 163.58,82.55 163.62,82.58 164.25,81.95 169.07,81.95 175.04,75.98 175.04,71.41 174.79,71.16
+5V_RUN_U37 on BOTTOM (solid shape): 54.31,78.1 54.31,75.45 54.28,75.43 53.76,75.43 53.76,75.42 53.76,74.88 53.76,74.87 54.31,74.87 54.31,74.87 54.31,74.63 54.31,74.63 53.76,74.63 53.76,74.08 53.77,74.07 54.3,74.07 54.31,74.06 54.31,73.75 54.3,73.75 52.59,73.75 52.44,73.89 52.44,76.19 52.15,76.48 51.41,76.48 51.3,76.59 51.3,77.29 51.63,77.62 51.63,78.01 51.91,78.29 54.12,78.29
+5V_USB_PWR1 on TOP (solid shape): outline of 261 points within 255.69,102.65 270.04,110.65
+5V_USB_PWR1 on BOTTOM (solid shape): 257.02,104.35 257.02,102.59 256.96,102.53 256.96,101.51 256.89,101.45 256.76,101.45 256.7,101.51 256.7,102.27 256.19,102.78 255.94,102.78 255.81,102.91 255.81,104.34 255.92,104.44 256.93,104.44
+5V_USB_PWR1 on BOTTOM (solid shape): 261.27,118.27 261.27,117.51 261.19,117.37 261.17,117.2 261.17,117.17 261.13,117.15 260.79,116.76 261.06,116.32 261.06,116.05 261.27,115.83 261.27,114.64 261.06,114.42 256.8,114.42 255.7,115.53 255.7,118.1 256.13,118.53 261.02,118.53
+5V_USB_PWR1 on IN4 (solid shape): outline of 120 points within 255.09,102.78 265.2,115.86
+5V_USB_PWR2 on BOTTOM (solid shape): 259.57,103.63 259.57,102.79 259.25,102.46 257.78,102.46 257.53,102.21 257.53,101.57 257.4,101.45 257.21,101.45 257.15,101.51 257.15,103.8 257.46,104.11 259.09,104.11
+5V_USB_PWR2 on BOTTOM (solid shape): outline of 222 points within 257.72,128.69 265.91,136.31
+5V_USB_PWR2 on IN3 (solid shape): outline of 710 points within 257.08,102.72 266.21,133.43
+5VALWP on BOTTOM (solid shape): 235.49,57.44 235.49,44.99 235.75,44.74 239.56,44.74 239.81,44.49 239.81,42.71 239.66,42.56 238.08,42.56 238.08,42 237.65,42 237.65,42.56 236.89,42.56 236.89,42 236.46,42 236.46,42.53 236.43,42.56 232.44,42.56 232.42,42.53 232.42,42.05 232.39,42.02 232.01,42.02 231.99,42.05 231.99,42.53 231.96,42.56 231.25,42.56 231.22,42.53 231.22,42.07 231.17,42.02 230.82,42.02 230.79,42.05 230.79,42.53 230.77,42.56 229.6,42.56 229.52,42.63 229.52,57.44 229.78,57.69 235.24,57.69
+VCC_CORE on TOP (solid shape): outline of 2678 points within 49.95,44.99 91.6,69.89
+VCC_CORE on BOTTOM (solid shape): outline of 2035 points within 49.95,45.12 91.6,70.52
+VCC_CORE on IN1 (solid shape): 56.04,54.9 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN1 (solid shape): 52.61,67.47 54.9,67.47 55.79,66.58 55.79,65.38 55.75,65.37 55.51,65.01 55.75,64.65 55.79,64.64 55.79,62.18 55.75,62.17 55.51,61.81 55.75,61.45 55.79,61.44 55.79,59.33 55.75,59.32 55.51,58.96 55.75,58.61 55.79,58.59 55.79,58.33 55.53,58.08 55.15,58.08 53.5,59.73 52.36,59.73 51.47,58.84 50.07,58.84 49.82,59.09 49.82,67.73 50.07,67.98 52.1,67.98
+VCC_CORE on IN1 (solid shape): outline of 1304 points within 72.81,54.52 82.58,69.25
+VCC_CORE on VCC (solid shape): outline of 14280 points within 49.95,35.34 93.38,71.03
+VCC_CORE on IN2 (solid shape): 56.04,54.9 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN3 (solid shape): 56.04,54.9 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN3 (solid shape): 52.61,67.47 54.9,67.47 55.79,66.58 55.79,65.38 55.75,65.37 55.51,65.01 55.75,64.65 55.79,64.64 55.79,62.18 55.75,62.17 55.51,61.81 55.75,61.45 55.79,61.44 55.79,59.33 55.75,59.32 55.51,58.96 55.75,58.61 55.79,58.59 55.79,58.33 55.53,58.08 55.15,58.08 53.5,59.73 52.36,59.73 51.47,58.84 50.07,58.84 49.82,59.09 49.82,67.73 50.07,67.98 52.1,67.98
+VCC_CORE on IN4 (solid shape): 56.02,54.92 56.02,52.67 56.04,52.64 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN4 (solid shape): 52.61,67.47 54.9,67.47 55.79,66.58 55.79,65.38 55.75,65.37 55.51,65.01 55.75,64.65 55.79,64.64 55.79,62.18 55.75,62.17 55.51,61.81 55.75,61.45 55.79,61.44 55.79,59.33 55.75,59.32 55.51,58.96 55.75,58.61 55.79,58.59 55.79,58.33 55.53,58.08 55.15,58.08 53.5,59.73 52.36,59.73 51.47,58.84 50.07,58.84 49.82,59.09 49.82,67.73 50.07,67.98 52.1,67.98
+VCC_CORE on IN4 (solid shape): outline of 598 points within 71.98,59.22 79.28,69
+VCCST on BOTTOM (solid shape): 67.92,75.12 67.92,71.28 67.72,71.08 66.72,71.08 66.64,71.16 66.64,75.41 66.8,75.57 67.47,75.57
GND on TOP (solid shape): 20.86,130.85 20.86,127.8 20.74,127.67 16.93,127.67 16.67,127.93 16.67,130.85 16.93,131.1 20.61,131.1
GND on TOP (solid shape): 24.29,78.4 24.29,75.22 23.91,74.84 20.99,74.84 20.61,75.22 20.61,78.4 20.79,78.57 24.11,78.57
GND on TOP (solid shape): 70.14,161.96 70.14,158.15 69.88,157.9 68.74,157.9 68.49,158.15 68.49,161.96 68.74,162.22 69.88,162.22
GND on TOP (solid shape): 122.34,160.82 122.34,160.56 121.95,160.18 119.29,160.18 119.03,160.44 119.03,161.33 119.29,161.58 121.57,161.58
GND on TOP (solid shape): 132.37,139.74 132.37,137.45 132.11,137.2 124.49,137.2 124.24,137.45 124.24,139.74 124.49,139.99 132.11,139.99
GND on TOP (solid shape): 173.64,38.39 173.64,36.36 173.39,36.1 169.33,36.1 169.07,36.36 169.07,38.39 169.33,38.64 173.39,38.64
GND on TOP (solid shape): 47.88,36.2 47.88,35.05 47.75,34.92 46.24,34.92 46.23,34.92 45.87,34.92 45.64,35.15 45.64,36.31 45.83,36.5 47.59,36.5
GND on TOP (solid shape): 131.23,34.96 131.23,33.31 130.97,33.06 129.7,33.06 129.45,32.8 129.45,31.41 129.32,31.28 121.19,31.28 121.19,35.09 121.32,35.22 130.97,35.22
GND on TOP (solid shape): 166.62,73.25 166.62,69.68 166.4,69.47 164.55,69.47 164.19,69.83 164.19,73.07 164.53,73.42 166.45,73.42
GND on TOP (solid shape): 167.04,84.48 167.04,79.34 166.81,79.12 164.36,79.12 164.12,79.36 164.12,84.46 164.31,84.66 166.86,84.66
GND on TOP (solid shape): 24.04,71.41 24.04,66.33 24.04,66.33 24.04,65.23 23.92,65.11 20.56,65.11 20.35,65.32 20.35,71.41 20.61,71.66 23.78,71.66
GND on TOP (solid shape): 69.95,165.07 69.95,164.06 69.57,163.68 67.41,163.68 67.22,163.49 67.22,162.89 67.01,162.68 64.17,162.68 64.06,162.8 64.06,164.7 64.23,164.88 65.95,164.88 66.39,165.33 69.69,165.33
GND on TOP (solid shape): 125,153.45 125,148.88 124.75,148.63 122.72,148.63 122.59,148.5 119.8,148.5 119.67,148.63 119.67,149.64 120.05,150.02 120.05,152.06 119.67,152.44 119.67,153.58 119.8,153.71 124.75,153.71
GND on TOP (solid shape): 39.9,122.35 39.91,122.18 39.91,121.7 39.66,121.45 37.7,121.45 37.7,121.47 37.09,121.47 36.86,121.7 36.86,122.34 37.12,122.59 39.66,122.59
GND on TOP (solid shape): 47.3,137.92 47.3,136.34 49.46,134.18 49.89,134.18 50.03,134.04 50.03,133.1 49.9,132.97 46.55,132.97 46.12,133.4 46.12,135.24 46.11,135.25 46.11,135.27 45.65,135.73 45.65,137.93 45.76,138.03 47.18,138.03
GND on TOP (solid shape): 136.43,90.45 136.43,69.63 136.18,69.38 135.8,69.38 135.04,70.14 135.04,82.97 134.91,83.09 134.91,83.6 134.88,83.63 134.88,83.66 134.26,84.29 134.22,84.29 134.15,84.36 134.15,89.06 135.67,90.59 136.3,90.59
GND on TOP (solid shape): 22.64,146.59 22.64,145.96 22.89,145.71 24.44,145.71 24.55,145.6 24.55,144.94 24.44,144.84 19.11,144.84 18.93,145.02 18.93,145.5 19.13,145.7 19.85,145.71 20.15,146.01 20.15,146.62 20.2,146.67 22.56,146.67
GND on TOP (solid shape): 57.65,156.53 57.65,153.94 57.02,153.3 56.15,153.3 55.93,153.08 55.93,152.8 55.6,152.47 53.22,152.47 53.04,152.65 53.04,153.43 53.11,153.49 53.58,153.49 54,153.91 54,156.27 54.5,156.78 57.4,156.78
GND on TOP (solid shape): 142.27,104.18 146.34,104.18 146.59,103.92 146.59,101.13 146.97,100.75 153.2,100.75 153.45,100.49 153.45,95.92 153.2,95.67 151.55,95.67 148.12,99.1 140.62,99.1 140.37,99.35 140.37,103.54 139.99,103.92 138.72,103.92 138.59,104.05 138.59,104.94 138.72,105.07 141.39,105.07
GND on TOP (solid shape): 163.86,65.01 163.86,64.71 164.59,63.98 166.66,63.98 166.9,63.74 166.9,60.85 167,60.74 167.82,60.74 167.93,60.63 167.93,59.22 167.67,58.96 166.53,58.96 166.28,58.71 166.28,51.73 166.02,51.47 164.88,51.47 164.63,51.73 164.63,63.62 164.26,63.98 163.57,63.98 163.28,64.27 163.28,64.99 163.32,65.03 163.84,65.03
GND on TOP (solid shape): 166.53,44.36 166.53,42.74 166.49,42.73 166.19,42.38 166.49,42.03 166.53,42.02 166.53,41.18 166.28,40.93 164.37,40.93 164.12,41.18 164.12,44.23 164.5,44.61 166.28,44.61
GND on TOP (solid shape): 46.01,76.24 46.01,74.97 46.64,74.33 47.28,74.33 47.56,74.05 47.56,60.77 47.53,60.74 47.53,54.39 47.15,54.01 47.15,52.87 49.06,50.96 49.06,40.04 49.18,39.91 49.18,37.25 48.93,36.99 48.17,36.99 47.41,37.76 45.75,37.76 45.5,38.01 45.5,52.87 43.98,54.39 43.98,59.85 43.72,60.11 43.72,62.52 41.56,64.68 41.56,66.97 43.98,69.38 43.98,74.2 43.6,74.59 42.96,74.59 42.83,74.71 42.83,76.24 42.86,76.26 45.98,76.26
GND on TOP (solid shape): 50.13,158.43 50.13,157.22 49.19,156.28 48.64,156.28 48.15,155.79 48.15,155.69 48.09,155.63 48.09,154.47 47.02,153.39 45.73,153.39 45.59,153.54 45.59,154.53 45.95,154.89 45.95,155.62 46.1,155.77 46.1,156.11 46.19,156.19 46.24,156.25 46.28,156.33 46.59,156.64 46.6,156.64 46.84,156.94 46.68,157.29 46.68,158.39 46.85,158.56 50,158.56
GND on TOP (solid shape): 131.73,71.79 131.73,65.7 132.24,65.19 132.24,64.43 132.11,64.3 132.11,62.9 132.24,62.77 132.24,59.47 132.37,59.35 132.37,58.71 132.24,58.58 132.24,56.93 132.37,56.81 132.37,56.17 132.24,56.04 132.24,54.52 132.37,54.39 132.37,53.63 132.11,53.38 132.11,50.73 132.3,50.54 136.28,50.54 136.43,50.39 136.43,29.79 136.39,29.75 135.93,29.75 133.94,31.73 133.94,44.22 132.02,46.15 132.02,47.94 132.06,47.98 133.01,47.98 133.17,48.15 133.17,48.98 133.02,49.13 131.4,49.13 130.45,50.07 128.69,50.07 128.43,50.33 128.43,66.84 126.27,69 126.27,71.79 126.53,72.05 131.48,72.05
GND on TOP (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.34 158.4,168.62 158.38,168.58 158.34,168.57 155.99,168.57 155.74,168.82 155.74,170.72 151.62,174.84 95.33,174.84 94.78,174.28 93.13,174.28 89.82,170.98 85.76,170.98 85.51,171.23 85.51,174.28 85.52,174.3 84.91,174.3 84.88,174.3 84.86,174.32 84.74,174.49 84.59,174.62 84.56,174.74 84.65,174.81 91.41,174.81 91.76,174.93 91.95,175.26 92,175.35 156.74,175.35
GND on TOP (solid shape): 150.01,50.54 150.01,29.53 149.44,29.53 149.19,29.27 147.17,29.27 146.95,29.49 146.95,33.91 147.02,34.01 147.13,33.98 147.25,33.86 147.24,33.84 147.85,33.54 147.55,34.15 147.52,34.14 147.02,34.65 146.95,34.65 146.95,44.06 146.99,44.14 147.08,44.16 147.51,44.53 147.05,44.85 147.04,44.85 146.95,44.85 146.95,49.99 147.56,50.6 149.96,50.6
GND on TOP (solid shape): 150.01,90.34 150.01,69.06 149.92,68.96 147.09,68.96 146.93,69.12 146.93,69.97 148.11,71.15 148.11,71.55 147.91,72.2 147.72,71.55 147.72,71.31 147.11,70.7 147,70.68 146.93,70.78 146.93,74.79 147,74.88 147.11,74.86 147.59,74.38 147.59,74.35 148.19,74.05 147.89,74.66 147.87,74.66 147.07,75.45 146.93,75.45 146.93,90.41 147.02,90.5 149.85,90.5
GND on TOP (solid shape): 168.49,75.47 168.57,75.43 168.58,75.34 168.57,75.15 168.66,74.97 168.68,74.9 168.66,74.84 168.94,74.2 169.23,74.84 169.21,74.9 169.23,74.97 169.32,75.15 169.3,75.34 169.32,75.43 169.4,75.47 173.14,75.47 173.39,75.22 173.39,74.84 173.14,74.59 170.34,74.59 169.2,73.44 169.2,72.55 169.33,72.43 169.71,72.43 169.8,72.52 169.86,72.56 169.92,72.62 169.94,72.66 170.21,72.93 172.63,72.93 172.88,72.68 172.88,72.17 172.75,72.05 170.21,72.05 170.09,71.92 167.55,71.92 167.29,72.17 167.29,75.22 167.55,75.47
GND on TOP (solid shape): 48.29,90.21 48.29,89.88 48.3,89.45 48.68,89.24 48.88,89.24 48.96,89.32 49.03,89.32 49.04,89.31 49.47,89.29 49.7,89.65 49.71,89.7 49.82,89.7 50.04,89.47 50.04,89.44 50.02,89.34 50.03,89.24 50.02,89.15 49.94,89.11 49.44,89.11 49.17,88.85 49.16,88.85 48.95,88.68 48.92,88.41 48.92,88.4 48.92,88.34 48.87,88.34 48.65,88.13 48.59,88.03 48.57,87.92 48.56,87.87 47.58,87.87 47.48,87.97 47.48,88.43 47.41,88.43 47.41,88.74 47.48,88.88 47.51,89.04 47.57,89.08 47.64,89.14 47.7,89.2 47.82,89.38 47.86,89.6 47.86,89.96 47.66,90.16 47.64,90.27 47.73,90.33 48.17,90.33
GND on TOP (solid shape): outline of 107 points within 4.35,66.28 16.3,88.3
GND on TOP (solid shape): outline of 222 points within 118.82,96.05 129.32,112.18
GND on TOP (solid shape): outline of 510 points within 85.51,47.03 93.58,68.11
GND on TOP (solid shape): outline of 1472 points within 0.26,0.26 94.84,178.45
GND on TOP (solid shape): outline of 2246 points within 96.99,13.2 275.3,175.35
GND on BOTTOM (solid shape): 43.6,98.21 43.6,97.19 43.34,96.94 41.82,96.94 41.56,97.19 41.56,98.21 41.82,98.46 43.34,98.46
GND on BOTTOM (solid shape): 44.23,114.21 44.23,110.53 43.98,110.27 42.07,110.27 41.82,110.53 41.82,114.21 42.07,114.46 43.98,114.46
GND on BOTTOM (solid shape): 72.23,162.12 72.23,158.95 71.89,158.61 70.32,158.61 69.31,159.63 69.31,162.08 69.49,162.26 72.08,162.26
GND on BOTTOM (solid shape): 200.82,61.12 200.82,58.33 199.81,57.31 197.14,57.31 196.88,57.57 196.88,59.98 198.28,61.38 200.57,61.38
GND on BOTTOM (solid shape): 210.27,46.21 210.27,45.32 209.99,45.04 208.24,45.04 208.02,45.26 208.02,46.11 208.17,46.26 210.22,46.26
GND on BOTTOM (solid shape): 212.23,39 212.23,37.73 211.97,37.48 209.08,37.48 208.85,37.7 208.85,39 208.97,39.13 212.1,39.13
GND on BOTTOM (solid shape): 220.13,92.75 220.13,91.86 219.87,91.6 217.71,91.6 217.46,91.86 217.46,92.75 217.71,93 219.87,93
GND on BOTTOM (solid shape): 227.24,57.19 227.24,55.54 226.98,55.28 225.59,55.28 225.33,55.54 225.33,57.06 225.59,57.31 227.11,57.31
GND on BOTTOM (solid shape): 239.43,56.81 239.43,54.39 239.18,54.14 236.13,54.14 235.87,54.39 235.87,56.81 236.13,57.06 239.18,57.06
GND on BOTTOM (solid shape): 252,38.52 252,34.33 251.75,34.07 250.99,34.07 250.73,34.33 250.73,38.52 250.99,38.77 251.75,38.77
GND on BOTTOM (solid shape): 257.34,56.68 257.34,54.27 257.08,54.01 254.29,54.01 253.65,54.65 253.65,56.68 253.91,56.93 257.08,56.93
GND on BOTTOM (solid shape): 261.53,97.95 261.53,94.65 261.27,94.4 258.35,94.4 258.1,94.65 258.1,97.95 258.35,98.21 261.27,98.21
GND on BOTTOM (solid shape): 24.55,146.47 24.55,144.94 24.44,144.84 18.93,144.84 18.9,144.87 18.9,145.39 19.34,145.83 19.34,146.21 19.64,146.52 24.49,146.52
GND on BOTTOM (solid shape): 179.23,52.11 179.23,51.19 178.88,50.84 178.88,49.77 178.8,49.69 178.65,49.69 178.6,49.74 178.6,52.11 178.72,52.23 179.1,52.23
GND on BOTTOM (solid shape): 248.7,67.85 248.7,67.22 247.94,66.46 247.94,65.44 247.81,65.31 246.41,65.31 246.16,65.57 246.16,67.22 246.92,67.98 248.57,67.98
GND on BOTTOM (solid shape): 66.45,74.08 66.45,71.54 66.23,71.31 64.65,71.31 64.04,71.92 63.53,71.92 63.28,72.17 63.28,74.08 63.53,74.33 66.2,74.33
GND on BOTTOM (solid shape): 110.23,30.21 110.23,26.78 110.12,26.67 106.86,26.67 105.55,27.98 103.78,27.98 103.51,28.25 103.51,30.48 103.74,30.7 109.74,30.7
GND on BOTTOM (solid shape): 169.96,118.97 169.96,116.62 169.8,116.46 168.8,116.46 168.7,116.37 166.91,116.37 166.79,116.5 166.79,119.02 167.1,119.34 169.59,119.34
GND on BOTTOM (solid shape): 267.88,82.61 267.88,77.63 267.62,77.38 263.18,77.38 262.92,77.63 262.92,82.9 263.7,83.68 266.81,83.68
GND on BOTTOM (solid shape): 59.39,113.31 59.39,112.33 59.27,112.2 56.36,112.2 55.96,111.81 54.99,111.81 54.93,111.86 54.93,113.4 55.11,113.57 59.13,113.57
GND on BOTTOM (solid shape): 67.22,47.92 67.22,47.15 67.85,46.52 67.85,45.25 67.6,44.99 66.2,44.99 65.95,45.25 65.95,46.52 65.57,46.9 65.57,47.92 65.82,48.17 66.96,48.17
GND on BOTTOM (solid shape): 41.69,73.65 41.69,71.84 41.61,71.77 39.43,71.77 39.38,71.82 39.38,72.63 39.41,72.66 40.76,72.66 40.83,72.73 40.83,73.65 40.9,73.72 41.61,73.72
GND on BOTTOM (solid shape): 83.07,140.03 83.07,138.92 83.06,138.92 83.06,137.55 82.85,137.34 82.67,137.34 81.77,138.24 81.76,138.24 81.33,138.67 81.33,140.18 82.92,140.18
GND on BOTTOM (solid shape): 182.15,71.16 182.15,67.85 181.9,67.6 175.17,67.6 174.91,67.85 174.91,68.62 176.06,69.76 176.06,71.16 176.31,71.41 181.9,71.41
GND on BOTTOM (solid shape): 259.56,101.07 259.56,98.97 259.56,98.78 259.24,98.46 257.78,98.46 257.72,98.52 257.72,99.22 257.4,99.54 255.24,99.54 254.86,99.92 254.86,101 255.11,101.26 259.37,101.26
GND on BOTTOM (solid shape): 267.88,63.16 267.88,60.87 267.62,60.62 264.32,60.62 264.07,60.87 264.07,63.16 264.32,63.41 267.62,63.41
GND on BOTTOM (solid shape): 33.68,73.76 33.68,71.05 33.56,70.94 32.56,70.94 32.39,71.11 32.39,72.18 32.24,72.34 32.24,73.76 32.51,74.03 33.41,74.03
GND on BOTTOM (solid shape): 50.57,78.49 50.57,76.57 50.9,76.24 51.99,76.24 52.02,76.21 52.02,75.3 51.94,75.22 49.95,75.22 49.69,75.47 49.69,77.13 49.95,77.38 49.95,78.4 50.07,78.52 50.54,78.52
GND on BOTTOM (solid shape): 26.13,141.43 26.13,139.56 25.96,139.4 25.24,139.4 25.02,139.18 25.02,136.99 24.87,136.85 23.39,136.85 21.88,138.35 21.75,138.35 21.72,138.39 21.72,141.55 21.75,141.58 25.97,141.58
GND on BOTTOM (solid shape): 128.93,113 128.93,111.28 128.6,110.95 127.94,110.95 127.86,111.03 127.83,111.09 127.65,111.28 127.61,111.28 127.06,111.82 126.4,111.82 126.26,111.96 126.26,112.93 126.5,113.17 128.75,113.17
GND on BOTTOM (solid shape): 187.49,51.34 187.49,48.93 187.74,48.68 190.15,48.68 190.41,48.42 190.41,46.39 190.28,46.26 187.23,46.26 186.34,45.38 184.82,45.38 184.69,45.5 184.69,48.52 185.45,49.28 185.45,51.34 185.71,51.6 187.23,51.6
GND on BOTTOM (solid shape): 262.42,35.85 262.42,35.09 261.91,34.58 261.91,31.79 261.53,31.41 261.53,30.14 261.27,29.88 259.62,29.88 259.37,30.14 259.37,31.53 260.13,32.29 260.13,34.58 260.77,35.22 260.89,35.22 261.02,35.34 261.02,35.98 261.15,36.1 262.16,36.1
GND on BOTTOM (solid shape): 166.15,66.58 166.15,53.5 166.02,53.38 166.02,51.85 165.59,51.42 165.59,50.03 165.5,49.95 164.88,49.95 164.63,50.2 164.63,50.96 164.37,51.22 164.37,52.49 164.63,52.74 164.63,66.58 164.88,66.84 165.9,66.84
GND on BOTTOM (solid shape): 168.18,34.71 168.18,34.45 168.11,34.2 168.18,33.95 168.18,33.44 167.93,33.18 164.12,33.18 163.86,33.44 163.86,34.71 164.12,34.96 167.93,34.96
GND on BOTTOM (solid shape): 172.25,78.27 172.25,76.74 172.37,76.62 173.01,76.62 173.52,77.13 174.53,77.13 174.79,76.87 174.79,75.86 174.53,75.6 171.48,75.6 171.36,75.73 171.36,78.27 171.61,78.52 171.99,78.52
GND on BOTTOM (solid shape): 246.29,53.38 246.29,50.48 247.18,49.59 247.18,48.8 246.92,48.55 244.13,48.55 243.87,48.8 243.87,49.57 244,49.69 244.76,49.69 245.14,50.07 245.14,50.96 244.89,51.22 242.99,51.22 242.86,51.34 242.86,53.38 243.11,53.63 246.03,53.63
GND on BOTTOM (solid shape): 247.91,53.28 247.91,52.5 248.06,52.36 248.14,52.36 249.84,52.36 250.1,52.11 250.1,50.58 249.59,50.07 249.59,48.93 249.34,48.68 247.68,48.68 247.43,48.93 247.43,49.63 246.67,50.39 246.67,53.25 246.82,53.41 247.79,53.41
GND on BOTTOM (solid shape): 264.98,59.5 264.98,58.68 265.13,58.53 266.53,58.53 266.86,58.2 268.13,58.2 268.26,58.08 268.26,57.06 268,56.81 267.37,56.81 266.56,57.62 264.63,57.62 264.45,57.44 264.45,57.19 264.32,57.06 263.56,57.06 262.8,57.82 262.8,58.58 262.92,58.71 264.32,58.71 264.45,58.84 264.45,59.47 264.55,59.57 264.91,59.57
GND on BOTTOM (solid shape): 48.34,155.2 48.52,154.99 48.8,154.97 48.81,154.98 49.79,154.98 50.26,154.51 50.26,153.51 50.04,153.29 48.64,153.29 48.33,153.6 48.33,154.31 48.04,154.61 47.73,154.61 47.58,154.76 47.58,155.02 47.79,155.24 48.32,155.24
GND on BOTTOM (solid shape): 179.29,76.8 179.34,76.8 180.25,76.8 180.56,76.49 181.01,76.49 181.07,76.43 181.07,75.99 180.96,75.87 180.53,75.87 180.03,76.38 180.03,76.5 179.94,76.59 179.64,76.59 179.59,76.6 179.55,76.61 179.34,76.61 179.3,76.6 179.25,76.59 179.07,76.59 178.99,76.67 178.99,76.74 179.05,76.8
GND on BOTTOM (solid shape): 113.33,149.46 113.55,149.37 113.8,149.37 113.8,149.38 114.08,149.38 114.11,149.37 114.78,148.7 114.78,148.51 114.84,148.45 114.84,146.98 114.97,146.85 115.57,146.85 115.71,146.7 115.71,146.4 115.52,146.21 114.23,146.21 114.13,146.11 114.13,144.85 114.07,144.79 113.22,144.79 113.13,144.88 113.13,146.66 112.81,146.98 112.81,149.39 112.89,149.46
GND on BOTTOM (solid shape): 55.41,27.34 55.41,26.94 55.04,26.58 55.02,26.57 54.49,26.11 54.72,25.44 54.72,24.62 54.26,24.17 51.34,24.17 50.45,25.06 50.45,26.71 50.71,26.96 51.34,26.96 51.98,27.6 55.15,27.6
GND on BOTTOM (solid shape): 25.31,160.06 25.31,159.42 24.93,159.04 24.93,157.26 25.43,156.75 25.43,154.47 24.8,153.83 23.78,153.83 23.53,153.58 23.53,152.69 23.43,152.59 23.37,152.56 23.13,152.56 22.94,152.61 22.76,152.56 22.54,152.56 22.36,152.61 22.18,152.56 21.94,152.56 21.89,152.58 21.84,152.6 19.72,154.72 19.72,155.48 19.34,155.87 18.7,155.87 18.58,155.99 18.58,157.39 19.59,157.39 19.72,157.52 19.72,158.28 19.47,158.53 19.21,158.53 19.08,158.66 19.08,159.68 19.59,160.18 25.18,160.18
GND on BOTTOM (solid shape): 48.8,75.98 48.8,69.32 48.75,69.24 48.65,69.23 48.11,68.99 48.47,68.51 48.49,68.51 48.8,68.21 48.8,54.9 47.41,53.5 47.41,45.12 48.8,43.72 48.8,34.71 48.57,34.48 45.73,34.48 45.5,34.71 45.5,53.88 44.61,54.77 44.61,59.09 43.72,59.98 43.72,63.16 44.36,63.79 44.36,73.19 42.83,74.71 42.83,76.11 42.96,76.24 48.55,76.24
GND on BOTTOM (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.13 158.4,168.62 158.38,168.58 158.34,168.57 155.99,168.57 155.74,168.82 155.74,170.72 151.62,174.84 95.33,174.84 94.78,174.28 93.13,174.28 89.82,170.98 85.76,170.98 85.51,171.23 85.51,174.28 85.52,174.3 84.91,174.3 84.88,174.3 84.87,174.32 84.74,174.49 84.59,174.62 84.56,174.74 84.65,174.81 91.41,174.81 91.78,174.95 91.97,175.33 92.01,175.35 156.15,175.35
GND on BOTTOM (solid shape): 18.22,88.28 18.22,88.07 17.18,87.03 14.51,87.03 14.26,87.29 7.02,87.29 6.89,87.41 6.89,88.17 7.15,88.43 13.94,88.43 13.95,88.4 14.28,88.17 14.61,88.4 14.63,88.43 14.93,88.43 14.96,88.4 14.99,88.37 14.98,88.33 15.12,87.82 15.61,88.01 15.69,88.08 15.78,88.05 16.54,88.05 16.8,87.79 17.18,87.79 17.43,88.05 17.43,88.3 17.69,88.56 17.94,88.56
GND on BOTTOM (solid shape): 150.03,50.1 150.03,29.58 149.9,29.44 147.19,29.44 146.95,29.68 146.95,33.37 147,33.46 147.1,33.46 147.48,33.46 147.49,33.45 147.94,33.88 147.35,34.05 147.33,34.03 147.26,34.03 147.26,34.11 147.02,34.35 146.95,34.35 146.95,44.15 147.07,44.15 147.08,44.16 147.1,44.16 147.51,44.53 147.07,44.86 146.98,44.88 146.95,44.96 146.95,49.89 147.32,50.26 149.87,50.26
GND on BOTTOM (solid shape): 150.07,90.83 150.07,68.8 149.98,68.71 147.03,68.71 146.95,68.79 146.95,69.95 147.09,69.95 148.11,70.97 148.11,71.55 147.91,72.2 147.72,71.55 147.72,71.14 147.13,70.55 147.01,70.52 146.95,70.62 146.95,74.75 147.21,74.75 147.59,74.38 147.59,74.35 148.19,74.05 147.89,74.66 147.87,74.66 147.37,75.15 146.95,75.15 146.95,90.84 147.03,90.91 149.98,90.91
GND on BOTTOM (solid shape): 50.25,144.63 50.25,143.69 50.08,143.52 49.57,143.52 49.57,143.51 49.17,143.51 49.14,143.47 49.13,143.47 48.88,143.14 49.07,142.78 49.17,142.74 49.26,142.73 49.47,142.73 49.61,142.59 49.61,136.64 49.43,136.46 47.44,136.46 47.24,136.66 47.24,139.51 46.9,139.85 46.91,139.89 46.87,140.27 46.5,140.39 46.36,140.31 46.26,140.17 46.25,140.14 45.67,140.14 45.55,140.25 45.55,140.8 45.57,140.84 45.83,140.96 45.93,141.2 45.93,141.25 45.92,141.31 45.91,141.34 46.11,141.54 46.5,141.54 46.56,141.45 46.64,141.38 46.64,141.35 47.04,140.96 47.1,140.89 47.1,140.87 47.47,140.6 47.6,141.04 47.6,141.29 48.19,141.88 48.19,144.8 48.34,144.96 49.92,144.96
GND on BOTTOM (solid shape): outline of 91 points within 121.45,29.37 136.43,90.71
GND on BOTTOM (solid shape): 58.12,99.68 58.12,99.67 58.2,99.56 58.32,99.48 58.33,99.47 58.45,99.35 58.65,99.35 58.75,99.29 58.73,99.18 58.69,99.14 58.58,98.97 58.56,98.77 58.55,98.73 58.52,98.71 58.42,98.68 58.34,98.62 58.27,98.59 58.2,98.62 57.59,98.36 58.2,98.11 58.27,98.14 58.34,98.11 58.7,98.03 58.94,98.32 58.96,98.35 58.99,98.36 59.04,98.36 59.08,98.35 59.1,98.32 59.33,98.03 59.7,98.11 59.77,98.14 59.84,98.11 60.11,98.01 60.37,98.15 60.44,98.19 60.52,98.16 60.74,97.94 60.74,96.8 60.13,96.19 60.13,96.05 60.1,96 60.04,96.01 60.02,96.04 59.84,96.16 59.62,96.2 59.19,96.2 58.93,95.95 56.52,95.95 56.44,95.94 56.36,95.92 56.3,95.92 56.17,96.05 56.17,97.7 56.55,98.08 56.93,98.08 57.31,98.46 57.31,98.92 57.31,98.92 57.31,99.48 57.57,99.73 58.07,99.73
GND on BOTTOM (solid shape): outline of 209 points within 257.46,121.07 262.16,128.18
GND on BOTTOM (solid shape): outline of 245 points within 85.53,47.15 93.58,68.11
GND on BOTTOM (solid shape): outline of 322 points within 4.35,74.71 23.15,80.81
GND on BOTTOM (solid shape): outline of 1509 points within 0.26,0.26 94.92,178.45
GND on BOTTOM (solid shape): outline of 2151 points within 97.28,13.2 275.3,175.35
GND on IN1 (solid shape): 47.28,74.97 47.28,70.01 47.02,69.76 44.48,69.76 44.23,70.01 44.23,74.97 44.48,75.22 47.02,75.22
GND on IN1 (solid shape): 47.41,59.28 47.41,54.33 47.15,54.07 44.61,54.07 44.36,54.33 44.36,59.28 44.61,59.54 47.15,59.54
GND on IN1 (solid shape): 49.06,43.35 49.06,39.53 48.61,39.09 46.01,39.09 45.5,39.6 45.5,44.23 45.75,44.49 47.92,44.49
GND on IN1 (solid shape): 90.73,174.18 90.73,171.19 90.47,170.93 86.59,170.93 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN1 (solid shape): 11.99,177.26 11.99,176.89 12.19,176.69 12.19,175.69 11.99,175.49 11.99,172.98 12.19,172.78 12.21,172.78 12.23,172.77 12.23,172.58 12,172.36 11.99,172.36 11.99,168.09 11.18,167.28 8.31,167.28 7.95,167.64 7.95,171.88 7.72,172.11 7.72,172.4 7.95,172.62 7.95,176.87 7.73,177.09 7.73,177.37 7.8,177.44 11.81,177.44
GND on IN1 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.14 59,175.08 59.11,175.08 59.59,174.6 65.1,174.6 65.2,174.7 65.4,174.7 65.53,174.58 65.53,174.42 65.45,174.34 65.45,171.15 65.12,170.82 61.47,170.82 60.02,169.37 60.02,164.99 58.74,163.71 55.65,163.71 50.77,168.59 50.77,172.18 49.9,173.05 49.57,173.05 49.38,173.24 49.38,177.58 50.15,178.35 52,178.35
GND on IN1 (solid shape): 32.79,178.12 33.62,178.12 34.27,177.47 34.27,176.54 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,177.26 23.19,177.44 26.05,177.44 27.02,176.48 32.27,176.48 32.27,177.66 32.74,178.13 32.78,178.13
GND on IN1 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.5 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.45,175.35
GND on IN1 (solid shape): outline of 583 points within 0.26,0.26 275.3,178.45
GND on VCC (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.05 158.4,168.57 156.59,168.57 156.2,168.18 155.97,168.18 155.74,168.42 155.74,175.19 155.89,175.35 156.34,175.35
GND on VCC (solid shape): 174.84,175.35 175.72,174.98 176.09,174.1 176.09,172.9 176.6,171.66 177.84,171.15 179.55,171.15 180.43,170.78 180.8,169.9 180.8,161.45 181.12,160.61 181.92,160.2 181.94,160.2 182.05,160.2 182.25,160.2 182.78,159.98 183,159.45 183,156.66 182.55,155.71 181.53,155.44 177.87,153.23 179.56,149.3 179.88,149 180,148.58 180,138.66 179.81,138.47 179.77,138.47 179.66,138.53 179.54,138.57 179.5,138.58 179.5,145.03 176.56,147.97 176.56,148.25 176.6,148.25 177.2,148.84 177.2,154.51 176.18,155.52 176.18,166.45 174.06,168.57 173.49,168.57 173.11,168.95 173.11,175 173.18,175.17 173.35,175.25 173.89,175.25 174.07,175.28 174.22,175.35
GND on VCC (solid shape): outline of 1102 points within 30.51,0.26 81.35,68.36
GND on VCC (solid shape): outline of 2942 points within 6.26,160.56 91.45,178.45
GND on VCC (solid shape): outline of 6674 points within 93.89,25.82 161.2,48.14
GND on VCC (solid shape): outline of 7746 points within 91.86,65.67 161.45,91.32
GND on IN2 (solid shape): 90.73,174.18 90.73,171.19 90.47,170.93 86.59,170.93 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN2 (solid shape): 12.15,177.33 12.15,172.45 12.07,172.37 11.99,172.37 11.99,168.09 11.18,167.28 8.38,167.28 8.01,167.65 7.95,167.65 7.8,167.8 7.8,177.39 8.02,177.61 11.87,177.61
GND on IN2 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.23 59.57,174.6 65.05,174.6 65.14,174.69 65.45,174.69 65.51,174.64 65.51,174.41 65.45,174.35 65.45,171.15 65.12,170.82 61.47,170.82 60.02,169.37 60.02,164.99 58.74,163.71 55.65,163.71 50.77,168.59 50.77,172.18 49.9,173.05 49.57,173.05 49.38,173.24 49.38,177.63 50.1,178.35 52,178.35
GND on IN2 (solid shape): 34.36,177.4 34.36,176.45 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,176.49 22.95,176.54 22.95,177.23 23.17,177.44 26.05,177.44 27.02,176.48 32.16,176.48 32.31,176.62 32.31,177.83 32.68,178.19 33.57,178.19
GND on IN2 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.26 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.13,175.35
GND on IN2 (solid shape): outline of 221 points within 0.26,0.26 85,178.45
GND on IN2 (solid shape): outline of 311 points within 97.03,13.48 275.3,175.35
GND on IN2 (solid shape): outline of 7211 points within 88.81,68.32 161.45,95.41
GND on IN2 (solid shape): outline of 8034 points within 91.6,21.75 162.59,51.98
GND on IN2 (solid shape): outline of 8037 points within 71.79,39.15 90.59,70.01
GND on IN3 (solid shape): 47.28,74.97 47.28,70.01 47.02,69.76 44.48,69.76 44.23,70.01 44.23,74.97 44.48,75.22 47.02,75.22
GND on IN3 (solid shape): 47.41,59.28 47.41,54.33 47.15,54.07 45.18,54.07 44.36,54.9 44.36,59.28 44.61,59.54 47.15,59.54
GND on IN3 (solid shape): 49.06,43.49 49.06,39.53 48.61,39.09 46.01,39.09 45.5,39.6 45.5,44.23 45.75,44.49 48.06,44.49
GND on IN3 (solid shape): 90.73,174.18 90.73,171.19 90.47,170.93 86.59,170.93 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN3 (solid shape): 12.13,177.34 12.13,172.42 12.05,172.34 11.99,172.34 11.99,168.09 11.18,167.28 8.36,167.28 7.68,167.96 7.68,177.31 7.95,177.59 11.87,177.59
GND on IN3 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.14 59.48,174.6 65,174.6 65.15,174.75 65.5,174.75 65.63,174.61 65.63,174.46 65.45,174.28 65.45,171.46 65.05,171.06 56.16,171.06 53.79,173.43 49.5,173.43 49.38,173.55 49.38,177.6 50.11,178.33 50.11,178.35 52,178.35
GND on IN3 (solid shape): 33.86,177.86 33.86,176.95 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,176.53 22.93,176.61 22.93,177.27 23.11,177.44 26.05,177.44 27.02,176.48 32.25,176.48 32.25,177.5 32.88,178.13 33.58,178.13
GND on IN3 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.33 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.41,175.35
GND on IN3 (solid shape): outline of 542 points within 0.26,0.26 275.3,178.45
GND on IN4 (solid shape): 47.28,74.97 47.28,70.01 47.02,69.76 44.48,69.76 44.23,70.01 44.23,74.97 44.48,75.22 47.02,75.22
GND on IN4 (solid shape): 47.41,59.28 47.41,54.33 47.15,54.07 44.61,54.07 44.36,54.33 44.36,59.28 44.61,59.54 47.15,59.54
GND on IN4 (solid shape): 49.06,43.47 49.06,39.53 48.93,39.41 45.69,39.41 45.5,39.6 45.5,44.23 45.75,44.49 48.04,44.49
GND on IN4 (solid shape): 90.73,174.18 90.73,171.19 90.59,171.06 86.47,171.06 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN4 (solid shape): 12.23,177.18 12.23,172.46 12.15,172.37 11.99,172.37 11.99,170.44 11.39,169.84 11.39,167.49 11.18,167.28 8.31,167.28 7.95,167.65 7.95,171.56 7.71,171.79 7.71,177.35 7.8,177.44 8.13,177.44 8.14,177.44 11.97,177.44
GND on IN4 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.14 59.48,174.6 65.05,174.6 65.17,174.72 65.45,174.72 65.52,174.65 65.52,174.45 65.4,174.33 65.45,174.28 65.45,171.68 64.93,171.15 61.8,171.15 59.66,169.02 59.66,164.64 58.74,163.71 55.65,163.71 50.77,168.59 50.77,172.18 49.9,173.05 49.57,173.05 49.38,173.24 49.38,177.52 50.21,178.35 52,178.35
GND on IN4 (solid shape): 33.97,177.78 33.97,176.61 34.11,176.48 34.34,176.48 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,176.56 22.98,176.58 22.98,177.32 23.1,177.44 26.05,177.44 27.02,176.48 32.14,176.48 32.32,176.65 32.32,177.74 32.76,178.17 33.58,178.17
GND on IN4 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.06 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.29,175.35
GND on IN4 (solid shape): outline of 240 points within 0.26,0.26 95.07,178.45
GND on IN4 (solid shape): outline of 309 points within 98.02,13.48 275.3,175.35
GND on TOP: 49.52,135.86 49.39,135.73 48.77,135.73 48.06,136.45 48.06,145.11 48.57,145.62 49.39,145.62 49.52,145.49
GND on TOP: 221.75,19.1 221.58,19.27 221.58,19.7 221.33,19.96 204.92,19.96 204.55,20.32 204.55,34.86 202,37.41 177.97,37.41 176.44,38.94 176.44,51.55 177.27,52.37 195.68,52.37 196.57,53.26 196.57,60.55 195.35,61.77 185.95,61.77 185.14,62.58 185.14,71.11 185.6,71.56 194.76,71.56 223.7,42.62 229.27,42.62 230.04,43.39 230.04,56.26 232.96,59.18 242.91,59.18 246.09,62.36 255.07,62.36 261.38,56.06 263.14,56.06 263.73,56.65 263.73,57.04 262.79,57.98 262.79,58.72 262.81,58.73 262.81,59.04 263.09,59.33 266.59,59.33 268.11,57.8 268.11,47.55 263.36,42.8 242.78,42.8 239.9,39.92 239.9,36.56 240.77,35.69 262.66,35.69 270.38,43.41 270.38,57.89 261.36,66.92 261.36,68.51 256.54,73.33 256.54,84.52 259.55,87.53 264.8,87.53 274.29,78.04 274.29,38.57 264.58,28.87 264.58,23.76 261.83,21.02 230.35,21.02 229.74,21.63 229.74,24.96 228.69,26.01 226.25,26.01 225.29,25.05 225.29,19.47 224.92,19.1
GND on GND1: outline of 348 points within 0.26,0.26 275.3,178.45
GND on VCC: outline of 85 points within 249.84,105.19 275.3,174.45
GND on GND2: outline of 351 points within 0.26,0.26 275.3,178.45
GND on GND3: outline of 347 points within 0.26,0.26 275.3,178.45
GND_CHASSIS on TOP (solid shape): 175.18,151.07 175.18,150.01 175.07,149.9 172.98,149.9 172.86,150.02 172.86,152.03 173.39,152.56 173.68,152.56
GND_CHASSIS on BOTTOM (solid shape): 167.55,158.41 167.55,157.77 167.29,157.52 166.56,157.52 165.74,157.52 165.62,157.52 164.85,157.52 164.73,157.52 163.33,157.52 163.15,157.69 163.15,158.58 163.23,158.66 167.29,158.66
+BL_PWR_SRC on TOP (solid shape): 53.76,155.61 53.76,154.05 53.51,153.81 49.7,153.81 49.64,153.87 49.64,155.66 49.85,155.87 53.5,155.87
+BL_PWR_SRC on BOTTOM (solid shape): 52.36,154.85 55.66,154.85 55.91,154.6 55.91,153.33 55.66,153.07 52.72,153.07 52.54,153.12 52.35,153.07 51.12,153.07 51.12,153.16 50.83,153.44 50.83,155.3 51.01,155.46 51.08,155.69 51.08,155.74 51.47,155.74
+CAMERA_VDD on TOP (solid shape): 57.38,152.81 57.38,152.38 56.8,151.8 56.8,151.18 56.47,150.85 51.91,150.85 51.48,151.28 49.71,151.28 49.62,151.37 49.62,151.54 49.69,151.61 51.14,151.61 51.52,151.99 51.96,151.99 51.97,151.99 52.13,151.95 52.29,151.99 52.3,151.99 52.45,151.99 52.84,151.81 53.12,152.14 53.12,152.16 53.2,152.24 55.56,152.24 56.07,152.75 56.07,152.97 56.13,153.02 57.16,153.02
+CAMERA_VDD on BOTTOM (solid shape): 59.06,153.96 59.06,152.64 58.78,152.36 56.19,152.36 56.06,152.5 56.06,153.69 56.72,154.35 58.66,154.35
+CAP_LDO on TOP (solid shape): outline of 175 points within 215.57,84.29 219.64,90.59
+CHAGER_SRC on BOTTOM (solid shape): 196,49.31 196,39.91 195.74,39.66 191.3,39.66 191.04,39.91 191.04,43.85 190.79,44.11 184.82,44.11 184.69,44.23 184.69,44.99 184.82,45.12 186.47,45.12 187.23,45.88 190.41,45.88 190.79,46.26 190.79,49.31 191.04,49.57 195.74,49.57
+DC1_PWR_SRC on BOTTOM (solid shape): 249.72,47.79 252.61,47.79 252.89,47.51 252.89,43.85 252.64,43.6 243.75,43.6 242.73,42.58 241.21,42.58 240.95,42.84 240.95,44.87 240.45,45.38 240.45,47.79 240.7,48.04 249.46,48.04
+DC1_PWR_SRC on BOTTOM (solid shape): 247.09,58.3 247.09,58.11 247.08,58.06 247.07,58.02 247.07,57.49 247.43,57.13 247.49,57.13 247.86,56.77 247.86,55.99 247.67,55.8 246.66,55.8 246.59,55.88 246.59,56.47 246.9,56.78 246.9,57.08 246.9,57.1 246.9,58.31 246.94,58.35 247.04,58.35
+DC_IN on BOTTOM (solid shape): 23.02,79.03 23.02,76.49 22.77,76.24 20.23,76.24 18.83,74.84 18.83,72.68 18.58,72.43 15.78,72.43 15.53,72.68 15.53,74.97 16.04,75.47 16.04,77.25 16.29,77.51 18.7,77.51 20.48,79.28 22.77,79.28
+DC_IN_SS on BOTTOM (solid shape): outline of 123 points within 13.24,66.71 25.82,74.59
+DCIN_JACK on BOTTOM (solid shape): outline of 354 points within 6.89,81.32 20.52,87.85
+DOCK_PWR_BAR on TOP (solid shape): outline of 7209 points within 108.49,43.34 229.14,135.04
+DOCK_PWR_BAR on BOTTOM (solid shape): 229.14,48.93 229.14,39.15 229.02,39.03 228.76,39.03 228.74,39.03 228.13,39.03 227.75,38.64 223.17,38.64 222.92,38.9 222.92,43.98 222.54,44.36 222.03,44.36 221.78,44.11 218.86,44.11 218.73,44.23 218.73,45.63 218.86,45.76 222.41,45.76 222.67,46.01 222.67,48.68 222.97,48.98 229.09,48.98
+DP_VCC on BOTTOM (solid shape): outline of 108 points within 260.31,146.14 268.13,158.04
+LCDVDD on TOP (solid shape): 49.1,153.14 50.93,153.14 50.98,153.09 50.98,151.91 50.89,151.82 49.44,151.82 49.44,151.87 49.08,152.21 48.73,151.87 48.72,151.82 47.58,151.82 47.33,152.08 47.33,153.09 47.82,153.58 48.66,153.58
+LCDVDD on BOTTOM (solid shape): 48.17,154.21 48.17,153.45 48.8,152.82 48.8,152.23 48.77,152.21 48.73,152.18 48.49,151.93 48.4,151.93 48.04,151.93 47.99,151.88 47.23,151.88 47.16,151.87 47.08,151.85 47.02,151.85 46.96,151.85 46.9,151.84 46.87,151.83 46.77,151.93 46.77,154.21 47.02,154.47 47.91,154.47
+LCDVDD on IN2 (solid shape): 48.93,153.07 48.93,152.31 48.68,152.06 47.28,152.06 46.9,152.44 46.9,153.07 47.04,153.21 48.79,153.21
+MXM_PWR_SRC on TOP (solid shape): 143.67,111.67 143.67,104.81 143.54,104.68 142.15,104.68 141.51,105.32 134.65,105.32 134.4,105.07 134.4,102.25 134.33,102.16 134.22,102.19 133.59,101.97 134.22,101.74 134.33,101.77 134.4,101.68 134.4,96.18 134.27,96.05 129.96,96.05 129.83,96.18 129.83,103.54 130.08,103.8 130.08,106.72 129.7,107.1 129.7,111.83 130.17,112.3 143.04,112.3
+PCH_USB_DCPSUS3 on IN2 (solid shape): outline of 233 points within 37.98,103.29 39.31,108.58
