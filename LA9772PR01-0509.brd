# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D1: length 88.1
  TOP w0.102: JCPU1.AT18 v1(90.12,75.75)
  TOP w0.14: v1(154.56,90.17) 153.15,88.76 JDIMM3.7
  IN3 w0.089: 92.11,77.25 91,76.15 90.52,76.15 v1(90.12,75.75)
  IN3 w0.127: v1(154.56,90.17) 154.8,90.17 154.92,90.3 154.92,90.52 154.8,90.64 153.04,90.64 150.82,92.87 145.16,92.87 143.21,94.81 139.53,94.81 139.4,94.69 139.4,94.05 139.27,93.92 139.02,93.92 138.89,94.05 138.89,94.69 138.77,94.81 138.51,94.81 138.38,94.69 138.38,94.32 138.26,94.19 138,94.19 137.88,94.32 137.88,94.69 137.75,94.81 137.39,94.81 130.94,88.36 99.69,88.36 95.79,84.45 95.79,80.93 92.11,77.25
  BOTTOM w0.14: v1(154.56,90.17) 154.11,89.72 153.17,89.72 152.51,89.06 JDIMM4.6
DDR_B_D2: length 91.9
  TOP w0.102: JCPU1.AM17 v1(91.12,71.75)
  TOP w0.14: v1(157.62,86.91) 157.74,86.91 158.59,86.06 JDIMM3.16
  IN3 w0.089: 94.73,77.25 93.56,76.08 93.56,74.51 93.35,74.3 92.87,74.3 92.54,73.97 92.54,73.62 92.24,73.32 89.85,73.32 89.54,73.01 89.54,71.71 89.9,71.36 90.61,71.36 91,71.75 v1(91.12,71.75)
  IN3 w0.127: 94.73,77.25 97.85,80.37 101.54,80.37 101.68,80.51 104.21,80.51 108.06,84.36 108.79,84.36 108.92,84.49 108.92,84.94 109.04,85.07 109.3,85.07 109.42,84.94 109.42,84.49 109.55,84.36 109.81,84.36 109.93,84.49 109.93,84.94 110.06,85.07 110.31,85.07 110.44,84.94 110.44,84.49 110.57,84.36 110.82,84.36 110.95,84.49 110.95,84.94 111.08,85.07 111.33,85.07 111.46,84.94 111.46,84.49 111.58,84.36 111.84,84.36 111.96,84.49 111.96,84.94 112.09,85.07 112.35,85.07 112.47,84.94 112.47,84.49 112.6,84.36 112.85,84.36 112.98,84.49 112.98,84.87 113.11,85 113.36,85 113.49,84.87 113.49,84.49 113.62,84.36 125.83,84.36 127.82,86.35 131.63,86.35 134.45,89.17 137.09,89.17 139.02,91.1 149.89,91.1 152.98,88 156.52,88 v1(157.62,86.91)
  BOTTOM w0.14: JDIMM4.15 158.17,86.36 v1(157.62,86.91)
DDR_B_D3: length 92.7
  TOP w0.102: JCPU1.AM18 v1(90.12,71.75)
  TOP w0.14: JDIMM3.18 158.46,85.46 157.7,86.22 156.79,86.22 v1(156.1,86.91)
  IN3 w0.089: 95.23,77.25 94.95,76.97 94.7,76.97 93.73,76.01 93.73,74.43 93.42,74.12 92.94,74.12 92.72,73.9 92.72,73.54 92.31,73.14 89.92,73.14 89.75,72.96 89.75,72.1 90.1,71.75 v1(90.12,71.75)
  IN3 w0.127: 95.23,77.25 98.02,80.04 101.67,80.04 101.81,80.18 104.35,80.18 108.2,84.03 125.97,84.03 127.91,85.96 131.72,85.96 134.59,88.83 137.23,88.83 139.16,90.76 144.81,90.76 144.94,90.64 144.94,89.66 145.07,89.53 145.32,89.53 145.45,89.66 145.45,90.64 145.57,90.76 145.83,90.76 145.96,90.64 145.96,89.66 146.08,89.53 146.34,89.53 146.46,89.66 146.46,90.64 146.59,90.76 146.84,90.76 146.97,90.64 146.97,89.66 147.1,89.53 147.35,89.53 147.48,89.66 147.48,90.64 147.61,90.76 149.75,90.76 152.84,87.67 155.34,87.67 v1(156.1,86.91)
  BOTTOM w0.14: v1(156.1,86.91) 156.95,86.05 157.79,86.05 158.09,85.75 159.39,85.75 JDIMM4.17
DDR_B_D4: length 87.9
  TOP w0.102: JCPU1.AR17 v1(91.12,74.75)
  TOP w0.14: v1(157.61,90.17) 158.12,89.66 JDIMM3.4
  IN3 w0.089: v1(91.12,74.75) 91.73,75.35 91.73,75.88 93.1,77.25
  IN3 w0.127: v1(157.61,90.17) 157.16,89.72 152.84,89.72 150.36,92.2 144.88,92.2 142.94,94.14 140.44,94.14 137.34,91.04 137.16,91.04 136.26,91.94 136.08,91.94 135.9,91.76 135.9,91.58 136.37,91.11 136.37,90.93 136.19,90.75 136.01,90.75 135.25,91.52 135.07,91.52 134.89,91.34 134.89,91.16 135.37,90.68 135.37,90.5 135.19,90.32 135.01,90.32 134.53,90.8 134.35,90.8 131.24,87.69 99.97,87.69 96.59,84.31 96.59,80.75 93.1,77.25
  BOTTOM w0.14: JDIMM4.5 158.42,89.36 v1(157.61,90.17)
DDR_B_D5: length 88.3
  TOP w0.102: v1(91.06,75.75) 90.59,75.33 JCPU1.AT17
  TOP w0.14: v1(156.09,90.17) 157.2,89.06 JDIMM3.6
  IN3 w0.089: v1(91.06,75.75) 90.68,75.37 89.97,75.37 89.75,75.59 89.75,75.9 91.1,77.25
  IN3 w0.127: 91.1,77.25 95.45,81.61 95.45,84.59 99.55,88.69 130.74,88.69 137.19,95.15 143.35,95.15 145.3,93.21 150.95,93.21 153.18,90.98 155.28,90.98 v1(156.09,90.17)
  BOTTOM w0.14: JDIMM4.7 157.5,88.76 v1(156.09,90.17)
DDR_B_D6: length 92.7
  TOP w0.102: JCPU1.AN17 v1(91.12,72.75)
  TOP w0.14: JDIMM3.17 153.43,85.76 v1(154.57,86.91)
  IN3 w0.089: 95.77,77.25 94.57,76.05 94.57,73.51 94.37,73.32 92.9,73.32 92.57,72.99 92.57,72.53 92.34,72.3 91.65,72.3 91.2,72.75 v1(91.12,72.75)
  IN3 w0.127: v1(154.57,86.91) 154.57,87.23 154.47,87.33 152.71,87.33 150.84,89.2 144.64,89.2 144,89.84 138.71,89.84 136.3,87.43 133.72,87.43 129.98,83.69 120.71,83.69 120.58,83.56 120.58,83 120.46,82.87 120.2,82.87 120.08,83 120.08,83.56 119.95,83.69 119.69,83.69 119.57,83.56 119.57,83 119.44,82.87 119.19,82.87 119.06,83 119.06,83.56 118.93,83.69 118.68,83.69 118.55,83.56 118.55,83 118.42,82.87 118.17,82.87 118.04,83 118.04,83.56 117.92,83.69 111.6,83.69 111.47,83.56 111.47,82.41 111.34,82.28 111.09,82.28 110.96,82.41 110.96,83.56 110.83,83.69 110.58,83.69 110.45,83.56 110.45,82.72 110.33,82.59 110.07,82.59 109.95,82.72 109.95,83.56 109.82,83.69 109.56,83.69 109.44,83.56 109.44,82.86 109.31,82.73 109.06,82.73 108.93,82.86 108.93,83.56 108.8,83.69 108.34,83.69 104.49,79.84 101.95,79.84 101.81,79.7 98.22,79.7 95.77,77.25
  BOTTOM w0.14: JDIMM4.18 153.13,85.46 v1(154.57,86.91)
DDR_B_D7: length 90.1
  TOP w0.102: JCPU1.AN18 v1(90.12,72.75)
  TOP w0.14: v1(153.05,86.91) 152.51,86.36 JDIMM3.15
  IN3 w0.089: 96.25,77.25 95.51,76.52 95.28,76.52 94.75,75.98 94.75,73.44 94.45,73.14 92.97,73.14 92.75,72.91 92.75,72.45 92.41,72.12 90.75,72.12 v1(90.12,72.75)
  IN3 w0.127: 96.25,77.25 98.37,79.37 101.95,79.37 102.09,79.51 104.63,79.51 107.07,81.95 107.6,81.95 107.73,82.08 107.73,82.61 107.86,82.74 108.11,82.74 108.24,82.61 108.24,82.08 108.36,81.95 111.86,81.95 111.99,82.08 111.99,83.23 112.11,83.36 112.37,83.36 112.49,83.23 112.49,82.47 112.62,82.34 112.87,82.34 113,82.47 113,83.23 113.13,83.36 113.38,83.36 113.51,83.23 113.51,82.66 113.64,82.54 113.89,82.54 114.02,82.66 114.02,83.23 114.14,83.36 114.4,83.36 114.53,83.23 114.53,82.66 114.65,82.54 115.01,82.54 115.14,82.66 115.14,83.23 115.26,83.36 116.76,83.36 117.58,82.54 122.25,82.54 122.38,82.66 122.38,83.23 122.5,83.36 122.76,83.36 122.88,83.23 122.88,82.66 123.01,82.54 124.56,82.54 124.68,82.66 124.68,83.2 124.81,83.32 125.07,83.32 125.19,83.2 125.19,82.66 125.32,82.54 125.92,82.54 126.04,82.66 126.04,82.98 126.17,83.11 126.42,83.11 126.55,82.98 126.55,82.66 126.68,82.54 127.83,82.54 127.96,82.66 127.96,83.23 128.08,83.36 128.34,83.36 128.47,83.23 128.47,82.66 128.59,82.54 129.3,82.54 133.86,87.09 136.44,87.09 138.85,89.5 143.86,89.5 144.5,88.86 150.7,88.86 152.66,86.91 v1(153.05,86.91)
  BOTTOM w0.14: v1(153.05,86.91) 152.21,86.07 151.21,86.07 JDIMM4.16
DDR_B_D8: length 72.5
  TOP w0.102: JCPU1.AT12 v1(96.12,75.75)
  TOP w0.14: JDIMM3.21 152.87,84.56 v1(153.16,84.85)
  IN3 w0.089: v1(96.12,75.75) 96.7,75.17 97.6,75.17 97.73,75.3 98.22,75.3 98.57,75.65 98.57,75.98 99.85,77.25
  IN3 w0.127: 99.85,77.25 100.86,78.27 102.41,78.27 102.55,78.41 105.09,78.41 106.91,80.23 107.46,80.23 107.59,80.36 107.59,80.64 107.71,80.77 107.97,80.77 108.09,80.64 108.09,80.36 108.22,80.23 108.48,80.23 108.6,80.36 108.6,80.63 108.73,80.76 108.98,80.76 109.11,80.63 109.11,80.36 109.24,80.23 109.49,80.23 109.62,80.36 109.62,80.69 109.75,80.82 110,80.82 110.13,80.69 110.13,80.36 110.25,80.23 111.51,80.23 111.63,80.36 111.63,80.71 111.76,80.83 112.01,80.83 112.14,80.71 112.14,80.36 112.27,80.23 112.85,80.23 112.98,80.35 112.98,80.88 113.51,81.42 129.74,81.42 134.32,85.99 136.9,85.99 138.67,87.76 150.24,87.76 153.15,84.85 v1(153.16,84.85)
  BOTTOM w0.14: v1(153.16,84.85) 152.57,84.26 JDIMM4.22
DDR_B_D9: length 76
  TOP w0.102: JCPU1.AR12 v1(96.12,74.75)
  TOP w0.14: JDIMM3.23 153.83,83.96 154.68,84.82 v1(154.68,84.85)
  IN3 w0.089: 98.94,77.25 97.65,75.96 97.65,75.74 97.28,75.37 96.91,75.37 96.6,75.68 96.6,75.79 96.28,76.12 95.97,76.12 95.75,75.9 95.75,75.12 v1(96.12,74.75)
  IN3 w0.127: 98.94,77.25 100.29,78.6 102.27,78.6 102.41,78.74 104.95,78.74 107.39,81.18 112.8,81.18 113.39,81.77 129.62,81.77 134.18,86.32 136.76,86.32 138.53,88.1 150.38,88.1 153.15,85.33 154.21,85.33 v1(154.68,84.85)
  BOTTOM w0.14: v1(154.68,84.85) 153.49,83.66 JDIMM4.24
DDR_B_D10: length 78.5
  TOP w0.102: v1(96.1,72.71) 95.61,72.28 JCPU1.AN12
  TOP w0.14: v1(153.38,81.65) 153.38,81.12 153.22,80.96 JDIMM3.33
  IN3 w0.089: v1(96.1,72.71) 95.75,72.36 95.75,71.59 95.97,71.37 96.28,71.37 96.66,71.75 96.66,71.81 97.14,72.3 98.2,72.3 98.69,72.78 98.69,72.85 99.01,73.16 99.32,73.16 99.73,73.57 99.73,73.88 99.97,74.13 100.28,74.13 100.72,74.56 100.72,74.88 101.04,75.19 101.1,75.19 101.53,75.63 101.53,76.01 102.04,76.52 103.52,76.52 103.66,76.66 106.28,76.66 106.85,77.22
  IN3 w0.127: v1(153.38,81.65) 153.38,81.41 153.27,81.3 152.76,81.3 152.45,81.61 152.45,81.79 152.82,82.17 152.82,82.35 152.64,82.53 152.47,82.53 152.09,82.15 151.91,82.15 151.73,82.33 151.73,82.51 151.99,82.77 151.99,82.94 151.81,83.12 151.63,83.12 151.37,82.87 151.19,82.87 151.01,83.05 151.01,83.23 151.27,83.48 151.27,83.66 151.09,83.84 150.91,83.84 150.65,83.59 150.47,83.59 149.86,84.2 147.45,84.2 147.33,84.08 147.33,83.91 147.2,83.78 146.94,83.78 146.82,83.91 146.82,84.08 146.69,84.2 146.44,84.2 146.31,84.08 146.31,83.91 146.18,83.78 145.93,83.78 145.8,83.91 145.8,84.08 145.67,84.2 145.42,84.2 145.29,84.08 145.29,83.91 145.17,83.78 144.91,83.78 144.79,83.91 144.79,84.08 144.66,84.2 138.32,84.2 136.58,82.47 134.73,82.47 131.6,79.33 115.09,79.33 114.56,78.81 114.56,78.63 114.86,78.33 114.86,78.15 114.68,77.97 114.5,77.97 114.2,78.27 114.02,78.27 113.33,77.57 107.2,77.57 106.85,77.22
  BOTTOM w0.14: v1(153.38,81.65) 153.38,81.39 153.02,81.04 152.82,81.04 152.44,80.66 JDIMM4.34
DDR_B_D11: length 80.4
  TOP w0.102: JCPU1.AM11 v1(97.12,71.75)
  TOP w0.14: JDIMM3.36 158.61,80.06 158.04,80.63 157.07,80.63 156.52,81.18 156.52,81.55 v1(156.42,81.65)
  IN3 w0.089: v1(97.12,71.75) 97.5,72.12 98.28,72.12 98.53,72.37 99.31,72.37 99.52,72.58 99.52,72.98 99.75,73.21 100.18,73.21 100.52,73.55 100.52,74.01 100.86,74.35 101.29,74.35 101.51,74.57 101.51,75.12 101.71,75.32 101.71,75.93 102.12,76.34 103.59,76.34 103.73,76.48 106.39,76.48 107.14,77.24 108.62,77.24
  IN3 w0.127: v1(156.42,81.65) 156.42,81.36 156.55,81.23 157.73,81.23 157.86,81.1 157.86,80.5 157.73,80.37 156.05,80.37 155.46,80.97 152.62,80.97 149.72,83.87 147.9,83.87 147.47,83.44 144.55,83.44 144.12,83.87 140.62,83.87 140.49,83.74 140.49,83.56 140.37,83.44 140.11,83.44 139.98,83.56 139.98,83.74 139.86,83.87 139.6,83.87 139.48,83.74 139.48,83.56 139.35,83.44 139.1,83.44 138.97,83.56 138.97,83.74 138.84,83.87 138.46,83.87 136.72,82.13 134.87,82.13 131.73,79 116.19,79 114.43,77.24 108.62,77.24
  BOTTOM w0.14: v1(156.42,81.65) 157.28,80.8 157.92,80.8 158.36,80.36 JDIMM4.35
DDR_B_D12: length 74.4
  TOP w0.102: JCPU1.AT11 v1(97.12,75.75)
  TOP w0.14: v1(156.21,84.85) 156.82,84.24 157.32,84.24 157.9,83.66 JDIMM3.24
  IN3 w0.089: v1(97.12,75.75) 97.12,75.91 98.47,77.25
  IN3 w0.127: v1(156.21,84.85) 155.4,85.66 153.29,85.66 150.52,88.43 144.32,88.43 143.68,89.06 139.02,89.06 136.62,86.66 134.04,86.66 129.48,82.1 113.25,82.1 112.66,81.52 107.25,81.52 104.81,79.08 102.27,79.08 102.13,78.94 100.15,78.94 98.47,77.25
  BOTTOM w0.14: v1(156.21,84.85) 156.67,84.39 157.43,84.39 157.86,83.96 JDIMM4.23
DDR_B_D13: length 74.1
  TOP w0.102: JCPU1.AR11 v1(97.12,74.75)
  TOP w0.14: v1(157.73,84.85) 158.32,84.26 JDIMM3.22
  IN3 w0.089: 100.38,77.25 100.12,77.25 99.9,77.03 99.88,77.03 98.75,75.9 98.75,75.56 98.31,75.12 97.9,75.12 97.53,74.75 v1(97.12,74.75)
  IN3 w0.127: v1(157.73,84.85) 157.73,84.4 157.62,84.29 153.13,84.29 149.99,87.42 149.08,87.42 148.95,87.3 148.95,86.99 148.82,86.87 148.57,86.87 148.44,86.99 148.44,87.3 148.31,87.42 146.23,87.42 146.1,87.3 146.1,87.14 145.97,87.02 145.72,87.02 145.59,87.14 145.59,87.3 145.47,87.42 145.21,87.42 145.08,87.3 145.08,87.14 144.96,87.02 144.7,87.02 144.58,87.14 144.58,87.3 144.45,87.42 138.8,87.42 136.23,84.85 133.93,84.85 130.17,81.08 114.36,81.08 113.17,79.89 107.05,79.89 105.22,78.07 102.69,78.07 102.55,77.93 101.06,77.93 100.38,77.25
  BOTTOM w0.14: v1(157.73,84.85) 158.02,84.56 JDIMM4.21
DDR_B_D14: length 79.1
  TOP w0.102: JCPU1.AM12 v1(96.12,71.75)
  TOP w0.14: JDIMM3.34 158.58,80.66 157.97,81.26 v1(157.97,81.65)
  IN3 w0.089: 105.93,77.25 105.69,77.01 103.51,77.01 103.37,76.87 101.9,76.87 101.34,76.31 100.91,76.31 100.57,75.97 100.57,75.66 100.05,75.14 99.99,75.14 99.73,74.88 99.73,74.82 99.16,74.25 99.1,74.25 98.69,73.84 98.69,73.78 98.25,73.34 97.18,73.34 96.63,72.79 96.63,72.45 96.12,71.94 v1(96.12,71.75)
  IN3 w0.127: v1(157.97,81.65) 156.93,82.69 154,82.69 153.49,83.2 152.7,83.2 150.34,85.55 145.93,85.55 145.81,85.68 145.81,85.81 145.68,85.94 145.43,85.94 145.3,85.81 145.3,85.68 145.17,85.55 144.92,85.55 144.79,85.68 144.79,85.81 144.66,85.94 144.41,85.94 144.28,85.81 144.28,85.52 144.16,85.39 143.9,85.39 143.78,85.52 143.78,85.81 143.65,85.94 143.39,85.94 143.27,85.81 143.27,85.51 143.14,85.39 142.89,85.39 142.76,85.51 142.76,85.81 142.63,85.94 142.38,85.94 142.25,85.81 142.25,85.47 142.12,85.35 141.87,85.35 141.74,85.47 141.74,85.81 141.62,85.94 141.36,85.94 141.24,85.81 141.24,85.52 141.11,85.39 140.85,85.39 140.73,85.52 140.73,85.72 140.6,85.85 140.35,85.85 140.22,85.72 140.22,85.51 140.09,85.38 139.84,85.38 139.71,85.51 139.71,85.71 139.58,85.84 139.33,85.84 139.2,85.71 139.2,85.47 139,85.27 138.43,85.27 136.85,83.68 134.98,83.68 131.31,80 114.81,80 113.05,78.24 106.92,78.24 105.93,77.25
  BOTTOM w0.14: v1(157.97,81.65) 157.97,81.4 158.41,80.96 JDIMM4.33
DDR_B_D15: length 79.8
  TOP w0.102: JCPU1.AN11 v1(97.12,72.75)
  TOP w0.14: v1(154.9,81.65) 154.9,81.6 153.66,80.36 JDIMM3.35
  IN3 w0.089: 106.41,77.25 105.99,76.83 103.58,76.83 103.44,76.69 101.97,76.69 101.41,76.13 100.98,76.13 100.75,75.9 100.75,75.35 100.54,75.14 100.54,74.64 100.21,74.31 99.78,74.31 99.55,74.07 99.55,73.65 99.24,73.34 98.84,73.34 98.66,73.16 97.39,73.16 97.12,72.89 v1(97.12,72.75)
  IN3 w0.127: v1(154.9,81.65) 154.91,81.65 155.04,81.78 155.04,82.18 154.91,82.31 153.9,82.31 153.35,82.86 152.56,82.86 150.88,84.54 150.4,84.54 150.27,84.67 150.27,85.05 150.14,85.18 149.89,85.18 149.76,85.05 149.76,84.67 149.64,84.54 148.92,84.54 148.8,84.67 148.8,85.06 148.67,85.19 148.41,85.19 148.29,85.06 148.29,84.67 148.16,84.54 147.2,84.54 147.07,84.67 147.07,85.09 146.95,85.21 146.69,85.21 146.56,85.09 146.56,84.67 146.44,84.54 146.18,84.54 146.06,84.67 146.06,85.09 145.93,85.21 145.68,85.21 145.55,85.09 145.55,84.67 145.42,84.54 145.17,84.54 145.04,84.67 145.04,85.09 144.91,85.21 144.66,85.21 144.53,85.09 144.53,84.67 144.41,84.54 138.18,84.54 136.44,82.8 134.59,82.8 131.46,79.67 114.95,79.67 113.19,77.91 107.06,77.91 106.41,77.25
  BOTTOM w0.14: v1(154.9,81.65) 153.7,80.45 152.99,80.45 152.6,80.06 JDIMM4.36
DDR_B_D16: length 65.8
  TOP w0.102: JCPU1.AR5 v1(103.12,74.75)
  TOP w0.14: JDIMM3.42 158.39,78.26 157.73,78.91 v1(157.73,79.61)
  IN3 w0.089: 108.62,75.76 107,75.76 106.89,75.65 106.18,75.65 105.7,75.17 103.54,75.17 v1(103.12,74.75)
  IN3 w0.127: v1(157.73,79.61) 157.86,79.61 157.98,79.48 157.98,78.8 157.86,78.67 155.91,78.67 155.46,79.13 152.42,79.13 150.4,81.15 147.67,81.15 147.53,81.3 137.92,81.3 137.32,80.69 135.46,80.69 132.33,77.56 116.79,77.56 114.98,75.76 108.62,75.76
  BOTTOM w0.14: v1(157.73,79.61) 157.67,79.55 157.67,78.69 157.8,78.56 JDIMM4.41
DDR_B_D17: length 68.3
  TOP w0.102: JCPU1.AR6 v1(102.12,74.75)
  TOP w0.14: JDIMM3.40 158.64,78.86 158.19,79.32 158.19,79.75 157.89,80.05 156.65,80.05 v1(156.21,79.61)
  IN3 w0.089: v1(102.12,74.75) 102.6,75.22 102.6,75.7 103.06,76.16 103.75,76.16 103.89,76.3 106.49,76.3 106.99,76.81 108.62,76.81
  IN3 w0.127: v1(156.21,79.61) 155.28,80.53 152.44,80.53 150.25,82.72 148,82.72 147.72,83 138.21,83 136.9,81.7 135.05,81.7 131.91,78.57 116.37,78.57 114.61,76.81 108.62,76.81
  BOTTOM w0.14: v1(156.21,79.61) 156.9,80.3 157.77,80.3 158.16,79.91 158.16,79.35 158.35,79.16 JDIMM4.39
DDR_B_D18: length 68.2
  TOP w0.102: v1(103.12,71.75) JCPU1.AM5
  TOP w0.14: v1(157.63,76.41) 157.63,75.73 158.11,75.25 159.39,75.25 JDIMM3.52
  IN3 w0.089: 108.62,73.67 107.83,73.67 107.28,73.12 106.93,73.12 106.71,72.91 106.71,72.45 106.41,72.15 103.52,72.15 v1(103.12,71.75)
  IN3 w0.127: v1(157.63,76.41) 158.24,76.41 158.36,76.28 158.36,75.91 158.24,75.78 152.76,75.78 150.08,78.46 147.54,78.46 147.29,78.71 145.48,78.71 144.92,78.15 144.02,78.15 143.89,78.28 143.89,78.58 143.76,78.71 141.16,78.71 140.59,78.15 138.66,78.15 137.05,76.54 134.26,76.54 133.19,75.47 117.65,75.47 115.85,73.67 108.62,73.67
  BOTTOM w0.14: v1(157.63,76.41) 157.5,76.41 157.37,76.28 157.37,75.46 157.5,75.33 158.07,75.33 158.45,74.96 JDIMM4.53
DDR_B_D19: length 70.6
  TOP w0.102: JCPU1.AM6 v1(102.12,71.75)
  TOP w0.14: JDIMM3.50 158.27,75.86 158.15,75.98 158.15,76.64 157.86,76.93 156.63,76.93 v1(156.11,76.41)
  IN3 w0.089: 108.62,74.68 107.58,74.68 107.24,74.33 106.87,74.33 106.51,73.98 106.51,73.52 106.31,73.32 102.12,73.32 101.74,72.93 101.74,72.13 v1(102.12,71.75)
  IN3 w0.127: 108.62,74.68 115.43,74.68 117.23,76.48 132.78,76.48 135.91,79.61 137.77,79.61 138.37,80.22 147.08,80.22 147.22,80.07 149.95,80.07 152.51,77.52 155.88,77.52 156.11,77.29 v1(156.11,76.41)
  BOTTOM w0.14: v1(156.11,76.41) 156.6,76.9 157.76,76.9 158.11,76.55 158.11,75.89 158.44,75.56 JDIMM4.51
DDR_B_D20: length 66.3
  TOP w0.102: v1(103.15,75.72) 102.65,75.28 JCPU1.AT5
  TOP w0.14: JDIMM3.41 153.64,78.56 v1(154.68,79.61)
  IN3 w0.089: 108.62,76.43 106.87,76.43 106.56,76.12 103.97,76.12 103.57,75.72 v1(103.15,75.72)
  IN3 w0.127: v1(154.68,79.61) 154.72,79.64 154.72,80.07 154.59,80.2 152.3,80.2 150.11,82.39 147.64,82.39 147.23,81.98 146.97,81.98 146.84,82.11 146.84,82.54 146.71,82.67 146.46,82.67 146.33,82.54 146.33,82.11 146.21,81.98 145.94,81.98 145.79,82.13 145.79,82.54 145.67,82.67 138.34,82.67 137.04,81.36 135.19,81.36 132.05,78.23 116.51,78.23 114.71,76.43 108.62,76.43
  BOTTOM w0.14: v1(154.68,79.61) 153.34,78.26 JDIMM4.42
DDR_B_D21: length 65.2
  TOP w0.102: JCPU1.AT6 v1(102.12,75.75)
  TOP w0.14: v1(153.16,79.61) 153.16,79.53 152.79,79.16 151.2,79.16 JDIMM3.39
  IN3 w0.089: v1(102.12,75.75) 102.12,75.48 101.68,75.04 101.68,74.48 101.86,74.31 102.45,74.31 102.68,74.53 102.68,74.97 102.94,75.23 103.25,75.23 103.37,75.35 105.62,75.35 106.11,75.83 106.52,75.83 106.78,76.09 108.62,76.09
  IN3 w0.127: v1(153.16,79.61) 152.42,79.61 149.97,82.05 147.78,82.05 147.37,81.65 145.58,81.65 145.46,81.77 145.46,82.21 145.33,82.33 145.08,82.33 144.95,82.21 144.95,81.77 144.82,81.65 144.57,81.65 144.44,81.77 144.44,82.21 144.31,82.33 138.48,82.33 137.18,81.03 135.33,81.03 132.19,77.89 116.65,77.89 114.85,76.09 108.62,76.09
  BOTTOM w0.14: JDIMM4.40 153.23,78.86 153.36,78.99 153.36,79.48 153.23,79.61 v1(153.16,79.61)
DDR_B_D22: length 69.3
  TOP w0.102: v1(103.12,72.75) JCPU1.AN5
  TOP w0.14: JDIMM3.53 152.38,74.96 153.15,75.73 153.9,75.73 v1(154.58,76.41)
  IN3 w0.089: v1(103.12,72.75) 103.51,73.14 106.38,73.14 106.69,73.44 106.69,73.9 106.94,74.15 107.31,74.15 107.5,74.34 108.62,74.34
  IN3 w0.127: v1(154.58,76.41) 154.72,76.41 154.85,76.53 154.85,77.05 154.72,77.18 152.37,77.18 150.42,79.13 147.81,79.13 147.56,79.38 147.21,79.38 147.08,79.51 147.08,79.73 146.96,79.86 146.7,79.86 146.58,79.73 146.58,79.51 146.45,79.38 146.19,79.38 146.07,79.51 146.07,79.73 145.94,79.86 145.69,79.86 145.56,79.73 145.56,79.51 145.43,79.38 145.18,79.38 145.05,79.51 145.05,79.73 144.92,79.86 144.67,79.86 144.54,79.73 144.54,79.51 144.42,79.38 140.36,79.38 140.24,79.25 140.24,78.95 140.11,78.83 139.85,78.83 139.73,78.95 139.73,79.25 139.6,79.38 139.35,79.38 139.22,79.25 139.22,78.95 139.09,78.83 138.84,78.83 138.71,78.95 138.71,79.25 138.58,79.38 138.01,79.38 137.91,79.28 136.05,79.28 132.92,76.14 117.37,76.14 115.57,74.34 108.62,74.34
  BOTTOM w0.14: v1(154.58,76.41) 154.63,76.41 154.76,76.28 154.76,75.73 154.63,75.6 153.8,75.6 153.46,75.26 JDIMM4.52
DDR_B_D23: length 68.5
  TOP w0.102: JCPU1.AN6 v1(102.12,72.75)
  TOP w0.14: JDIMM3.51 152.44,75.56 153.06,76.17 v1(153.06,76.41)
  IN3 w0.089: 108.62,74.01 107.91,74.01 107.2,73.3 106.85,73.3 106.54,72.98 106.54,72.53 106.34,72.32 102.54,72.32 v1(102.12,72.75)
  IN3 w0.127: 108.62,74.01 115.71,74.01 117.51,75.81 133.06,75.81 134.12,76.87 134.53,76.87 134.66,77 134.66,77.4 134.79,77.53 135.04,77.53 135.17,77.4 135.17,77 135.29,76.87 135.55,76.87 135.68,77 135.68,77.4 135.8,77.53 136.06,77.53 136.18,77.4 136.18,77 136.31,76.87 136.91,76.87 137.19,77.15 137.19,77.33 136.33,78.19 136.33,78.37 136.51,78.55 136.69,78.55 137.55,77.69 137.73,77.69 137.91,77.87 137.91,78.05 137.37,78.58 137.37,78.76 137.55,78.94 137.73,78.94 138.26,78.41 138.44,78.41 138.52,78.48 140.46,78.48 141.02,79.04 144.18,79.04 144.31,78.92 144.31,78.62 144.44,78.5 144.69,78.5 144.82,78.62 144.82,78.92 144.94,79.04 147.42,79.04 147.67,78.79 150.28,78.79 152.67,76.41 v1(153.06,76.41)
  BOTTOM w0.14: JDIMM4.50 153.29,75.86 153.41,75.99 153.41,76.28 153.29,76.41 v1(153.06,76.41)
DDR_B_D24: length 65.5
  TOP w0.102: v1(104.12,68.75) JCPU1.AJ4
  TOP w0.14: v1(157.65,74.37) 157.65,74.12 158.31,73.46 JDIMM3.58
  IN3 w0.089: 108.62,72.24 108.39,72.24 107.31,71.16 106,71.16 105.56,70.71 105.56,70.65 105.06,70.15 105,70.15 104.71,69.86 104.71,69.33 v1(104.12,68.75)
  IN3 w0.127: 108.62,72.24 116.45,72.24 118.25,74.04 133.79,74.04 134.86,75.1 137.64,75.1 138.73,76.19 150.18,76.19 152.8,73.57 158.17,73.57 158.3,73.7 158.3,74.24 158.17,74.37 v1(157.65,74.37)
  BOTTOM w0.14: JDIMM4.59 158.4,73.16 157.65,73.91 v1(157.65,74.37)
DDR_B_D25: length 66.8
  TOP w0.102: JCPU1.AK4 v1(104.12,69.75)
  TOP w0.14: v1(156.12,74.37) 156.67,74.92 157.79,74.92 158.12,74.59 158.12,74.25 158.32,74.06 JDIMM3.56
  IN3 w0.089: v1(104.12,69.75) 103.75,70.12 103.75,70.9 104.2,71.36 107.26,71.36 108.48,72.57 108.62,72.57
  IN3 w0.127: v1(156.12,74.37) 156.12,74.03 156,73.9 152.94,73.9 150.32,76.52 144.74,76.52 144.22,77.03 139.1,77.03 137.5,75.44 134.72,75.44 133.65,74.37 118.11,74.37 116.31,72.57 108.62,72.57
  BOTTOM w0.14: v1(156.12,74.37) 156.55,74.79 157.82,74.79 158.15,74.47 158.15,74.06 158.45,73.76 JDIMM4.57
DDR_B_D26: length 64.8
  TOP w0.089: v1(107.12,68.75) 107.16,68.75 107.29,68.62 107.29,68.41 107.16,68.28 JCPU1.AJ1
  TOP w0.14: v1(156.28,71.09) 156.28,69.99 156.41,69.86 JDIMM3.70
  IN3 w0.089: 108.62,70.24 107.13,68.75 v1(107.12,68.75)
  IN3 w0.127: 108.62,70.24 108.85,70.47 117.15,70.47 118.97,72.29 134.52,72.29 134.88,72.65 137.67,72.65 138.85,73.83 143.3,73.83 143.67,73.47 146.69,73.47 147.09,73.86 148.31,73.86 148.44,73.99 148.44,74.28 148.57,74.4 148.82,74.4 148.95,74.28 148.95,73.99 149.07,73.86 149.78,73.86 152.97,70.67 156.52,70.67 156.65,70.8 156.65,70.97 156.52,71.09 v1(156.28,71.09)
  BOTTOM w0.14: JDIMM4.69 156.04,70.16 155.91,70.29 155.91,70.97 156.04,71.09 v1(156.28,71.09)
DDR_B_D27: length 63.9
  TOP w0.102: v1(106.12,68.75) JCPU1.AJ2
  TOP w0.14: v1(157.81,71.09) 157.66,71.09 157.53,70.97 157.53,70.59 157.66,70.46 JDIMM3.68
  IN3 w0.089: 108.79,69.89 107.28,68.37 106.78,68.37 106.4,68.75 v1(106.12,68.75)
  IN3 w0.127: v1(157.81,71.09) 158.56,71.09 158.68,70.97 158.68,70.46 158.56,70.34 152.83,70.34 149.7,73.47 147.17,73.47 146.83,73.13 143.53,73.13 143.19,73.47 138.96,73.47 137.8,72.31 135.02,72.31 134.66,71.95 119.11,71.95 117.29,70.13 109.03,70.13 108.79,69.89
  BOTTOM w0.14: JDIMM4.67 158.09,70.76 157.87,70.55 157.69,70.55 157.45,70.79 157.45,70.97 157.58,71.09 v1(157.81,71.09)
DDR_B_D28: length 60.9
  TOP w0.102: JCPU1.AM1 v1(107.12,71.75)
  TOP w0.14: JDIMM3.59 152.61,73.16 153.09,73.65 153.09,74.34 v1(153.07,74.37)
  IN3 w0.089: 108.62,72.91 108.28,72.91 v1(107.12,71.75)
  IN3 w0.127: v1(153.07,74.37) 153.25,74.37 153.37,74.5 153.37,74.88 153.25,75.01 152.45,75.01 152.14,75.32 152.14,75.32 150.6,76.86 150.17,76.86 150.04,76.99 150.04,77.06 149.92,77.18 149.66,77.18 149.54,77.06 149.54,76.99 149.41,76.86 149.16,76.86 149.03,76.99 149.03,77.06 148.9,77.18 148.65,77.18 148.52,77.06 148.52,76.99 148.39,76.86 148.14,76.86 148.01,76.99 148.01,77.06 147.89,77.18 147.63,77.18 147.5,77.06 147.5,76.99 147.38,76.86 147.1,76.86 146.97,76.99 146.97,77.81 146.85,77.94 146.59,77.94 146.46,77.81 146.46,76.99 146.34,76.86 146.08,76.86 145.96,76.99 145.96,77.59 145.83,77.72 145.58,77.72 145.45,77.59 145.45,76.99 145.32,76.86 145.07,76.86 144.94,76.99 144.94,77.25 144.81,77.38 138.97,77.38 137.37,75.77 134.58,75.77 133.51,74.71 117.97,74.71 116.17,72.91 108.62,72.91
  BOTTOM w0.14: JDIMM4.58 152.49,73.46 153.07,74.04 v1(153.07,74.37)
DDR_B_D29: length 61.7
  TOP w0.102: v1(107.12,72.75) JCPU1.AN1
  TOP w0.14: JDIMM3.57 152.32,73.76 152.43,73.87 152.43,74.38 152.97,74.92 154.05,74.92 v1(154.6,74.37)
  IN3 w0.089: v1(107.12,72.75) 107.15,72.75 107.65,73.24 108.62,73.24
  IN3 w0.127: 108.62,73.24 116.03,73.24 117.83,75.04 133.37,75.04 134.44,76.11 137.23,76.11 138.83,77.71 145.09,77.71 145.66,78.28 147.04,78.28 147.8,77.52 150.41,77.52 152.58,75.35 154.43,75.35 154.6,75.18 v1(154.6,74.37)
  BOTTOM w0.14: JDIMM4.56 152.21,74.06 152.41,74.25 152.41,74.43 152.79,74.81 153.64,74.81 153.98,75.16 154.5,75.16 154.6,75.06 v1(154.6,74.37)
DDR_B_D30: length 63.5
  TOP w0.102: v1(153.19,71.09) 153.19,70.71 152.63,70.16 JDIMM3.69 ; v1(106.12,69.75) JCPU1.AK2
  IN3 w0.089: v1(106.12,69.75) 106.53,69.34 107.25,69.34 108.62,70.71
  IN3 w0.127: 108.62,70.71 108.71,70.8 117.01,70.8 118.83,72.62 134.38,72.62 134.75,73 135.27,73 135.39,73.12 135.39,73.54 135.52,73.67 135.78,73.67 135.9,73.54 135.9,73.11 136.03,72.98 136.33,72.98 136.46,73.11 136.46,73.56 136.59,73.69 136.84,73.69 136.97,73.56 136.97,73.11 137.09,72.98 137.35,72.98 137.48,73.11 137.48,73.56 137.6,73.69 138.23,73.69 138.71,74.16 143.89,74.16 144.01,74.04 144.01,73.93 144.14,73.8 144.43,73.8 144.56,73.93 144.56,74.48 144.69,74.61 144.94,74.61 145.07,74.48 145.07,73.93 145.19,73.8 145.45,73.8 145.58,73.93 145.58,74.61 145.7,74.74 145.96,74.74 146.08,74.61 146.08,73.93 146.21,73.8 146.51,73.8 146.64,73.93 146.64,74.61 146.77,74.74 149.63,74.74 150.59,73.78 153.19,71.18 v1(153.19,71.09)
  BOTTOM w0.102: JDIMM4.70 152.87,69.86 153.19,70.18 v1(153.19,71.09)
DDR_B_D31: length 65.7
  TOP w0.102: JCPU1.AK1 v1(107.12,69.75) ; JDIMM3.67 152.27,70.76 152.46,70.95 152.46,71.72 152.59,71.85 154.91,71.85 155.04,71.72 155.04,71.22 154.91,71.09 v1(154.74,71.09)
  IN3 w0.089: 108.62,71.14 108.57,71.14 107.18,69.75 v1(107.12,69.75)
  IN3 w0.127: 108.62,71.14 116.87,71.14 118.69,72.96 134.24,72.96 135.3,74.02 138.09,74.02 139.14,75.07 149.77,75.07 152.55,72.29 152.73,72.29 152.91,72.47 153.09,72.47 153.25,72.31 153.25,72.13 153.08,71.96 153.08,71.78 153.26,71.6 153.44,71.6 153.61,71.77 153.79,71.77 153.83,71.73 154.98,71.73 155.1,71.6 155.1,71.22 154.98,71.09 v1(154.74,71.09)
  BOTTOM w0.102: JDIMM4.68 152.22,70.46 152.56,70.8 152.56,71.05 153.79,72.29 154.89,72.29 155.01,72.16 155.01,71.22 154.89,71.09 v1(154.74,71.09)
DDR_B_D32: length 72.1
  TOP w0.102: JCPU1.L2 v1(106.12,49.75)
  TOP w0.14: v1(154.44,47.72) 154.54,47.72 154.67,47.84 154.67,49.2 154.54,49.33 153.31,49.33 152.88,49.76 JDIMM3.129
  IN3 w0.089: 108.62,48.38 107.64,49.36 106.51,49.36 v1(106.12,49.75)
  IN3 w0.127: v1(154.44,47.72) 154.6,47.72 154.99,47.33 154.99,47.18 154.74,46.93 154.49,46.93 154.13,47.3 153.74,47.3 153.59,47.14 153.59,46.75 153.44,46.6 151.4,46.6 151.27,46.47 151.27,45.65 151.15,45.52 150.37,45.52 150.25,45.64 150.25,45.8 150.37,45.92 150.64,45.92 150.77,46.05 150.77,46.47 150.64,46.6 150.38,46.6 150.26,46.47 150.26,46.34 150.13,46.21 149.88,46.21 149.75,46.34 149.75,46.47 149.62,46.6 149.37,46.6 149.24,46.47 149.24,46.35 149.11,46.22 148.86,46.22 148.73,46.35 148.73,46.47 148.61,46.6 148.17,46.6 148.1,46.53 148.1,46.13 147.97,46 147.97,45.92 148.13,45.76 148.13,45.59 148.01,45.48 147.85,45.48 147.7,45.63 147.6,45.63 146.67,44.7 146.67,44.51 144.95,42.78 139.52,42.78 139.03,42.29 135.83,42.29 135.66,42.46 135.66,43 135.52,43.14 135.09,43.14 134.62,42.67 134.62,42.44 134.46,42.29 116.8,42.29 111.3,47.79 109.21,47.79 108.62,48.38
  BOTTOM w0.14: v1(154.44,47.72) 154.44,49.27 154.24,49.46 151.2,49.46 JDIMM4.130
DDR_B_D33: length 70.9
  TOP w0.102: JCPU1.M2 v1(106.12,50.75)
  TOP w0.14: JDIMM3.130 157.36,49.46 155.96,48.06 v1(155.96,47.72)
  IN3 w0.089: 108.62,47.91 107.4,49.12 106.22,49.12 105.75,49.59 105.75,50.37 v1(106.12,50.75)
  IN3 w0.127: v1(155.96,47.72) 155.96,47.42 156.09,47.3 157.42,47.3 157.55,47.17 157.55,46.84 157.42,46.71 155.23,46.71 155.12,46.6 154.29,46.6 153.95,46.26 152.38,46.26 151.3,45.18 150.04,45.18 149.92,45.06 149.92,44.79 149.79,44.66 149.54,44.66 149.41,44.79 149.41,45.06 149.28,45.18 148.8,45.18 147.45,43.84 146.47,43.84 145.09,42.45 139.66,42.45 139.17,41.95 116.66,41.95 111.16,47.45 109.07,47.45 108.62,47.91
  BOTTOM w0.14: JDIMM4.129 157.71,49.76 155.96,48.01 v1(155.96,47.72)
DDR_B_D34: length 74.4
  TOP w0.102: JCPU1.L4 v1(104.12,49.75)
  TOP w0.14: JDIMM3.142 158.28,45.86 157.9,45.48 157.9,44.46 157.39,43.95 156.58,43.95 v1(155.91,44.63)
  IN3 w0.089: 108.62,46.38 108.51,46.38 108.5,46.38 108.45,46.38 107.5,47.33 104.91,47.33 104.67,47.56 104.67,47.98 104.28,48.37 103.97,48.37 103.75,48.59 103.75,49.37 v1(104.12,49.75)
  IN3 w0.127: v1(155.91,44.63) 155.48,45.06 152.7,45.06 150.4,42.76 146.92,42.76 145.04,40.87 144.35,40.87 144.23,40.74 144.23,40.38 144.1,40.25 143.85,40.25 143.72,40.38 143.72,40.74 143.59,40.87 139.86,40.87 139.74,40.74 139.74,40.35 139.61,40.23 139.36,40.23 139.23,40.35 139.23,40.74 139.1,40.87 138.85,40.87 138.72,40.74 138.72,40.35 138.59,40.23 138.34,40.23 138.21,40.35 138.21,40.74 138.09,40.87 137.83,40.87 137.71,40.74 137.71,40.35 137.58,40.23 137.32,40.23 137.2,40.35 137.2,40.74 137.07,40.87 136.82,40.87 136.69,40.74 136.69,40.35 136.56,40.23 136.31,40.23 136.18,40.35 136.18,40.74 136.05,40.87 116.21,40.87 110.71,46.38 108.62,46.38
  BOTTOM w0.14: v1(155.91,44.63) 156.41,44.13 157.69,44.13 157.97,44.41 157.97,45.16 158.37,45.56 JDIMM4.143
DDR_B_D35: length 73.1
  TOP w0.102: JCPU1.M4 103.59,51.24 v1(104.08,50.75)
  TOP w0.14: JDIMM3.140 158.34,46.46 157.43,45.55 v1(157.43,44.63)
  IN3 w0.089: v1(104.08,50.75) 103.71,51.12 102.97,51.12 102.57,50.72 102.57,48.52 102.97,48.12 103.28,48.12 103.53,47.87 103.53,47.56 103.97,47.12 104.11,47.12 104.5,46.74 104.5,46.59 104.9,46.19 107.34,46.19 108.26,45.26 108.62,45.26
  IN3 w0.127: v1(157.43,44.63) 156.31,43.51 152.88,43.51 150.4,41.02 146.85,41.02 144.34,38.5 139.27,38.5 138.55,39.22 123.47,39.22 122.83,39.87 115.8,39.87 110.4,45.26 108.62,45.26
  BOTTOM w0.14: v1(157.43,44.63) 157.43,45.64 157.96,46.16 159.4,46.16 JDIMM4.141
DDR_B_D36: length 68.3
  TOP w0.102: JCPU1.L1 v1(107.12,49.75)
  TOP w0.14: JDIMM3.131 152.31,49.16 152.91,48.56 v1(152.91,47.72)
  IN3 w0.089: 108.62,48.85 107.73,49.75 v1(107.12,49.75)
  IN3 w0.127: 108.62,48.85 109.35,48.13 111.44,48.13 116.94,42.62 134.1,42.62 134.99,43.51 136.23,43.51 136.35,43.38 136.35,42.75 136.48,42.62 136.73,42.62 136.86,42.75 136.86,43.38 136.99,43.51 137.24,43.51 137.37,43.38 137.37,42.75 137.5,42.62 137.75,42.62 137.88,42.75 137.88,43.38 138,43.51 138.26,43.51 138.38,43.38 138.38,42.75 138.51,42.62 138.77,42.62 138.89,42.75 138.89,43.38 139.02,43.51 139.27,43.51 139.4,43.38 139.4,43.25 139.53,43.12 139.78,43.12 139.91,43.25 139.91,43.38 140.04,43.51 140.29,43.51 140.42,43.38 140.42,43.25 140.54,43.12 140.8,43.12 140.92,43.25 140.92,43.38 141.05,43.51 141.31,43.51 141.43,43.38 141.43,43.25 141.56,43.12 141.81,43.12 141.94,43.25 141.94,43.38 142.07,43.51 142.32,43.51 142.45,43.38 142.45,43.25 142.58,43.12 142.83,43.12 142.96,43.25 142.96,43.38 143.08,43.51 143.34,43.51 143.46,43.38 143.46,43.25 143.59,43.12 143.85,43.12 143.97,43.25 143.97,43.38 144.1,43.51 144.53,43.51 144.78,43.76 144.96,43.76 145.12,43.61 145.3,43.61 145.48,43.79 145.48,43.97 145.32,44.12 145.32,44.3 145.5,44.48 145.68,44.48 145.84,44.33 146.02,44.33 146.2,44.51 146.2,44.69 146.04,44.84 146.04,45.02 146.22,45.2 146.4,45.2 146.46,45.14 146.64,45.14 146.82,45.32 146.82,45.5 146.76,45.56 146.76,45.74 146.94,45.92 147.12,45.92 147.18,45.86 147.36,45.86 147.54,46.04 147.54,46.22 147.48,46.28 147.48,46.46 147.95,46.93 150.62,46.93 150.75,47.06 150.75,47.45 150.87,47.57 151.13,47.57 151.25,47.45 151.25,47.06 151.38,46.93 151.63,46.93 151.76,47.06 151.76,47.45 151.89,47.57 152.14,47.57 152.27,47.45 152.27,47.06 152.4,46.93 152.78,46.93 152.91,47.06 v1(152.91,47.72)
  BOTTOM w0.14: JDIMM4.132 152.48,48.86 152.91,48.43 v1(152.91,47.72)
DDR_B_D37: length 68
  TOP w0.102: JCPU1.M1 v1(107.12,50.75)
  TOP w0.14: JDIMM3.132 158.33,48.86 157.99,48.52 157.99,48.22 157.74,47.97 157.71,47.97 157.48,47.74 v1(157.48,47.72)
  IN3 w0.089: v1(107.12,50.75) 107.2,50.75 108.76,49.19
  IN3 w0.127: v1(157.48,47.72) 157.48,47.7 157.61,47.57 159.48,47.57 159.61,47.7 159.61,48.02 159.48,48.14 152.75,48.14 152.51,47.91 150.48,47.91 149.84,47.27 147.73,47.27 144.31,43.85 139.11,43.85 138.98,43.97 138.98,44.05 138.86,44.18 138.6,44.18 138.48,44.05 138.48,43.97 138.35,43.85 138.1,43.85 137.97,43.97 137.97,44.05 137.84,44.18 137.59,44.18 137.46,44.05 137.46,43.97 137.33,43.85 137.08,43.85 136.95,43.97 136.95,44.05 136.83,44.18 136.57,44.18 136.44,44.05 136.44,43.97 136.32,43.85 136.06,43.85 135.94,43.97 135.94,44.05 135.81,44.18 135.56,44.18 135.43,44.05 135.43,43.97 135.3,43.85 134.85,43.85 133.96,42.96 117.08,42.96 111.57,48.46 109.49,48.46 108.76,49.19
  BOTTOM w0.14: JDIMM4.131 158.48,49.16 157.48,48.16 v1(157.48,47.72)
DDR_B_D38: length 72.7
  TOP w0.102: JCPU1.L5 v1(103.12,49.75)
  TOP w0.14: v1(152.86,44.63) 153.13,44.9 153.13,45.25 152.82,45.56 JDIMM3.143
  IN3 w0.089: v1(103.12,49.75) 103.57,49.3 103.57,48.52 103.89,48.19 104.2,48.19 104.5,47.9 104.5,47.49 104.83,47.15 107.32,47.15 108.55,45.93 108.62,45.93
  IN3 w0.127: v1(152.86,44.63) 150.66,42.42 147.06,42.42 144.53,39.89 135.78,39.89 135.66,40.02 135.66,40.41 135.53,40.54 134.76,40.54 134.63,40.41 134.63,40.02 134.5,39.89 134.25,39.89 134.12,40.02 134.12,40.41 134,40.54 133.74,40.54 133.62,40.41 133.62,40.02 133.49,39.89 133.23,39.89 133.11,40.02 133.11,40.41 132.98,40.54 132.73,40.54 132.6,40.41 132.6,40.02 132.47,39.89 132.22,39.89 132.09,40.02 132.09,40.41 131.96,40.54 131.71,40.54 131.58,40.41 131.58,40.02 131.46,39.89 131.2,39.89 131.08,40.02 131.08,40.41 130.95,40.54 130.69,40.54 130.57,40.41 130.57,40.02 130.44,39.89 130.19,39.89 130.06,40.02 130.06,40.41 129.93,40.54 129.68,40.54 129.55,40.41 129.55,40.02 129.42,39.89 129.17,39.89 129.04,40.02 129.04,40.41 128.92,40.54 128.66,40.54 128.54,40.41 128.54,40.02 128.41,39.89 128.15,39.89 128.03,40.02 128.03,40.41 127.9,40.54 127.65,40.54 127.52,40.41 127.52,40.02 127.39,39.89 127.14,39.89 127.01,40.02 127.01,40.41 126.88,40.54 126.63,40.54 126.5,40.41 126.5,40.02 126.38,39.89 126.12,39.89 126,40.02 126,40.41 125.87,40.54 125.61,40.54 125.49,40.41 125.49,40.02 125.36,39.89 125.11,39.89 124.98,40.02 124.98,40.41 124.85,40.54 116.07,40.54 110.68,45.93 108.62,45.93
  BOTTOM w0.14: v1(152.86,44.63) 152.86,45.16 152.16,45.86 JDIMM4.142
DDR_B_D39: length 74.6
  TOP w0.102: JCPU1.M5 v1(103.12,50.75)
  TOP w0.14: v1(154.39,44.63) 154.39,44.74 154.21,44.92 154,44.92 152.76,46.16 JDIMM3.141
  IN3 w0.089: v1(103.12,50.75) 102.93,50.75 102.75,50.57 102.75,48.59 103.04,48.3 103.54,48.3 103.71,48.13 103.71,47.63 104.04,47.3 104.23,47.3 104.23,47.3 104.44,47.3 104.67,47.06 104.67,46.66 104.97,46.37 107.58,46.37 108.35,45.6 108.62,45.6
  IN3 w0.127: 108.62,45.6 110.54,45.6 115.93,40.2 123.36,40.2 123.49,40.07 123.49,39.68 123.61,39.56 123.87,39.56 123.99,39.68 123.99,40.07 124.12,40.2 124.37,40.2 124.5,40.07 124.5,39.68 124.63,39.56 144.67,39.56 147.2,42.09 147.89,42.09 148.01,41.96 148.01,41.48 148.14,41.36 148.39,41.36 148.52,41.48 148.52,41.96 148.65,42.09 148.9,42.09 149.03,41.96 149.03,41.48 149.16,41.36 149.41,41.36 149.54,41.48 149.54,41.96 149.66,42.09 149.92,42.09 150.04,41.96 150.04,41.65 150.17,41.52 150.43,41.52 150.55,41.65 150.55,41.96 150.68,42.09 150.99,42.09 152.74,43.84 154.57,43.84 154.69,43.97 154.69,44.5 154.57,44.63 v1(154.39,44.63)
  BOTTOM w0.14: v1(154.39,44.63) 154.39,45.16 153.08,46.47 151.21,46.47 JDIMM4.140
DDR_B_D40: length 77.9
  TOP w0.102: v1(100.12,45.75) JCPU1.G7
  TOP w0.14: v1(156.57,42.32) 155.99,41.74 153.37,41.74 152.64,42.48 152.64,43.24 152.12,43.76 JDIMM3.149
  IN3 w0.089: v1(100.12,45.75) 101.67,45.75 102.52,44.89 102.52,44.43 102.83,44.12 106.67,44.12 106.97,43.82 108.62,43.82
  IN3 w0.127: 108.62,43.82 109.8,43.82 115.84,37.78 137.96,37.78 139.28,36.46 144.33,36.46 146.59,38.72 150.13,38.72 152.91,41.5 156.41,41.5 156.57,41.65 v1(156.57,42.32)
  BOTTOM w0.14: v1(156.57,42.32) 156.13,41.89 153.39,41.89 153.07,42.21 153.07,42.99 152,44.06 JDIMM4.148
DDR_B_D41: length 76.7
  TOP w0.102: v1(99.12,47.75) JCPU1.J8
  TOP w0.14: JDIMM3.146 158.63,44.66 158.17,44.21 158.17,43.98 157.64,43.44 156.17,43.44 v1(155.04,42.32)
  IN3 w0.089: 108.62,44.49 108.3,44.49 107.9,44.89 106.8,44.89 106.54,45.15 102.77,45.15 101.55,46.37 99.97,46.37 99.75,46.59 99.75,47.12 v1(99.12,47.75)
  IN3 w0.127: v1(155.04,42.32) 154.62,42.74 153.2,42.74 150.71,40.25 147.17,40.25 144.66,37.74 138.95,37.74 138.24,38.45 122.57,38.45 122.44,38.58 122.44,38.97 122.31,39.1 122.06,39.1 121.93,38.97 121.93,38.58 121.8,38.45 121.55,38.45 121.42,38.58 121.42,38.97 121.3,39.1 121.04,39.1 120.91,38.97 120.91,38.58 120.79,38.45 120.53,38.45 120.41,38.58 120.41,38.97 120.28,39.1 120.03,39.1 119.9,38.97 119.9,38.83 119.77,38.71 119.52,38.71 119.39,38.83 119.39,38.97 119.26,39.1 115.48,39.1 110.08,44.49 108.62,44.49
  BOTTOM w0.14: v1(155.04,42.32) 155.94,43.22 157.41,43.22 158.55,44.36 JDIMM4.147
DDR_B_D42: length 74.1
  TOP w0.102: v1(99.12,45.75) JCPU1.G8
  TOP w0.14: JDIMM3.160 158.67,40.46 157.69,39.48 v1(157.69,39.26)
  IN3 w0.089: v1(99.12,45.75) 99.12,45.53 99.72,44.93 99.72,44.58 99.96,44.35 101.32,44.35 101.71,43.95 101.71,43.6 101.96,43.34 102.37,43.34 102.68,43.04 102.68,42.61 102.93,42.35 108.62,42.35
  IN3 w0.127: 108.62,42.35 109.75,42.35 115.4,36.7 137.51,36.7 139.31,34.91 144.3,34.91 146.32,36.93 146.66,36.93 147.19,36.4 147.57,36.4 148.81,37.64 150.58,37.64 152.65,39.71 155.93,39.71 156.14,39.93 158.26,39.93 158.36,39.83 158.36,39.36 158.26,39.26 v1(157.69,39.26)
  BOTTOM w0.14: v1(157.69,39.26) 157.69,40.02 158.43,40.75 159.39,40.75 JDIMM4.159
DDR_B_D43: length 75.8
  TOP w0.102: v1(98.12,45.75) JCPU1.G9
  TOP w0.14: v1(156.15,39.27) 156.57,39.69 157.23,39.69 158.61,41.06 JDIMM3.158
  IN3 w0.089: 108.62,41.03 108.12,41.03 107.98,41.16 102.93,41.16 102.52,41.56 102.52,41.88 102.22,42.17 101.84,42.17 101.51,42.5 101.51,42.89 101.24,43.16 99.88,43.16 99.53,43.5 99.53,43.87 99.24,44.16 98.89,44.16 98.54,44.51 98.54,44.97 98.31,45.2 98.31,45.56 v1(98.12,45.75)
  IN3 w0.127: v1(156.15,39.27) 155.28,38.4 152.76,38.4 151,36.63 149.23,36.63 147.98,35.39 147.51,35.39 146.92,34.8 145.18,33.06 139.18,33.06 137.18,35.06 134.58,35.06 133.94,35.7 114.98,35.7 109.65,41.03 108.62,41.03
  BOTTOM w0.14: JDIMM4.157 158.4,41.36 156.32,39.28 156.15,39.28 v1(156.15,39.27)
DDR_B_D44: length 73.5
  TOP w0.102: v1(100.12,47.75) JCPU1.J7
  TOP w0.14: v1(161.58,43.45) 160.97,44.06 JDIMM3.148
  IN3 w0.089: v1(100.12,47.75) 100.56,47.31 101.42,47.31 101.62,47.1 101.62,46.72 103.02,45.32 106.61,45.32 106.87,45.07 108.03,45.07 108.27,44.83 108.62,44.83
  IN3 w0.127: 108.62,44.83 110.22,44.83 115.62,39.43 122.65,39.43 123.29,38.79 138.37,38.79 139.09,38.07 144.52,38.07 147.03,40.59 150.58,40.59 153.06,43.08 160.35,43.08 160.39,43.04 161.17,43.04 v1(161.58,43.45)
  BOTTOM w0.14: v1(161.58,43.45) 161.12,43.9 160.51,43.9 160.37,43.76 JDIMM4.149
DDR_B_D45: length 75
  TOP w0.102: v1(98.12,47.75) JCPU1.J9
  TOP w0.14: v1(153.52,42.32) 153.52,42.94 152.1,44.36 JDIMM3.147
  IN3 w0.089: v1(98.12,47.75) 98.59,47.28 99.12,47.28 99.57,46.83 99.57,46.52 99.89,46.19 101.47,46.19 102.7,44.97 102.7,44.51 102.91,44.3 107.68,44.3 107.82,44.16 108.62,44.16
  IN3 w0.127: 108.62,44.16 109.94,44.16 115.34,38.76 115.74,38.76 115.86,38.64 115.86,38.29 115.99,38.16 116.24,38.16 116.37,38.29 116.37,38.64 116.5,38.76 116.75,38.76 116.88,38.64 116.88,38.29 117.01,38.16 117.26,38.16 117.39,38.29 117.39,38.64 117.51,38.76 117.76,38.76 117.89,38.64 117.89,38.25 118.01,38.12 118.27,38.12 118.39,38.25 118.39,38.64 118.52,38.76 118.77,38.76 118.9,38.64 118.9,38.25 119.03,38.12 138.1,38.12 138.81,37.4 144.8,37.4 146.45,39.06 146.82,39.06 146.95,39.18 146.95,39.56 147.08,39.69 147.33,39.69 147.46,39.56 147.46,39.18 147.59,39.06 147.84,39.06 147.97,39.18 147.97,39.27 148.09,39.39 148.35,39.39 148.48,39.27 148.48,39.18 148.6,39.06 148.86,39.06 148.98,39.18 148.98,39.27 149.11,39.39 149.36,39.39 149.49,39.27 149.49,39.18 149.62,39.06 149.99,39.06 153.26,42.32 v1(153.52,42.32)
  BOTTOM w0.14: JDIMM4.146 152.13,44.66 153.52,43.27 v1(153.52,42.32)
DDR_B_D46: length 75.9
  TOP w0.102: v1(97.12,45.75) JCPU1.G10
  TOP w0.14: v1(154.63,39.27) 152.54,41.36 JDIMM3.157
  IN3 w0.089: v1(97.12,45.75) 97.51,46.14 98.28,46.14 98.51,45.91 98.51,45.27 98.71,45.07 98.71,44.61 98.98,44.35 99.42,44.35 99.72,44.04 99.72,43.58 99.96,43.35 101.35,43.35 101.71,42.99 101.71,42.56 101.91,42.35 102.32,42.35 102.7,41.97 102.7,41.64 102.98,41.36 108.62,41.36
  IN3 w0.127: 108.62,41.36 109.79,41.36 115.12,36.03 136.68,36.03 139.31,33.39 145.04,33.39 147.37,35.73 147.84,35.73 149.09,36.97 150.86,36.97 152.63,38.74 154.1,38.74 v1(154.63,39.27)
  BOTTOM w0.14: v1(154.63,39.27) 154.57,39.27 153.75,40.09 153.35,40.09 152.38,41.06 JDIMM4.158
DDR_B_D47: length 74.4
  TOP w0.102: v1(97.12,47.75) JCPU1.J10
  TOP w0.14: v1(153.09,39.27) 153.09,40.09 152.43,40.76 JDIMM3.159
  IN3 w0.089: v1(97.12,47.75) 97.7,47.17 97.7,46.47 97.85,46.31 98.36,46.31 98.71,45.96 98.71,45.4 98.99,45.12 99.28,45.12 99.53,44.87 99.53,44.5 99.88,44.16 101.25,44.16 101.51,43.9 101.51,43.52 101.89,43.14 102.29,43.14 102.5,42.94 102.5,42.53 102.88,42.15 108.14,42.15 108.27,42.02 108.62,42.02
  IN3 w0.127: 108.62,42.02 109.61,42.02 115.26,36.37 137.37,36.37 139.17,34.57 144.48,34.57 144.84,34.94 145.02,34.94 145.47,34.48 145.65,34.48 145.83,34.66 145.83,34.84 145.38,35.3 145.38,35.48 145.59,35.69 145.77,35.69 146.22,35.23 146.4,35.23 146.58,35.41 146.58,35.59 146.13,36.05 146.13,36.22 146.31,36.4 146.49,36.4 146.94,35.95 147.12,35.95 147.23,36.06 147.7,36.06 148.95,37.31 150.72,37.31 152.68,39.27 v1(153.09,39.27)
  BOTTOM w0.14: JDIMM4.160 152.19,40.46 153.09,39.56 v1(153.09,39.27)
DDR_B_D48: length 80.3
  TOP w0.102: v1(99.12,39.75) JCPU1.A8
  TOP w0.14: JDIMM3.163 152.2,39.56 153.94,37.82 154.12,37.82 v1(154.8,37.13)
  IN3 w0.089: v1(99.12,39.75) 99.52,40.14 101.3,40.14 101.53,39.91 101.53,39.81 102.14,39.19 108.15,39.19 108.39,39.43 108.62,39.43
  IN3 w0.127: 108.62,39.43 109.21,39.43 114.38,34.26 115.51,34.26 115.64,34.13 115.64,33.73 115.77,33.6 116.02,33.6 116.15,33.73 116.15,34.13 116.28,34.26 116.53,34.26 116.66,34.13 116.66,33.73 116.78,33.6 117.04,33.6 117.17,33.73 117.17,34.13 117.29,34.26 117.55,34.26 117.67,34.13 117.67,33.73 117.8,33.6 118.05,33.6 118.18,33.73 118.18,34.13 118.31,34.26 118.56,34.26 118.69,34.13 118.69,33.73 118.82,33.6 119.07,33.6 119.2,33.73 119.2,34.13 119.32,34.26 119.58,34.26 119.71,34.13 119.71,33.73 119.83,33.6 120.09,33.6 120.21,33.73 120.21,34.13 120.34,34.26 120.59,34.26 120.72,34.13 120.72,33.73 120.85,33.6 133.19,33.6 133.21,33.62 133.62,33.62 133.75,33.49 133.75,33.17 133.88,33.04 134.13,33.04 134.26,33.17 134.26,33.49 134.38,33.62 134.64,33.62 134.76,33.49 134.76,33.2 134.89,33.08 135.15,33.08 135.27,33.2 135.27,33.49 135.4,33.62 136.46,33.62 136.59,33.49 136.59,32.84 136.77,32.66 136.95,32.66 137.16,32.86 137.34,32.86 139.17,31.03 145.18,31.03 147.07,32.91 149.3,32.91 153.06,36.66 154.8,36.66 154.92,36.79 154.92,37.01 v1(154.8,37.13)
  BOTTOM w0.14: JDIMM4.164 151.21,39.25 152.22,39.25 153.1,38.37 153.87,38.37 154.8,37.43 v1(154.8,37.13)
DDR_B_D49: length 79.7
  TOP w0.102: v1(99.12,40.75) JCPU1.B8
  TOP w0.14: v1(153.27,37.13) 153.53,37.38 153.53,37.69 152.26,38.95 151.21,38.95 JDIMM3.165
  IN3 w0.089: v1(99.12,40.75) 99.52,40.35 101.38,40.35 101.58,40.14 102.4,40.14 102.62,39.91 102.62,39.65 102.9,39.37 107.9,39.37 108.45,39.92 108.62,39.92
  IN3 w0.127: 108.62,39.92 109.19,39.92 114.52,34.6 121.05,34.6 121.18,34.47 121.18,34.06 121.3,33.94 121.56,33.94 121.69,34.06 121.69,34.47 121.81,34.6 122.07,34.6 122.19,34.47 122.19,34.06 122.32,33.94 122.57,33.94 122.7,34.06 122.7,34.47 122.83,34.6 123.08,34.6 123.21,34.47 123.21,34.06 123.34,33.94 123.59,33.94 123.72,34.06 123.72,34.47 123.84,34.6 124.1,34.6 124.23,34.47 124.23,34.06 124.35,33.94 124.61,33.94 124.73,34.06 124.73,34.47 124.86,34.6 125.11,34.6 125.24,34.47 125.24,34.06 125.37,33.94 125.62,33.94 125.75,34.06 125.75,34.47 125.88,34.6 126.13,34.6 126.26,34.47 126.26,34.06 126.38,33.94 126.64,33.94 126.77,34.06 126.77,34.47 126.89,34.6 127.15,34.6 127.27,34.47 127.27,34.06 127.4,33.94 127.65,33.94 127.78,34.06 127.78,34.47 127.91,34.6 128.16,34.6 128.29,34.47 128.29,34.06 128.42,33.94 128.67,33.94 128.8,34.06 128.8,34.47 128.92,34.6 130.56,34.6 130.68,34.47 130.68,34.06 130.81,33.94 131.07,33.94 131.19,34.06 131.19,34.47 131.32,34.6 131.57,34.6 131.7,34.47 131.7,34.06 131.83,33.94 132.08,33.94 132.21,34.06 132.21,34.47 132.34,34.6 133.48,34.6 133.73,34.35 133.73,34.02 133.8,33.95 136.72,33.95 139.31,31.36 144.01,31.36 144.14,31.49 144.14,31.82 144.26,31.95 144.52,31.95 144.64,31.82 144.64,31.49 144.77,31.36 145.02,31.36 145.15,31.49 145.15,31.82 145.28,31.95 145.64,31.95 146.93,33.25 149.16,33.25 153.05,37.13 v1(153.27,37.13)
  BOTTOM w0.14: v1(153.27,37.13) 153.27,37.58 152.19,38.66 JDIMM4.166
DDR_B_D50: length 79
  TOP w0.102: v1(98.12,39.75) JCPU1.A9
  TOP w0.14: JDIMM3.176 158.54,35.66 157.87,34.99 157.87,34.01 v1(157.68,33.82)
  IN3 w0.089: 101.25,38.77 101.02,39 98.69,39 98.12,39.57 v1(98.12,39.75)
  IN3 w0.127: 101.25,38.77 101.67,38.35 108.77,38.35 114.59,32.52 115.86,32.52 115.99,32.4 115.99,32.23 116.12,32.1 116.37,32.1 116.5,32.23 116.5,32.4 116.63,32.52 116.88,32.52 117.01,32.4 117.01,32.23 117.13,32.1 117.39,32.1 117.52,32.23 117.52,32.4 117.64,32.52 118,32.52 118.12,32.4 118.12,32.23 118.25,32.1 118.51,32.1 118.63,32.23 118.63,32.4 118.76,32.52 119.01,32.52 119.14,32.4 119.14,32.23 119.27,32.1 119.52,32.1 119.65,32.23 119.65,32.4 119.78,32.52 120.03,32.52 120.16,32.4 120.16,32.23 120.28,32.1 120.54,32.1 120.66,32.23 120.66,32.4 120.79,32.52 121.05,32.52 121.17,32.4 121.17,32.23 121.3,32.1 133.29,32.1 133.82,31.57 137.1,31.57 137.36,31.31 137.36,31.13 137.16,30.93 137.16,30.75 137.34,30.57 137.52,30.57 137.72,30.77 137.9,30.77 138.08,30.59 138.08,30.41 137.88,30.21 137.88,30.03 138.06,29.85 138.24,29.85 138.44,30.05 138.62,30.05 138.8,29.87 138.8,29.69 138.6,29.49 138.6,29.31 138.78,29.13 138.96,29.13 139.16,29.33 139.34,29.33 139.49,29.19 144.87,29.19 147.03,31.34 149.49,31.34 153.28,35.13 156.94,35.13 157.68,34.38 v1(157.68,33.82)
  BOTTOM w0.14: JDIMM4.177 158.52,35.36 157.68,34.52 v1(157.68,33.82)
DDR_B_D51: length 81.6
  TOP w0.102: v1(98.12,40.75) JCPU1.B9
  TOP w0.14: JDIMM3.174 158.3,36.26 157.46,35.42 157.46,34.99 156.96,34.48 156.82,34.48 v1(156.16,33.82)
  IN3 w0.089: 98.44,38.77 97.72,39.49 97.72,39.91 98.12,40.31 v1(98.12,40.75)
  IN3 w0.127: 98.44,38.77 98.53,38.68 100.86,38.68 101.71,37.84 108.8,37.84 114.87,31.77 128.05,31.77 128.17,31.64 128.17,31.37 128.3,31.24 128.55,31.24 128.68,31.37 128.68,31.64 128.81,31.77 129.06,31.77 129.19,31.64 129.19,31.37 129.32,31.24 129.57,31.24 129.7,31.37 129.7,31.64 129.82,31.77 130.08,31.77 130.21,31.64 130.21,31.37 130.33,31.24 130.59,31.24 130.71,31.37 130.71,31.64 130.84,31.77 131.09,31.77 131.22,31.64 131.22,31.37 131.35,31.24 131.6,31.24 131.73,31.37 131.73,31.64 131.86,31.77 132.11,31.77 132.24,31.64 132.24,31.37 132.36,31.24 132.62,31.24 132.75,31.37 132.75,31.64 132.87,31.77 133.13,31.77 133.25,31.64 133.25,31.37 133.38,31.24 136.19,31.24 139.37,28.06 144.29,28.06 147.23,31.01 149.63,31.01 153.42,34.8 155.98,34.8 156.16,34.61 v1(156.16,33.82)
  BOTTOM w0.14: v1(156.16,33.82) 158.3,35.96 JDIMM4.175
DDR_B_D52: length 82.9
  TOP w0.102: v1(99.12,42.75) JCPU1.D8
  TOP w0.14: JDIMM3.164 158.36,39.26 157.59,38.49 156.46,38.49 156.33,38.36 v1(156.33,37.13)
  IN3 w0.089: v1(99.12,42.75) 99.12,42.47 99.62,41.97 99.62,41.61 99.9,41.34 101.33,41.34 101.63,41.03 101.63,40.55 101.82,40.36 102.51,40.36 102.7,40.17 108.1,40.17 108.19,40.26 108.62,40.26
  IN3 w0.127: 108.62,40.26 109.33,40.26 114.66,34.93 133.62,34.93 134.26,34.29 136.86,34.29 138.86,32.29 145.5,32.29 147.73,34.52 149.97,34.52 150.09,34.64 150.09,34.82 149.45,35.46 149.45,35.64 149.63,35.82 149.81,35.82 150.45,35.18 150.63,35.18 152.99,37.55 158.95,37.55 159.08,37.42 159.08,36.61 158.95,36.49 156.97,36.49 v1(156.33,37.13)
  BOTTOM w0.14: v1(156.33,37.13) 156.33,37.61 156.88,38.15 157.2,38.15 158.17,39.13 158.17,39.22 158.52,39.56 JDIMM4.163
DDR_B_D53: length 81.1
  TOP w0.102: v1(99.12,43.75) JCPU1.E8
  TOP w0.14: v1(161.58,38.14) 161.58,38.49 161.41,38.66 JDIMM3.166
  IN3 w0.089: v1(99.12,43.75) 99.12,43.46 99.72,42.86 99.72,42.58 99.96,42.35 101.28,42.35 101.61,42.02 101.61,41.67 102.04,41.23 102.4,41.23 102.68,40.96 102.68,40.52 102.83,40.37 107.22,40.37 107.45,40.59 108.62,40.59
  IN3 w0.127: 108.62,40.59 109.47,40.59 114.8,35.27 133.76,35.27 134.4,34.62 137,34.62 139,32.63 145.36,32.63 147.52,34.78 147.52,34.79 147.69,34.96 148.16,34.96 149.41,36.2 151.17,36.2 152.85,37.88 155.37,37.88 156.06,38.57 162.16,38.57 162.29,38.44 162.29,36.66 162.19,36.56 161.68,36.56 161.58,36.66 v1(161.58,38.14)
  BOTTOM w0.14: JDIMM4.165 160.75,38.96 v1(161.58,38.14)
DDR_B_D54: length 82.5
  TOP w0.102: v1(98.12,42.75) JCPU1.D9
  TOP w0.14: v1(153.09,33.81) 153.26,33.97 153.26,34.33 152.23,35.36 JDIMM3.177
  IN3 w0.089: v1(98.12,42.75) 97.96,42.75 97.41,42.19 96.85,42.19 96.67,42.02 96.67,39.64 97.19,39.13 97.34,39.13 97.7,38.77
  IN3 w0.127: v1(153.09,33.81) 152.91,33.81 149.77,30.67 147.86,30.67 147.74,30.54 147.74,29.97 147.61,29.84 147.32,29.84 147.06,30.1 146.8,30.1 144.39,27.69 139.26,27.69 136.05,30.9 127.85,30.9 127.72,31.03 127.72,31.31 127.59,31.43 127.34,31.43 127.21,31.31 127.21,31.03 127.08,30.9 126.83,30.9 126.7,31.03 126.7,31.31 126.58,31.43 126.32,31.43 126.2,31.31 126.2,31.03 126.07,30.9 125.81,30.9 125.69,31.03 125.69,31.31 125.56,31.43 125.31,31.43 125.18,31.31 125.18,31.03 125.05,30.9 124.8,30.9 124.67,31.03 124.67,31.31 124.54,31.43 124.29,31.43 124.16,31.31 124.16,31.03 124.04,30.9 123.78,30.9 123.66,31.03 123.66,31.31 123.53,31.43 123.27,31.43 123.15,31.31 123.15,31.03 123.02,30.9 122.77,30.9 122.64,31.03 122.64,31.31 122.51,31.43 122.26,31.43 122.13,31.31 122.13,31.03 122,30.9 121.75,30.9 121.62,31.03 121.62,31.31 121.5,31.43 121.24,31.43 121.12,31.31 121.12,31.03 120.99,30.9 120.73,30.9 120.61,31.03 120.61,31.31 120.48,31.43 120.23,31.43 120.1,31.31 120.1,31.03 119.97,30.9 119.72,30.9 119.59,31.03 119.59,31.31 119.46,31.43 119.21,31.43 119.08,31.31 119.08,31.03 118.96,30.9 118.7,30.9 118.58,31.03 118.58,31.31 118.45,31.43 114.74,31.43 108.66,37.5 101.57,37.5 100.72,38.35 98.12,38.35 97.7,38.77
  BOTTOM w0.14: JDIMM4.176 152.09,35.66 153.09,34.66 v1(153.09,33.81)
