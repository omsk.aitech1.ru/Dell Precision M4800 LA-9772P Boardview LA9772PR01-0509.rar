# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N22890234: length 8.5
  TOP w0.102: UH1.AT8 39.18,92.95 40.04,92.95 v1(40.09,92.9)
  BOTTOM w0.102: v1(40.09,92.9) 40.09,91.53 39.73,91.17 39.73,89.89 39.45,89.61 39.45,89.01 39.79,88.68 40.98,88.68 v2(41.25,88.42) 42.05,87.62 RH195.2
N23248496: length 3.6
  BOTTOM w0.102: R802.2 v2(211.25,76.06) 211.76,76.06 212.97,77.27 U46.B18
N24484285: length 4
  BOTTOM w0.102: C546.1 262.89,59.23 v2(262.67,59.01)
  BOTTOM w0.254: U43.6 265.34,59.73 265.09,59.98 264.19,59.98 263.88,59.66 C546.1
N24485569: length 4
  BOTTOM w0.102: v2(115.3,147.6) 115.67,147.23 C547.1 115.99,146.68 115.99,146.24 115.66,145.92 U56.6
N24487647: length 1.4
  BOTTOM w0.254: U37.6 50.94,77.48 51.23,77.77 C541.1
N24489474: length 6.7
  BOTTOM w0.102: U38.6 83.34,140.12 83.03,140.43 81.26,140.43 80.7,139.88 C542.1 80.58,139.96 80.58,140.82 v2(80.78,141.02)
N25846218: length 7.1
  BOTTOM w0.102: U38.3 83.34,135.04 82.76,134.47 82.67,134.47 C16.1 82.42,133.69 82.81,133.3 v2(84.59,133.3) 85.62,134.33 R15.2
N26598173: length 2.4
  TOP w0.102: R3722.1 60.8,137.07 U630.48
N26614658: length 3.2
  TOP w0.102: R208.2 52.5,146.03 v2(52.02,146.51) 51.58,146.95 JEDP1.18
N32810427: length 0.9
  BOTTOM w0.102: RE5.2 CE3.1
N32854162: length 2.5
  TOP w0.102: v2(105.19,120.22) R756.2 105.22,118.81 C704.1
N32854418: length 2.3
  BOTTOM w0.102: v2(98.43,112.23) CE8.1 RE11.2
N32854492: length 2
  BOTTOM w0.102: CE9.1 RE12.2 v2(90.03,112.23)
N32916170: length 6.8
  TOP w0.102: v1(212,74.84) 211.97,74.86 211.97,75.19 213.99,77.22 v1(213.99,77.41)
  BOTTOM w0.102: U46.B19 213.63,77.77 v1(213.99,77.41) ; v2(212.45,73.77) R804.1 211.24,74.08 v1(212,74.84)
N32917691: length 1.9
  BOTTOM w0.102: v2(209.33,83.27) 209,82.94 R795.2 C713.1
N32917710: length 2
  BOTTOM w0.102: v2(207.78,85.65) 207.78,85.29 208.14,84.94 C712.1 R794.2
N33080426: length 3.3
  BOTTOM w0.102: v2(50.86,158.28) 50.29,157.7 Q22.1
  BOTTOM w0.254: Q22.1 50.89,156.75 51.67,156.75 R423.2
N34391004: length 2.4
  BOTTOM w0.254: Q29.5 169.91,47.92 R513.2 170.16,48.63 Q29.6
N38606908: length 2.3
  TOP w0.102: v2(67.64,167.37) 67.71,167.3 R783.1 68.57,167.26 U48.7
N48711348: length 1.6
  TOP w0.102: v2(47.95,30.22) 47.09,29.36 PC521.1
N51290432: length 1.6
  BOTTOM w0.102: PR502.1 v2(36.67,75.32)
N51302473: length 1.1
  BOTTOM w0.089: 38.39,70.23 38.76,69.86 PR501.1
  BOTTOM w0.102: 38.39,70.23 v2(38.27,70.34)
N53085144: length 3.7
  BOTTOM w0.102: v2(180.73,73.71) 180.73,73.14 179.83,72.24 PC206.2
  BOTTOM w0.508: PR200.1 PC206.2
N53085275: length 3.1
  BOTTOM w0.203: PU200.9 178.29,79.36 178.47,79.54
  BOTTOM w0.635: PR205.2 v2(179.1,80.17) 178.47,79.54
N53866851: length 2.7
  BOTTOM w0.102: R885.2 C747.1 v2(100.17,146.54)
N63746311: length 6.2
  TOP w0.102: R884.1 108.8,162.72 108.44,162.37 108.44,161.8 v2(108.19,161.55) 107.86,161.21 107.86,160.28 v1(107.68,160.11)
  BOTTOM w0.102: v1(107.68,160.11) 107.76,160.02 U51.B2
N63746359: length 11.5
  TOP w0.102: v1(107.63,157.1) 107.31,156.78 106.89,156.78 v2(105.88,155.76) 105.29,155.18 105.29,153.33 105.37,153.26 105.37,149.29 105.83,148.83 R1984.1
  BOTTOM w0.102: U51.B8 107.7,157.02 v1(107.63,157.1)
N72304780: length 6.2
  TOP w0.102: UH1.AY1 41,89.65 41,89.28 42.36,87.92 46.02,87.92 T126.1
N85751870: length 1.2
  BOTTOM w0.102: v2(17.52,142.87) 17.55,142.85 PR301.2
N85751893: length 2.9
  TOP w0.102: PC309.1 v2(14.26,140.69)
  TOP w0.508: PR304.2 14.26,138.72 PC309.1
N88960285: length 3
  BOTTOM w0.102: Q344.3 21.51,150.97 R955.1 22.91,150.1 v2(23.59,150.79)
N94639990: length 4.4
  BOTTOM w0.102: U3.4 50.72,150.44 50.88,150.28 51.57,150.28 51.8,150.05 51.8,149.64 v2(51.34,149.18) 51.19,149.03 50.34,149.03 D68.2
N106386290: length 1.1
  BOTTOM w0.102: CE1.1 48.29,94.47 RE1.2
N106390602: length 2.7
  BOTTOM w0.102: RE2.2 55.79,95.29 v2(55.7,95.37) 55.61,95.47 54.01,95.47 CE2.1
N109035766: length 43.2
  IN2 w0.127: v1(211.24,62.09) 212.1,62.95 216.11,62.95 217.18,61.89 222.84,61.89 226.75,65.8 234.63,65.8 244.08,75.25 v1(244.08,76.39)
  BOTTOM w0.102: Q340.3 243.15,77.15 243.91,76.39 v1(244.08,76.39) 244.45,76.39 v2(244.69,76.63) ; R2190.2 v1(211.24,62.09)
N109035794: length 38.3
  IN2 w0.127: v1(241.82,69.02) 239.15,69.02 235.42,65.29 227.24,65.29 223.12,61.17 216.82,61.17 216.37,61.63 212.71,61.63 v1(211.31,60.23)
  BOTTOM w0.102: v2(241.37,69.72) 241.82,69.28 v1(241.82,69.02) ; v1(211.31,60.23) 211.35,60.27 R2192.2 ; v1(241.82,69.02) 241.82,68.95 242.17,68.59 Q339.5 ; v1(241.82,69.02) 242.03,69.24 Q339.6
N109035808: length 2.7
  BOTTOM w0.102: v2(239.21,75.59) R2191.2 240.65,75.45 Q340.6
N111311136: length 1.4
  TOP w0.102: JCPU1.AC7 v1(101.12,62.75)
  BOTTOM w0.102: T60.1 100.64,62.27 v1(101.12,62.75)
N111311586: length 1.4
  TOP w0.102: JCPU1.AG8 v1(100.12,66.75)
  BOTTOM w0.089: T64.1 99.68,67.19 v1(100.12,66.75)
N111316295: length 1.4
  TOP w0.102: JCPU1.R27 v1(80.12,54.75)
  BOTTOM w0.102: T69.1 80.2,54.75 v1(80.12,54.75)
N111321501: length 1.4
  TOP w0.279: v1(107.12,74.75) JCPU1.AR1
  BOTTOM w0.089: v1(107.12,74.75) 107.12,74.75 T99.1
N111321503: length 2.7
  TOP w0.102: v1(105.12,39.75) JCPU1.A2
  BOTTOM w0.102: T100.1 106.25,39.75 v1(105.12,39.75)
N111321505: length 1.5
  TOP w0.305: JCPU1.K6 v1(101.12,48.75)
  BOTTOM w0.102: T94.1 101.63,49.26 v1(101.12,48.75)
N111321507: length 1.4
  TOP w0.102: v1(102.12,44.75) JCPU1.F5
  BOTTOM w0.102: T93.1 102.62,45.25 v1(102.12,44.75)
N111321509: length 1.5
  TOP w0.102: JCPU1.AM2 v1(106.12,71.75)
  BOTTOM w0.102: v1(106.12,71.75) 106.04,71.75 T95.1
N111321511: length 2.7
  TOP w0.102: JCPU1.C35 72.59,42.22 v1(72.12,41.75)
  BOTTOM w0.089: T82.1 70.46,42.34 71.38,42.34 71.98,41.75 v1(72.12,41.75)
N111321513: length 1.5
  TOP w0.102: JCPU1.B35 72.59,41.22 v1(72.12,40.75)
  BOTTOM w0.102: T81.1 72.55,41.18 v1(72.12,40.75)
N111321515: length 1.5
  TOP w0.102: v1(73.12,39.75) 73.59,40.22 JCPU1.A34
  BOTTOM w0.102: v1(73.12,39.75) 73.57,40.19 T73.1
N111321517: length 1.5
  TOP w0.102: v1(72.12,39.75) 72.59,40.22 JCPU1.A35
  BOTTOM w0.089: v1(72.12,39.75) 71.7,39.75 T74.1
N111321521: length 6.5
  TOP w0.089: JCPU1.AT2 105.59,77.25
  TOP w0.102: 105.59,77.25 105.59,79.08 T71.1
N111321546: length 1.4
  TOP w0.102: JCPU1.E20 87.59,44.22 v1(87.12,43.75)
  BOTTOM w0.102: v1(87.12,43.75) 87.12,43.82 T101.1
N111321548: length 1.4
  TOP w0.102: JCPU1.E21 86.59,44.22 v1(86.12,43.75)
  BOTTOM w0.089: v1(86.12,43.75) 86.12,44.3 T102.1
N111321550: length 1.4
  TOP w0.102: v1(89.12,43.75) 89.59,44.22 JCPU1.E18
  BOTTOM w0.089: 89.12,43.79 89.12,44.32 T96.1
  BOTTOM w0.102: 89.12,43.79 v1(89.12,43.75)
N111321552: length 1.4
  TOP w0.102: v1(84.12,42.75) 84.59,43.22 JCPU1.D23
  BOTTOM w0.102: v1(84.12,42.75) 84.15,42.75 T88.1
N111321596: length 1.2
  TOP w0.102: JCPU1.W30 v1(77.12,58.75)
  BOTTOM w0.089: T84.1 77.12,58.43 v1(77.12,58.75)
N111321598: length 1.4
  TOP w0.102: v1(76.12,58.75) 76.59,58.28 JCPU1.W31
  BOTTOM w0.089: 76.12,58.7 76.12,58.69 T83.1
  BOTTOM w0.102: 76.12,58.7 v1(76.12,58.75)
N111321602: length 1.5
  TOP w0.102: JCPU1.W29 v1(78.12,58.75)
  BOTTOM w0.089: v1(78.12,58.75) 78.3,58.57 T75.1
N111321604: length 1.4
  TOP w0.102: JCPU1.W28 79.59,58.28 79.13,58.74 v1(79.12,58.74)
  BOTTOM w0.089: 79.13,58.74 79.17,58.74 T76.1
  BOTTOM w0.102: 79.13,58.74 v1(79.12,58.74)
N111321610: length 1.5
  TOP w0.102: JCPU1.P10 v1(98.12,52.75)
  BOTTOM w0.102: v1(98.12,52.75) 97.62,53.25 T97.1
N111321612: length 1.5
  TOP w0.102: JCPU1.U10 v1(98.12,55.75)
  BOTTOM w0.102: v1(98.12,55.75) 97.57,56.3 T98.1
N111321642: length 1.3
  TOP w0.102: JCPU1.AL25 v1(82.12,70.75)
  BOTTOM w0.102: v1(82.12,70.75) 82.58,70.29 T85.1
N111321646: length 7.2
  TOP w0.089: JCPU1.AT1 106.59,77.25
  TOP w0.102: T70.1 108,79.27 107.38,79.27 106.59,78.48 106.59,77.25
N111321650: length 2.1
  TOP w0.102: v1(81.12,71.75) JCPU1.AM26
  BOTTOM w0.089: v1(81.12,71.75) 81.66,72.29 T89.1
N111321654: length 1.4
  TOP w0.102: JCPU1.AR33 v1(74.12,74.75)
  BOTTOM w0.089: T91.1 73.61,75.26 v1(74.12,74.75)
N111321656: length 1.4
  TOP w0.102: JCPU1.AM27 v1(80.12,71.75)
  BOTTOM w0.089: T92.1 80.12,71.81 v1(80.12,71.75)
N111321658: length 1.5
  TOP w0.102: v1(84.12,40.75) 84.59,41.22 JCPU1.B23
  BOTTOM w0.102: v1(84.12,40.75) 84.12,40.82 T78.1
N111321660: length 1.5
  TOP w0.102: JCPU1.C23 84.59,42.22 v1(84.12,41.75)
  BOTTOM w0.089: T86.1 84.05,41.75 v1(84.12,41.75)
N111321662: length 1.5
  TOP w0.102: JCPU1.D24 83.59,43.22 v1(83.12,42.75)
  BOTTOM w0.089: 83.12,42.87 83.12,43.42 T87.1
  BOTTOM w0.102: 83.12,42.87 v1(83.12,42.75)
N111321667: length 1.3
  TOP w0.102: v1(77.12,69.76) 77.12,69.81 JCPU1.AL30
  BOTTOM w0.089: T79.1 77.12,69.84 v1(77.12,69.76)
N111321671: length 1.5
  TOP w0.102: JCPU1.AD10 v1(98.12,63.75)
  BOTTOM w0.102: v1(98.12,63.75) 97.66,63.28 T72.1
N111327495: length 1.3
  TOP w0.102: v1(80.12,57.75) JCPU1.V27
  BOTTOM w0.102: v1(80.12,57.75) 80.55,57.32 T113.1
N111327547: length 4.8
  TOP w0.102: T157.1 72.59,80.01 JCPU1.AT35
N111327958: length 1.4
  TOP w0.254: JCPU1.AL27 v1(80.12,70.75)
  BOTTOM w0.089: T151.1 80.05,70.75 v1(80.12,70.75)
N111328199: length 5
  TOP w0.102: JCPU1.AR35 72.04,74.83 72.04,78.76 T158.1
N111328255: length 1.3
  TOP w0.102: v1(80.12,69.75) JCPU1.AK27
  BOTTOM w0.102: T152.1 80.55,69.32 v1(80.12,69.75)
N111328259: length 1.4
  TOP w0.254: JCPU1.AL13 v1(94.12,70.75)
  BOTTOM w0.254: T154.1 94.6,70.27 v1(94.12,70.75)
N111329001: length 1.4
  TOP w0.254: v1(80.12,50.75) JCPU1.L27
  BOTTOM w0.102: v1(80.12,50.75) 80.54,50.33 T77.1
N111329005: length 1.4
  TOP w0.254: v1(80.12,49.75) JCPU1.K27
  BOTTOM w0.089: v1(80.12,49.75) 80.09,49.75 T110.1
N111329010: length 1.3
  TOP w0.102: JCPU1.T27 v1(80.12,55.75)
  BOTTOM w0.089: v1(80.12,55.75) 79.71,55.75 T112.1
N111329086: length 1.4
  TOP w0.102: JCPU1.E17 90.59,44.22 v1(90.12,43.75)
  BOTTOM w0.102: T153.1 90.59,44.21 v1(90.12,43.75)
N111329153: length 1.7
  TOP w0.102: JCPU1.W32 v1(75.12,58.75)
  BOTTOM w0.089: T160.1 74.8,58.75 v1(75.12,58.75)
N111329155: length 1.3
  TOP w0.305: JCPU1.AL16 v1(91.12,70.75)
  BOTTOM w0.089: T159.1 v1(91.12,70.75)
N111329157: length 1.4
  TOP w0.102: v1(81.12,52.75) 81.12,52.75 81.59,52.28 JCPU1.N26
  BOTTOM w0.102: T115.1 81.12,52.68 81.12,52.75 v1(81.12,52.75)
N111337107: length 1.3
  TOP w0.102: JCPU1.AK33 v1(74.12,69.75)
  BOTTOM w0.089: T114.1 74.05,69.75 v1(74.12,69.75)
N111857606: length 1.3
  TOP w0.102: v1(78.12,70.75) JCPU1.AL29
  BOTTOM w0.102: v1(78.12,70.75) 78.52,70.35 T80.1
N113061370: length 3.8
  TOP w0.102: v2(119.06,107.81) 119.21,107.66 R1970.2 119.8,107.43 119.8,105.78 119.75,105.73 JMXM1.55
N116282053: length 2.1
  TOP w0.102: CD89.2 123.8,84.75 v2(123.35,84.3)
  TOP w0.508: CD89.2 124.37,84.72 RC109.1
N116282133: length 2.5
  TOP w0.102: RC110.1 v2(123.82,47.2)
  TOP w0.508: CD90.2 RC110.1
N116406009: length 2.1
  BOTTOM w0.102: RC111.1 177.55,88.53 v2(177,88.53)
  BOTTOM w0.508: CD91.2 RC111.1
N116905454: length 6.8
  TOP w0.102: Q113.5 Q113.2 86.05,131.46 85.63,131.46 R1537.2 84.39,130.97 Q110.3 83.76,129.66 v2(83.85,129.56)
N116905461: length 2.9
  TOP w0.102: Q113.3 87.19,131.38 87.56,131.76 R1530.2 88.3,132.84 v2(88.37,132.91)
N116905506: length 2.9
  TOP w0.102: R1539.2 84.87,135.06 85.61,134.33 85.77,134.33 v2(85.91,134.19) 85.99,134.11 85.99,133.36 85.89,133.26 Q113.6
N116909867: length 3.3
  TOP w0.102: v2(33.09,162.67) 32.41,163.36 R2157.2 30.75,162.63 Q335.3
N116909894: length 4.3
  TOP w0.102: Q336.6 27.34,150.02 26.56,149.25 R2152.2 26.56,147.18 v2(26.88,146.86)
N116909908: length 7.3
  TOP w0.102: v1(29.42,156.55) 29.12,156.25 R2151.2 ; Q335.6 32.05,159.53 v1(32.39,159.19) 31.54,159.19 v2(31.38,159.36)
  BOTTOM w0.102: v1(29.42,156.55) 32.06,159.19 v1(32.39,159.19)
N116909947: length 2.5
  TOP w0.102: R2161.2 28.79,163.15 28.21,162.58 Q337.3 27.38,162.28 v2(27.16,162.49)
N116909973: length 3
  TOP w0.102: R2154.2 29.22,158.1 29.75,158.63 v2(29.75,159.37) 29.75,159.8 29.51,160.04 Q337.6
N117170853: length 5.6
  BOTTOM w0.102: R1171.2 v2(154.76,164.7) 158.49,164.7 JLOM1.13
N117170855: length 52.8
  BOTTOM w0.102: JLOM1.11 170.52,163.18 175.7,158 175.7,149.23 175.2,148.73 156.47,148.73 155.99,149.2 155.99,160.18 v2(154.83,161.34) 153.25,162.93 R1167.2
N117171278: length 51.9
  BOTTOM w0.102: R1170.2 154.67,160.23 155.76,159.14 155.76,148.32 156.36,147.72 v2(158.38,147.72) 160.28,147.72 161.06,148.5 175.29,148.5 175.93,149.13 175.93,161.78 JLOM1.10
N117983692: length 2.9
  TOP w0.102: U29.17 167.32,129.03 R818.2 166.62,129 v2(166.33,129.3)
N117984013: length 6.3
  TOP w0.102: R420.1 162.42,134.72 v2(161.86,134.16)
  TOP w0.254: U29.11 165.76,134.01 164.14,135.62 162.75,135.62 R420.1
N117984029: length 4.3
  TOP w0.102: v2(162.64,131.6) 162.8,131.75 164.21,131.75 R418.1
  TOP w0.254: U29.14 164.97,132.51 R418.1
N118331047: length 2.8
  TOP w0.102: v2(7.5,144.79) 7.57,144.72 R939.1 8.94,144.32 Q79.1
N118331054: length 3.4
  TOP w0.102: Q79.2 11.3,146.17 11.71,145.77 v2(12.25,145.77) Q78.1
N118331059: length 2.3
  TOP w0.102: Q75.1 9.37,146.96 R934.1 8.09,146.96 v2(7.62,147.43)
N118331066: length 4.8
  TOP w0.102: v2(12.87,152.54) 12.58,152.25 D59.1 11.68,152.21 10.8,152.21 10.6,152.41 8.9,152.41 8.66,152.17 Q74.3
N118331070: length 7.9
  TOP w0.102: Q74.1 9.96,151.18 10.52,150.61 11.48,150.61 D59.2 ; D59.2 12.18,150.39 R932.2 11.85,149.57 D62.2 12.85,149.01 Q328.3 ; D59.2 12.69,150.85 v2(12.92,151.08)
N118331074: length 1.1
  TOP w0.102: Q74.6 9.96,149.44 Q75.2
N118331095: length 3.6
  BOTTOM w0.102: Q318.1 12.58,150.93 12.07,151.44 R941.1 13.23,151.99 v2(13.48,152.25)
N118331099: length 3.7
  BOTTOM w0.102: Q80.1 8.29,153.26 R942.1 8.82,151.96 9.51,151.27 v2(9.51,150.96)
N118331106: length 2.2
  BOTTOM w0.102: Q86.1 16.75,144.59 R943.1 15.66,144.51 v2(15.5,144.66)
N118331109: length 3.7
  TOP w0.102: v1(16.08,148.12) 15.15,149.06 Q328.1 v2(16.51,149.26)
  BOTTOM w0.102: Q86.2 16.1,148.11 v1(16.08,148.12)
N118535661: length 5.6
  BOTTOM w0.102: v2(170.18,110.88) 170.18,111.26 170.63,111.72 170.63,113.23 170.34,113.52 R656.1 169.37,113.35 U39.9
N118640218: length 6.4
  TOP w0.102: RH144.1 30.77,85.62 31.58,86.43 v2(31.76,86.43) 32,86.43 32.88,87.31 32.88,89.49 33.11,89.73 UH1.AA2
N118640221: length 7
  TOP w0.102: UH1.Y3 32.72,90.22 32.42,89.91 32.42,87.87 v2(32.28,87.73) 31.95,87.4 31.8,87.4 29.5,85.1 RH145.1
N119148113: length 1.4
  TOP w0.254: v1(80.12,48.75) JCPU1.J27
  BOTTOM w0.102: T164.1 80.57,48.3 v1(80.12,48.75)
N119362006: length 3.4
  BOTTOM w0.102: U45.7 256.33,102.07 255.92,102.47 255.66,102.47 255.18,102.96 R747.1 254.93,103.12 254.61,102.79 253.87,102.79 v2(253.83,102.83)
N119363129: length 2.8
  BOTTOM w0.102: U638.30 227.61,86.41 227.08,86.93 227.08,87.44 R2141.2
N119556938: length 2.3
  TOP w0.102: Q28.2 156.41,135.26 R399.2 v2(156.37,133.91)
N260222010: length 37
  IN1 w0.254: v1(214.52,50.9) 214.52,50.81 214.38,50.67 214.38,45.9 207.69,39.2 207.69,30.17 206.22,28.71 199.8,28.71 v1(198.83,27.73)
  BOTTOM w0.102: v2(213.91,52.74) 214.55,52.11 PR1033.1
  BOTTOM w0.254: PQ1083.5 198.4,27.3 v1(198.83,27.73) ; v1(214.52,50.9) 214.55,50.92 PR1033.1

## Copper pours and planes (outline as drawn)
1.05V_RUN_ENABLE on TOP (solid shape): 38.39,129.45 38.39,129.3 38.39,128.45 38.39,128.43 38.39,127.54 38.39,127.42 38.13,127.16 37.63,127.16 37.5,127.29 37.5,127.67 36.74,128.43 34.96,128.43 34.71,128.69 34.71,129.58 34.96,129.83 38.01,129.83
1.5VSP_LX on BOTTOM (solid shape): 259.24,33.56 259.88,33.56 260,33.44 260,32.93 259.88,32.8 259.24,32.8 258.99,32.55 258.99,30.14 257.46,28.61 255.81,28.61 255.56,28.87 255.56,34.45 255.81,34.71 258.1,34.71
1.5VSP_VIN on BOTTOM (solid shape): 263.05,33.31 263.05,28.87 262.8,28.61 260,28.61 259.75,28.87 259.75,29.37 260,29.63 261.4,29.63 261.78,30.01 261.78,31.28 262.04,31.53 262.04,31.73 262.04,31.73 262.04,33.44 262.16,33.56 262.8,33.56
1.35V_B+ on BOTTOM (solid shape): 185.45,67.09 185.45,62.9 185.2,62.65 180.88,62.65 179.23,64.3 175.17,64.3 174.91,64.55 174.91,67.22 175.04,67.35 185.2,67.35
+0.9V_LAN on TOP (solid shape): outline of 318 points within 117.43,148.25 126.53,158.15
+0.9V_LAN on BOTTOM (solid shape): 118.53,153.58 118.53,153.2 118.78,152.94 119.8,152.94 119.8,152.31 118.78,152.31 118.27,152.82 117.64,152.82 117.38,153.07 117.38,153.58 117.64,153.83 118.27,153.83
+0.675V_DDR_VTT on TOP (solid shape): outline of 355 points within 121.19,23.91 167.29,31.02
+0.675V_DDR_VTT on BOTTOM (solid shape): 169.58,76.22 169.58,73.95 169.33,73.7 168.31,73.7 167.55,74.46 167.55,76.03 167.58,76.04 167.79,76.29 167.73,76.61 167.7,76.65 167.8,76.74 169.05,76.74
+0.675V_DDR_VTT on BOTTOM (solid shape): outline of 309 points within 150.02,22.77 171.74,29.25
+0.675V_DDR_VTT on IN3 (solid shape): 167.67,29.5 167.67,28.1 167.42,27.85 165.01,27.85 164.75,28.1 164.75,29.5 165.01,29.75 167.42,29.75
+0.675V_DDR_VTT on IN3 (solid shape): 169.96,76.49 169.96,73.82 169.33,73.19 168.18,73.19 167.93,73.44 167.93,76.49 168.18,76.74 169.71,76.74
+0.675V_P on BOTTOM (solid shape): 177.19,75.93 177.19,75.18 176.85,74.84 176.56,74.84 176.31,74.59 176.31,73.82 176.06,73.57 170.42,73.57 170.32,73.67 170.32,75.19 170.47,75.35 174.66,75.35 174.91,75.6 176.06,75.6 176.31,75.86 176.82,75.86 176.95,75.98 177.14,75.98
+1.05V_M on TOP (solid shape): 28.05,132.44 28.11,132.53 28.22,132.51 28.57,132.17 31.21,132.17 31.33,132.05 31.33,130.07 31.4,129.99 31.4,129.96 31.66,129.7 31.66,125 31.4,124.75 29.88,124.75 29.64,124.99 29.64,125 29.55,125.15 29.39,125.24 29.38,125.25 28.08,126.55 28.08,127.14 27.52,127.14 27.52,127.39 28.05,127.39 28.08,127.42 28.08,127.95 27.52,127.95 27.52,128.2 28.08,128.2 28.08,131.07 27.52,131.07 27.52,131.23 28.05,131.23 28.05,131.33 28.08,131.33 28.08,131.89 27.52,131.89 27.52,132.03 28.05,132.03 28.05,132.14 28.05,132.14
+1.05V_M on TOP (solid shape): 32.52,99.38 32.52,99.36 32.57,99.21 32.69,99.1 32.7,99.1 33.05,98.75 33.05,97.7 33.2,97.55 33.2,97.55 33.43,97.32 33.44,97.3 33.5,97.11 33.66,96.99 33.69,96.98 33.69,96.81 33.44,96.56 30.9,96.56 30.64,96.81 30.64,97.02 30.79,97.16 30.83,97.36 30.85,97.43 30.9,97.47 31.04,97.56 31.1,97.72 31.33,97.94 31.33,98.65 31.5,98.94 31.35,99.25 31.3,99.33 31.33,99.41 31.44,99.51 31.53,99.51 31.55,99.5 31.86,99.39 32.12,99.58 32.14,99.6 32.29,99.6
+1.05V_M on BOTTOM (solid shape): 33.56,99.22 33.56,97.95 33.5,97.89 32.94,97.89 32.71,97.66 32.71,97.1 32.54,96.94 31.23,96.94 31.13,96.84 30.44,96.84 30.44,96.81 30.39,96.81 30.01,96.43 29.54,96.43 29.05,96.57 28.93,96.08 28.93,95.97 28.84,95.92 28.61,95.92 28.39,96.14 28.4,96.17 28.4,96.3 28.36,96.42 28.36,96.43 28.36,96.56 28.77,96.98 28.79,96.98 28.95,97.07 29.05,97.24 29.05,97.25 29.12,97.32 30.12,97.32 30.12,97.28 30.68,97.04 30.64,97.64 30.59,97.72 30.62,97.81 31.53,98.72 31.53,99.1 31.78,99.35 33.44,99.35
+1.05V_M on BOTTOM (solid shape): 32.17,116.24 32.67,116.24 32.73,116.18 32.76,116.08 32.67,116.01 32.53,115.95 32.42,115.84 32.34,115.79 32.25,115.82 31.64,115.51 32.32,115.47 32.37,115.5 32.42,115.48 32.45,115.43 32.47,115.36 32.45,115.3 32.72,114.72 33,115.3 32.97,115.36 33,115.43 33.05,115.51 33.08,115.61 33.14,115.69 33.25,115.67 33.56,115.35 33.56,114 33.53,113.97 33.51,113.93 33.42,113.88 33.33,113.93 32.67,113.75 33.33,113.57 33.42,113.62 33.51,113.57 33.53,113.54 33.56,113.5 33.56,113.45 33.82,113.19 33.82,110.54 33.32,110.05 32.78,110.05 32.67,110.15 32.67,111.96 31.78,112.85 31.78,113.32 31.53,113.57 31.53,114.5 31.15,114.88 31.15,115.23 30.51,115.86 29.28,115.86 29.27,115.86 28.85,115.7 28.86,115.24 28.86,114.84 28.61,114.59 27.85,114.59 27.59,114.84 27.59,116.75 27.82,116.98 30.57,116.98 30.59,117 31.4,117
+1.05V_M on VCC (solid shape): outline of 3249 points within 24.55,96.18 32.67,128.56
+1.05V_MP on TOP (solid shape): 25.14,138.17 25.51,137.88 25.88,138.17 27.38,138.17 27.85,137.7 27.85,136.63 27.77,136.41 27.85,136.19 27.85,135.84 27.54,135.54 27.54,133.19 27.85,132.89 27.85,132.37 27.34,132.37 27.34,130.85 27.39,130.85 27.39,130.83 27.85,130.83 27.85,128.43 27.34,128.43 27.34,126.91 27.85,126.91 27.85,126.53 27.72,126.4 22.13,126.4 21.24,127.29 21.24,128.43 21.5,128.69 22.26,128.69 22.39,128.81 22.39,129.58 22.26,129.7 21.5,129.7 21.24,129.96 21.24,132.12 22.51,133.39 22.51,138.01 22.67,138.17
+1.5V_RUN on TOP (solid shape): 252.38,86.65 252.38,66.46 252.26,66.33 250.73,66.33 249.72,67.35 249.72,76.49 250.35,77.13 250.35,86.65 250.61,86.9 252.13,86.9
+1.05V_RUN on TOP (solid shape): 36.99,127.8 36.99,127.29 37.25,127.04 39.66,127.04 39.89,126.81 39.89,123.07 39.66,122.85 35.09,122.85 34.83,123.1 34.83,127.8 35.09,128.05 36.74,128.05
+1.5V_RUN on TOP (solid shape): 16.73,89 16.73,88.98 16.78,88.72 16.99,88.57 17,88.56 17,87.87 17.13,87.74 16.67,87.29 16.67,86.78 16.54,86.65 14.51,86.65 14.39,86.78 12.23,86.78 12.1,86.9 12.1,87.67 12.23,87.79 15.19,87.79 15.28,87.78 15.37,87.79 15.53,87.79 15.78,88.05 15.78,88.28 15.83,88.33 15.83,88.99 16.04,89.19 16.54,89.19
+1.5V_RUN on TOP (solid shape): 104.17,142.24 104.17,140.71 103.83,140.37 95.67,140.37 95.41,140.63 95.41,141.25 95.42,141.28 95.44,141.34 95.46,141.4 95.46,141.46 95.46,141.52 101.25,141.52 101.25,141.46 101.26,141.41 101.28,141.36 101.3,141.31 101.33,141.27 101.37,141.23 101.41,141.19 101.45,141.17 101.5,141.15 101.56,141.14 101.61,141.13 101.66,141.14 101.71,141.15 101.76,141.17 101.81,141.19 101.85,141.23 101.89,141.27 101.92,141.31 101.94,141.36 101.96,141.41 101.96,141.46 101.96,141.52 101.96,141.57 101.94,141.62 101.92,141.67 101.89,141.71 101.85,141.75 101.81,141.78 101.76,141.81 101.71,141.83 101.66,141.84 101.61,141.85 101.56,141.84 101.5,141.83 101.45,141.81 101.41,141.78 101.37,141.75 101.33,141.71 101.3,141.67 101.28,141.62 101.26,141.57 101.25,141.52 95.46,141.52 95.45,141.58 95.44,141.61 95.44,142.14 95.74,142.44 103.97,142.44
+1.05V_RUN on BOTTOM (solid shape): 47.89,111.5 47.89,111.22 47.26,110.59 47.1,110.59 46.87,110.82 46.87,111.09 47.45,111.67 47.72,111.67
+1.5V_RUN on BOTTOM (solid shape): 254.29,27.6 254.29,26.2 254.03,25.94 251.75,25.94 251.49,26.2 251.49,27.6 251.75,27.85 254.03,27.85
+1.5V_RUN on BOTTOM (solid shape): 12.35,111.03 12.35,110.65 11.59,109.89 10.24,109.89 10.19,109.89 9.94,110.15 9.94,110.4 11.34,111.8 11.59,111.8
+1.5V_RUN on BOTTOM (solid shape): 15.73,118.25 15.87,118.11 15.78,118.02 15.04,118.02 14.99,118.02 14.89,118.02 14.77,118.15 14.77,118.98 14.77,119.29 15.02,119.54 15.73,119.54
+1.05V_RUN on BOTTOM (solid shape): 14.03,102.98 14.34,102.87 14.63,103.03 14.95,103.03 15.04,102.95 15.04,102.19 14.87,102.02 13.24,102.02 12.99,102.27 12.99,103.03 13.24,103.29 13.73,103.29
+1.5V_RUN on BOTTOM (solid shape): 16.62,89.57 16.69,89.54 16.72,89.48 16.75,89.36 16.8,89.27 16.83,89.2 16.8,89.14 16.78,88.72 17.18,88.57 17.27,88.55 17.31,88.47 17.31,88.3 17.05,88.05 16.72,88.05 16.6,88.17 16.54,88.17 16.42,88.3 15.91,88.3 15.53,88.68 15.53,89.06 16.04,89.57
+1.05V_RUN on BOTTOM (solid shape): outline of 189 points within 35.59,114.72 39.91,122.97
+1.5V_RUN on BOTTOM (solid shape): outline of 2208 points within 35.47,97.83 49.82,113.07
+1.5V_RUN on IN1 (solid shape): 181.26,85.7 181.26,85.34 179.4,85.34 179.1,85.63 177.98,85.63 177.9,85.67 177.88,85.75 177.87,85.92 177.78,86.07 177.75,86.14 177.78,86.21 178.72,87.16 179.81,87.16
+1.5V_RUN on IN1 (solid shape): outline of 1216 points within 115.48,114.97 154.09,149.52
+1.5V_RUN on IN1 (solid shape): outline of 2171 points within 208.44,59.35 252.38,71.11
+1.5V_RUN on IN2 (solid shape): 96.68,142.78 96.68,141.11 95.61,140.04 95.41,140.24 95.41,142.78 95.67,143.04 96.43,143.04
+1.5V_RUN on IN2 (solid shape): outline of 659 points within 40.04,105.57 51.09,113.07
+1.5V_RUN on IN3 (solid shape): outline of 297 points within 103.41,139.74 116.87,142.4
+1.5V_RUN on IN4 (solid shape): 182.15,84.8 182.15,84.11 181.52,83.48 180.25,83.48 179.1,84.62 179.1,85.89 179.36,86.14 180.81,86.14
+1.5V_RUN on IN4 (solid shape): 208.7,62.77 210.6,62.77 210.85,62.52 210.85,61.12 210.6,60.87 207.81,60.87 206.16,62.52 206.16,62.77 206.92,63.54 207.93,63.54
+1.5V_RUN on IN4 (solid shape): 253.02,69.38 253.02,67.47 252.76,67.22 252.26,67.22 249.59,69.89 249.59,70.78 249.84,71.03 251.37,71.03
+1.5V_RUN on IN4 (solid shape): 255.43,27.98 255.43,27.85 255.3,27.72 255.43,27.6 255.43,26.2 255.18,25.94 251.75,25.94 251.49,26.2 251.49,27.98 251.75,28.23 255.18,28.23
+1.5V_RUN on BOTTOM: 8.8,92.24 8.54,92.49 8.54,94.02 8.78,94.25 8.88,94.27 8.95,94.18 8.97,94.07 9.03,93.97 9.05,93.9 9.03,93.84 9.31,93.25 9.58,93.84 9.56,93.9 9.58,93.97 9.65,94.11 9.65,94.32 9.67,94.36 9.69,94.38 9.72,94.39 9.75,94.4 10.06,94.4 10.22,94.25 10.22,92.51 9.94,92.24
+1.5V_RUN on IN1: 8.92,92.49 8.67,92.75 8.67,95.16 9.35,95.84 9.43,95.87 9.51,95.82 10.02,95.71 10.08,96.23 10.05,96.3 10.08,96.37 10.17,96.62 10.07,96.86 10.07,99.42 10.12,99.6 10.07,99.79 10.07,102.4 9.62,102.85 9.62,102.85 9.56,102.93 9.48,102.99 9.47,102.99 8.93,103.54 8.93,110.4 9.18,110.65 11.21,110.65 11.46,110.4 11.46,109.67 11.41,109.48 11.46,109.3 11.46,109.08 11.41,108.9 11.46,108.72 11.46,106.39 11.41,106.21 11.46,106.02 11.46,105.81 11.41,105.62 11.46,105.44 11.46,105.18 11.41,105 11.46,104.82 11.46,98.28 11.43,98.21 11.36,98.18 11.01,97.97 11.08,97.58 11.11,97.51 11.08,97.44 11.01,97.04 11.36,96.84 11.43,96.81 11.46,96.73 11.46,95.06 11.21,94.8 11.21,92.94 10.76,92.49
+1.05V_RUN on VCC: outline of 209 points within 30.01,95.41 50.58,128.56
+1.5V_RUNP on BOTTOM (solid shape): 253.78,38.26 253.78,38.23 254.29,37.73 254.29,35.6 255.18,34.71 255.18,28.87 254.92,28.61 251.75,28.61 251.49,28.87 251.49,33.31 252.51,34.33 252.51,38.52 252.76,38.77 253.27,38.77
+1.05VSP_B+ on BOTTOM (solid shape): 21.09,141.46 21.09,138.14 21.26,137.97 21.96,137.97 22.04,137.88 22.04,135.69 21.9,135.54 18.55,135.54 18.16,135.93 18.16,138.14 17.98,138.32 17.29,138.32 17.14,138.47 17.14,139.28 17.14,139.28 17.69,139.28 17.69,139.83 17.14,139.83 17.14,139.83 17.14,140.08 17.69,140.08 17.69,140.08 17.69,140.63 17.69,140.63 17.15,140.63 17.15,140.63 17.15,141.4 17.41,141.67 20.88,141.67
+1.35V_MEM on TOP (solid shape): 136.43,66.2 136.43,51.09 136.2,50.86 135.95,50.86 135.69,51.47 135.45,50.86 135.35,50.83 135.26,50.78 134.3,50.78 134.17,51.47 134.04,50.78 132.63,50.78 132.5,50.92 132.5,53.38 132.62,53.5 132.62,54.52 132.5,54.65 132.5,55.92 132.62,56.04 132.62,56.93 132.5,57.06 132.5,58.46 132.62,58.58 132.62,59.47 132.5,59.6 132.5,62.9 132.37,63.03 132.37,64.04 132.5,64.17 132.5,65.31 132.24,65.57 132.24,66.97 132.5,67.22 135.42,67.22
+1.35V_MEM on TOP (solid shape): outline of 111 points within 93.15,46.9 97.44,68.24
+1.35V_MEM on BOTTOM (solid shape): 182.79,57.01 183.55,57.01 183.55,57.54 183.98,57.54 183.98,57.01 187.69,57.01 187.69,57.54 188.12,57.54 188.12,57.01 188.88,57.01 188.88,57.54 189.31,57.54 189.31,57.01 190,57.01 190.28,56.73 190.28,55.66 190.03,55.41 187.61,55.41 186.22,54.01 181.52,54.01 181.26,54.27 181.26,56.68 181.59,57.01 182.36,57.01 182.36,57.54 182.79,57.54
+1.35V_MEM on BOTTOM (solid shape): 136.31,67.6 136.31,54.94 136.06,54.94 135.77,54.65 135.67,54.65 133.38,52.36 133.38,50.96 133.13,50.71 132.62,50.71 132.37,50.96 132.37,53.58 132.4,53.6 132.44,53.6 132.44,53.65 132.5,53.7 132.5,54.57 132.37,54.7 132.37,55.99 132.5,56.12 132.5,56.98 132.37,57.11 132.37,58.28 132.62,58.53 132.62,59.27 132.37,59.53 132.37,64.04 132.5,64.17 132.5,64.37 132.5,64.37 132.5,65.37 132.5,65.44 132.37,65.57 132.37,67.6 132.62,67.85 136.05,67.85
+1.35V_MEM on BOTTOM (solid shape): 164.43,68.22 164.43,67.21 164.25,67.03 164.25,53 163.31,52.06 163.1,52.06 162.73,51.87 162.67,51.46 162.68,51.43 162.21,50.96 160.82,50.96 160.56,51.22 160.56,54.9 160.82,55.15 162.34,55.15 162.72,55.54 162.72,55.92 162.98,56.17 162.98,59.22 162.72,59.47 160.94,59.47 160.69,59.73 160.69,68.11 160.94,68.36 164.29,68.36
+1.35V_MEM on BOTTOM (solid shape): outline of 12838 points within 88.05,33.05 111.39,69.38
+1.35V_MEM on IN2 (solid shape): outline of 13256 points within 88.68,43.55 165.64,72.54
+1.35V_MEM on TOP: 164.37,51.09 165.48,49.98 165.48,49 165.9,48.59 165.9,45.76 165.64,45.5 164.37,45.5 163.74,44.87 163.74,41.18 167.17,37.76 167.17,36.36 166.79,35.98 162.72,35.98 162.09,36.61 162.09,42.96 162.28,43.45 162.09,43.94 162.09,45.5 161.83,45.76 161.83,50.06 161.83,50.07 161.83,50.36 161.15,51.04 160.74,51.04 160.56,51.22 160.56,55.49 160.61,55.58 160.71,55.58 160.92,55.54 161.12,55.62 161.18,55.64 161.25,55.62 161.67,55.59 161.82,55.98 162.98,57.14 162.98,59.47 162.72,59.73 160.82,59.73 160.56,59.98 160.56,68.11 161.32,68.87 161.32,77.93 161.57,78.17 166.71,78.17 167.04,77.84 167.04,74.08 166.79,73.82 163.94,73.82 163.82,73.7 163.82,69.08 164.16,68.74 166.79,68.74 167.04,68.49 167.04,64.68 166.63,64.27 164.68,64.27 164.08,64.87 164.08,65.06 163.93,65.21 163.22,65.21 163.15,65.14 163.15,64.11 163.41,63.85 164.1,63.85 164.37,63.58
+1.35V_MEM on VCC: outline of 342 points within 88.55,34.2 191.8,78.01
+1.35V_MEN_P on BOTTOM (solid shape): 174.66,71.46 174.66,70.93 174.68,70.9 175.14,70.9 175.17,70.93 175.17,71.46 175.19,71.49 175.47,71.49 175.68,71.28 175.68,69.89 174.66,68.87 174.66,62.01 174.91,61.76 190.6,61.76 191.42,62.58 191.42,70.14 191.68,70.39 199.93,70.39 200.19,70.14 200.19,62.14 199.93,61.89 198.15,61.89 196.38,60.11 196.38,57.44 196.12,57.19 189.49,57.19 189.49,57.72 188.71,57.72 188.71,57.16 188.27,57.16 188.27,57.72 187.51,57.72 187.51,57.16 184.16,57.16 184.16,57.72 183.4,57.72 183.37,57.69 183.37,57.16 182.94,57.16 182.94,57.72 182.18,57.72 182.18,57.19 174.53,57.19 172.5,59.22 172.5,70.14 173.85,71.49 174.63,71.49
+3.3V_ALW on TOP (solid shape): 111.08,138.69 111.44,138.69 111.79,138.34 111.79,137.7 111.54,137.45 109.89,137.45 109.64,137.7 109.64,138.59 109.76,138.72 111.08,138.72
+3.3V_ALW on TOP (solid shape): 45.64,31.58 45.78,31.44 45.78,30.28 45.66,30.16 45.18,30.16 45.11,30.24 45.11,30.48 44.97,30.62 44.97,31.54 45.01,31.58 45.53,31.58
+3.3V_ALW on TOP (solid shape): 126.87,164.22 126.87,163.71 126.49,163.33 125.95,163.33 125.51,163.77 125.51,164.49 125.56,164.54 125.82,164.54 125.82,164.54 126.56,164.54
+3.3V_ALW on TOP (solid shape): 126.29,167.04 126.29,166.51 126.29,166.51 126.29,165.99 126.23,165.94 125.57,165.94 125.51,166 125.51,166.55 125.26,166.8 125.26,167.03 125.41,167.18 126.14,167.18
+3.3V_ALW on TOP (solid shape): 175.59,121 175.59,119.24 175.5,119.15 174.37,119.15 174.23,119.02 174.23,114.37 174.46,114.15 174.46,112.55 173.91,112 172.2,112 172.04,112.15 172.04,112.71 172.14,112.81 173.54,112.81 173.66,112.93 173.66,113.79 173.66,114.08 173.6,114.13 172.07,114.13 172,114.2 172,115.73 172.6,116.33 172.6,118.53 172.02,119.11 172.02,120.52 172.73,121.24 175.34,121.24
+3.3V_ALW on BOTTOM (solid shape): 120.2,110.47 120.2,109.45 120.12,109.37 119.45,109.37 119.36,109.46 119.36,110.09 119.86,110.58 120.08,110.58
+3.3V_ALW on BOTTOM (solid shape): 56.47,109.01 56.98,109.01 57.14,108.85 57.14,108.16 56.84,107.85 56.34,107.85 56,108.18 55.68,108.18 55.63,108.23 55.63,109.08 55.72,109.16 56.32,109.16
+3.3V_ALW on BOTTOM (solid shape): 57.23,111.84 57.23,110.64 57.11,110.51 55.67,110.51 55.62,110.56 55.62,111.1 56.49,111.98 57.1,111.98
+3.3V_ALW on BOTTOM (solid shape): 208.07,78.01 208.07,77.04 208,76.97 207.39,76.97 207.37,76.99 206.54,76.99 206.54,77 206.41,77 206.16,77.25 206.16,78.01 206.41,78.27 207.82,78.27
+3.3V_ALW on BOTTOM (solid shape): 262.54,27.6 262.54,24.8 262.29,24.55 256.32,24.55 256.07,24.8 256.07,26.2 256.32,26.45 259.24,26.45 259.5,26.71 259.5,27.6 259.75,27.85 262.29,27.85
+3.3V_ALW on BOTTOM (solid shape): 111.54,145.71 111.92,145.7 112.05,145.58 112.07,145.57 112.81,145.57 112.94,145.45 112.94,144.31 112.68,144.05 110.27,144.05 110.09,144.24 110.09,145.65 110.7,146.26 110.98,146.26
+3.3V_ALW on BOTTOM (solid shape): 86.1,136 86.1,134.72 85.89,134.5 84.34,134.5 84.31,134.52 84.27,134.54 83.69,135.12 83.69,135.99 83.71,136.02 84.43,136.02 84.5,136.08 84.51,136.08 84.51,136.1 84.54,136.12 85.99,136.12
+3.3V_ALW on BOTTOM (solid shape): 224.19,70.27 224.19,70.15 224.18,70.14 224.14,69.96 224.19,69.78 224.19,69.08 224.11,69 222.84,69 222.78,69.06 222.78,70.25 222.87,70.34 224.11,70.34
+3.3V_ALW on BOTTOM (solid shape): 227.24,85 227.24,82.84 226.98,82.59 226.12,82.59 225.97,82.74 225.97,84.43 226.12,84.72 225.97,85.01 225.97,85.71 226.53,85.71
+3.3V_ALW on BOTTOM (solid shape): 45.25,153.71 45.25,152.18 44.99,151.93 44.23,151.93 43.98,152.18 43.98,152.98 44.17,153.3 43.98,153.62 43.98,153.71 44.23,153.96 44.99,153.96
+3.3V_ALW on BOTTOM (solid shape): 109.84,169.89 109.91,169.89 109.99,169.81 109.99,169.55 109.43,169.55 109.43,169.48 109.41,169.45 109.41,169.15 109.43,169.12 109.43,169.11 109.45,169.11 109.46,169.1 109.97,169.1 109.99,169.07 109.99,168.7 109.99,168.59 109.81,168.41 108.37,168.41 108.35,168.43 108,168.43 107.86,168.57 107.86,169.71 108.11,169.96 109.76,169.96
+3.3V_ALW on BOTTOM (solid shape): 268,55.92 268,44.11 267.88,43.98 265.34,43.98 264.88,44.44 264.88,47.03 264.91,47.05 265.44,47.05 265.44,47.81 264.88,47.81 264.88,48.12 264.91,48.14 265.41,48.14 265.44,48.17 265.44,49.03 264.88,49.03 264.88,52.36 264.91,52.39 265.41,52.39 265.44,52.41 265.44,53.12 265.41,53.15 264.91,53.15 264.88,53.17 264.88,53.55 264.91,53.58 265.41,53.58 265.44,53.6 265.44,54.34 265.41,54.37 264.91,54.37 264.88,54.39 264.88,55.08 265.69,55.89 265.69,57.29 265.77,57.36 266.56,57.36
+3.3V_ALW on IN2 (solid shape): outline of 108 points within 55.03,107.74 57.82,112.02
+3.3V_ALW on IN2 (solid shape): outline of 146 points within 83.2,134.43 93.81,140.82
+3.3V_ALW on IN2 (solid shape): outline of 198 points within 255.3,25.82 267.12,55.03
+3.3V_ALW on IN4 (solid shape): outline of 327 points within 11.21,143.8 18.83,151.42
+3.3V_ALW on IN1: 168.58,83.6 168.67,83.55 168.68,83.46 168.78,83.01 169.24,83.04 169.31,83.06 169.38,83.04 169.83,83.01 169.94,83.46 169.94,83.55 170.03,83.6 170.98,83.6 171.23,83.35 171.23,80.58 171.2,80.57 171,80.25 171.2,79.93 171.23,79.92 171.23,79.03 170.98,78.78 162.59,78.78 162.34,79.03 162.34,79.67 162.39,79.76 162.49,79.76 163.03,80.07 162.49,80.38 162.39,80.38 162.34,80.47 162.34,83.35 162.59,83.6
+3.3V_ALW on VCC: outline of 513 points within 24.42,46.77 268.51,171.87
+3.3V_ALW_PCH on TOP (solid shape): 27.54,84.42 27.54,83.68 27.16,83.3 26.5,83.3 26.2,83.6 25.81,83.6 25.69,83.73 25.69,84.49 25.82,84.62 27.34,84.62
+3.3V_ALW_PCH on BOTTOM (solid shape): 55.3,104.94 55.3,103.19 55,102.89 53.62,102.89 53.09,103.42 53.09,105.08 53.26,105.25 54.99,105.25
+3.3V_ALW_PCH on BOTTOM (solid shape): 20.99,87.54 20.99,85.13 21.5,84.62 22.01,84.62 22.26,84.36 22.26,81.95 21.5,81.19 21.12,81.19 20.86,81.44 20.86,82.59 21.5,83.22 21.5,83.24 21.52,83.26 21.68,83.57 21.49,83.86 21.49,83.86 21.37,83.98 20.48,83.98 19.87,84.59 19.87,87.56 20.1,87.79 20.74,87.79
+3.3V_ALW_PCH on IN2 (solid shape): outline of 207 points within 20.86,81.06 36.1,84.46
+3.3V_ALW_PCH on IN2 (solid shape): outline of 1484 points within 19.86,95.16 43.34,102.53
+3.3V_ALW_PCH_U34 on BOTTOM (solid shape): 54.38,109.05 54.38,108.36 54.63,108.11 54.63,107.54 54.58,107.33 54.66,107.12 54.69,107.06 54.66,106.99 54.61,106.63 54.91,106.41 54.91,106.03 54.85,105.97 53.57,105.97 53.5,106.04 53.5,106.26 53.38,106.43 53.38,109.08 53.45,109.14 54.29,109.14
+3.3V_ALW_U46 on BOTTOM (solid shape): 208.62,76.24 208.7,76.24 209.2,75.73 209.2,74.84 209.1,74.74 206.94,74.74 206.87,74.81 206.87,76.16 207,76.28 208.58,76.28
+3.3V_ALW_U46 on IN2 (solid shape): outline of 1429 points within 208.06,75.47 226.35,82.84
+3.3V_ALW_VTR on BOTTOM (solid shape): 111.79,169.71 111.79,168.69 111.54,168.44 110.4,168.44 110.14,168.69 110.14,169.5 110.17,169.53 110.17,169.81 110.14,169.84 110.27,169.96 111.54,169.96
+3.3V_ALW_VTR on BOTTOM (solid shape): 98.21,149.36 98.21,148.12 97.95,147.86 94.9,147.86 94.55,148.22 94.55,149.41 94.75,149.62 94.82,149.62 94.88,149.64 97.92,149.64
+3.3V_ALW_VTR on IN4 (solid shape): outline of 1337 points within 95.16,147.99 114.97,161.96
+3.3V_LAN on TOP (solid shape): outline of 275 points within 117.18,155.48 150.53,173.67
+3.3V_LAN on BOTTOM (solid shape): 154.97,166.79 154.97,165.77 154.59,165.39 152.43,165.39 151.93,164.88 149.77,164.88 149.64,165.01 149.64,166.91 149.89,167.17 154.59,167.17
+3.3V_LAN on IN2 (solid shape): outline of 1463 points within 115.48,135.8 134.27,159.93
+3.3V_LAN_OUT on BOTTOM (solid shape): 121.83,155.74 121.83,153.58 121.32,153.58 121.19,153.71 121.19,155.74 121.32,155.87 121.7,155.87
+3.3V_LAN_OUT on IN2 (solid shape): outline of 515 points within 119.8,146.98 126.78,155.87
+3.3V_LAN_U63 on TOP (solid shape): 122.14,164.53 124.2,164.53 124.25,164.49 124.25,163.54 124.43,163.36 124.43,162.39 124.26,162.22 123.54,162.22 123,162.76 120.08,162.76 120.08,163.09 120.63,163.09 120.63,163.64 120.08,163.64 120.08,163.89 120.63,163.89 120.63,164.44 120.08,164.44 120.08,164.81 120.19,164.92 121.75,164.92
+3.3V_M on BOTTOM (solid shape): 51.09,99.1 51.09,98.08 50.38,97.37 49.77,97.37 49.56,97.57 49.56,99.1 49.82,99.35 50.83,99.35
+3.3V_M on BOTTOM (solid shape): 73.06,112.81 73.06,110.74 72.86,110.54 71.28,110.54 71.15,110.67 71.15,112.81 71.41,113.07 72.81,113.07
+3.3V_M on BOTTOM (solid shape): 126.1,114.67 126.1,113.29 126.01,113.2 126.01,111.55 125.74,111.28 125.65,111.28 125.34,110.96 124.68,110.96 124.68,111.43 124.13,111.43 124.13,111.72 124.68,111.72 124.68,112.23 124.13,112.23 124.13,112.52 124.69,112.52 124.69,114.37 125.24,114.92 125.84,114.92
+3.3V_M on IN2 (solid shape): 169.33,127.04 169.33,125.64 169.03,125.34 167,125.34 166.66,125.68 166.66,127.04 166.91,127.29 169.07,127.29
+3.3V_M on IN2 (solid shape): 73.5,111.19 73.5,110.23 73.35,110.08 71.45,110.08 71.29,110.23 71.29,111.11 71.52,111.34 73.35,111.34
+3.3V_M on IN2 (solid shape): 127.27,115.01 127.27,113.98 126.85,113.56 124.23,113.56 123.77,114.02 123.77,114.71 123.89,114.83 124.16,114.83 124.64,115.31 126.97,115.31
+3.3V_M on IN3 (solid shape): outline of 943 points within 161.2,125.64 172.75,140.63
+3.3V_M on IN4 (solid shape): 172.63,140.63 172.63,139.61 172.5,139.48 169.13,139.48 169.07,139.54 169.07,140.54 169.14,140.61 170.22,140.61 170.49,140.88 172.37,140.88
+3.3V_M_U35 on BOTTOM (solid shape): 124.52,112.98 124.56,112.98 124.56,112.65 124.01,112.65 124.01,112.1 124.55,112.1 124.55,111.85 124,111.85 124,111.3 124.55,111.3 124.55,110.02 124.42,109.89 122.81,109.89 122.29,109.37 121.54,109.37 121.47,109.45 121.47,110.31 121.07,110.71 121.07,111.7 121.23,111.86 122.81,111.86 123.06,112.11 123.06,112.66 123.38,112.98 124.51,112.98
+3.3V_MXM on TOP (solid shape): 55.12,97.61 55.12,97.59 55.15,97.56 55.15,96.18 55.03,96.05 53.76,96.05 53.48,96.32 53.45,96.42 53.52,96.49 53.77,96.93 53.33,97.18 53.26,97.19 53.21,97.24 53.12,97.38 52.99,97.47 52.99,97.7 53.12,97.83 54.08,97.83 54.9,97.83
+3.3V_MXM on BOTTOM (solid shape): 52.96,104.42 52.96,103.03 52.38,102.45 51.77,102.45 51.19,103.03 51.19,103.13 50.86,103.46 50.86,104.45 51.15,104.73 52.65,104.73
+3.3V_MXM on BOTTOM (solid shape): 54.8,101.07 54.8,101.04 55.14,100.65 55.51,101.02 55.54,101.1 55.61,101.13 56.68,101.13 56.93,100.87 56.93,99.73 57.18,99.48 57.18,98.97 56.93,98.72 56.56,98.72 56.46,98.77 56.48,98.88 56.16,99.45 55.96,98.83 55.99,98.75 55.96,98.68 55.84,98.44 55.91,98.19 55.91,96.05 55.79,95.92 53.88,95.92 53.43,96.37 53.56,96.51 53.57,96.51 53.76,96.96 53.33,97.18 53.26,97.19 53.21,97.24 53.17,97.32 53.11,97.39 52.99,97.51 52.99,98.08 53.84,98.92 54,99.05 54.13,99.21 54.39,99.48 54.39,100.87 54.64,101.13 54.74,101.13
+3.3V_MXM_U34 on BOTTOM (solid shape): 54.36,112.96 54.36,110.56 54.3,110.5 52.6,110.5 52.31,110.2 52.31,107.51 52.27,107.41 52.26,107.3 52.26,106.69 52.3,106.49 52.43,106.33 52.43,105.52 52.37,105.46 51.21,105.46 51.14,105.54 51.14,108.77 51.16,108.8 51.16,111.57 53.04,113.45 53.88,113.45
+3.3V_PCIE_FLASH on BOTTOM (solid shape): outline of 557 points within 92.48,133.62 118.39,146.64
+3.3V_PCIE_WWAN on BOTTOM (solid shape): outline of 95 points within 259.48,65.65 267.4,77
+3.3V_PCIE_WWAN on IN2 (solid shape): outline of 1244 points within 247.18,65.82 263.05,89.32
+3.3V_PCIE_WWAN_U43 on BOTTOM (solid shape): 272.17,71.91 272.17,59.24 271.74,58.8 265.79,58.8 265.67,58.92 265.67,60.09 266.07,60.49 267.68,60.49 268,60.82 268,68.79 267.52,69.27 266.2,70.59 266.2,71.15 266.75,71.15 266.75,71.7 266.2,71.7 266.2,71.95 266.75,71.95 266.75,72.49 266.2,72.49 266.2,72.9 266.29,72.99 271.1,72.99
+3.3V_RUN on TOP (solid shape): 133.64,34.96 133.64,33.31 133.38,33.06 131.73,33.06 131.48,33.31 131.48,34.83 131.86,35.22 133.38,35.22
+3.3V_RUN on TOP (solid shape): 170.09,62.77 172.75,62.77 173.01,62.52 173.01,60.74 172.75,60.49 171.36,60.49 171.1,60.23 171.1,59.98 171.36,59.73 195.74,59.73 196,59.47 196,56.42 195.74,56.17 191.04,56.17 190.28,56.93 168.56,56.93 168.31,57.19 168.31,60.51 167.91,60.91 167.28,60.91 167.22,60.96 167.22,63.25 167.27,63.3 169.56,63.3
+3.3V_RUN on TOP (solid shape): 88.43,155.1 88.43,154.21 89.19,153.45 89.19,143.42 90.69,141.92 90.69,138.91 93.51,136.1 93.51,132.75 92.87,132.12 92.62,132.12 91.73,133.01 91.73,135.67 89,138.4 89,141.23 87.54,142.69 87.54,152.69 86.52,153.71 86.52,155.1 86.78,155.36 88.17,155.36
+3.3V_RUN on TOP (solid shape): outline of 88 points within 11.97,71.79 19.21,80.43
+3.3V_RUN on TOP (solid shape): outline of 3707 points within 226.73,65.95 249.34,93.25
+3.3V_RUN on BOTTOM (solid shape): 209.2,80.17 209.2,78.65 208.95,78.4 208.6,78.4 207.96,79.03 207.93,79.03 207.81,79.16 207.81,80.17 208.06,80.43 208.95,80.43
+3.3V_RUN on BOTTOM (solid shape): 254.63,109.29 254.63,107.88 254.44,107.68 253.85,107.68 253.25,107.08 252.31,107.08 251.79,107.61 251.79,108.38 252.83,109.42 254.5,109.42
+3.3V_RUN on BOTTOM (solid shape): 157.72,117.13 157.72,116.9 157.69,116.88 157.16,116.88 157.16,116.42 157.18,116.39 157.69,116.39 157.72,116.37 157.72,116.11 157.46,115.86 156.37,115.86 156.12,116.11 156.12,117.04 156.46,117.38 157.46,117.38
+3.3V_RUN on BOTTOM (solid shape): 247.28,93.76 247.28,91.43 245.95,90.11 244.58,90.11 244.2,90.11 244,90.3 244,90.72 244,90.72 244,90.84 244.48,91.32 244.48,91.35 244.64,91.51 244.64,93.58 244.87,93.82 247.22,93.82
+3.3V_RUN on BOTTOM (solid shape): 27.47,160.31 27.47,158.66 26.96,158.15 26.93,158.17 26.67,158.19 26.47,158.02 25.82,158.02 25.56,158.28 25.56,160.44 25.94,160.82 26.96,160.82
+3.3V_RUN on BOTTOM (solid shape): 86.01,155.61 87.01,155.61 87.03,155.61 88.3,155.61 88.68,155.23 88.68,153.2 88.05,152.56 86.57,152.56 86,151.99 86,151.27 85.9,151.17 84.49,151.17 84.31,151.34 84.31,153.27 85.23,154.19 85.23,155.24 85.23,155.28 85.23,156.07 85.23,156.1 85.33,156.2 85.43,156.2
+3.3V_RUN on BOTTOM (solid shape): 261.83,149.91 261.83,148.25 264.31,145.77 264.31,142.63 263.32,141.64 262.14,141.64 262.01,141.67 261.88,141.64 261.88,141.64 260.64,141.64 260,142.28 260,142.46 260.02,142.56 260,142.65 260,145.06 260.63,145.68 260.63,147.39 260.31,147.71 260.31,150 260.59,150.28 261.46,150.28
+3.3V_RUN on BOTTOM (solid shape): 45.5,84.49 46.01,84.49 46.26,84.24 46.26,83.6 45.9,83.24 45.87,83.25 45.72,83.27 45.57,83.22 45.23,83.22 45.04,83.27 44.86,83.22 44.07,83.22 43.85,83.3 43.63,83.22 42.96,83.22 42.71,83.48 42.71,84.49 42.96,84.75 45.25,84.75
+3.3V_RUN on BOTTOM (solid shape): 16.48,107.59 16.48,106.23 16.93,105.79 16.93,103.92 16.8,103.8 16.34,103.8 16.23,103.68 16.23,102.41 16.18,102.36 15.42,102.36 15.33,102.45 15.33,103.51 15.02,103.82 15.02,104.43 14.88,104.57 14.87,104.58 14.81,104.66 14.74,104.71 14.73,104.72 14.65,104.8 12.39,104.8 12.18,105.01 12.18,106.8 12.27,106.89 12.53,106.89 12.91,106.51 12.91,106.14 13.45,105.6 14.31,105.6 14.63,105.27 15.49,105.27 15.57,105.28 15.65,105.31 15.66,105.32 15.78,105.32 15.91,105.45 15.91,105.83 15.56,106.18 15.49,106.18 15.46,106.21 15.46,107.64 15.54,107.73 16.34,107.73
+3.3V_RUN on BOTTOM (solid shape): outline of 200 points within 24.04,109.71 27.21,115.1
+3.3V_RUN on IN1 (solid shape): outline of 1203 points within 15.78,150.67 30.01,166.15
+3.3V_RUN on IN2 (solid shape): outline of 700 points within 25.56,99.22 31.28,110.27
+3.3V_RUN on IN2 (solid shape): outline of 880 points within 107.73,133.01 118.78,157.9
+3.3V_RUN on IN2 (solid shape): outline of 3738 points within 15.78,147.61 40.55,165.9
+3.3V_RUN on IN3 (solid shape): 39.15,148.22 39.15,144.44 37.88,143.17 36.23,143.17 35.91,143.48 35.91,144.94 35.98,145.04 36.09,145.01 36.7,145.33 36.01,145.34 36,145.3 35.91,145.3 35.91,145.39 35.85,145.45 35.85,146.15 38.33,148.63 38.74,148.63
+3.3V_RUN on IN4 (solid shape): 256.14,110.54 256.14,108.31 255.51,107.68 253.66,107.68 253.5,107.83 253.5,110.32 254,110.82 255.86,110.82
+3.3V_RUN on IN4 (solid shape): 262.67,144.82 262.67,142.15 262.16,141.64 262.14,141.64 262.01,141.67 261.88,141.64 261.88,141.64 260.64,141.64 260,142.28 260,144.82 260.51,145.32 262.16,145.32
+3.3V_RUN on IN4 (solid shape): outline of 349 points within 237.63,89.25 245.92,94.34
+3.3V_RUN on IN4 (solid shape): outline of 4031 points within 129.7,26.33 172.88,61.38
+3.3V_RUN on BOTTOM: 10.4,95.01 10.19,95.22 10.19,99.53 10.65,99.99 10.65,101.74 10.8,101.89 12.61,101.89 12.86,101.64 12.86,100.11 13.12,99.86 14.89,99.86 14.91,99.87 16.04,101 16.93,101 17.18,100.75 17.18,98.84 16.93,98.59 15.15,98.59 14.51,99.22 14.49,99.22 14.48,99.23 14.3,99.27 14.12,99.22 12.23,99.22 11.97,98.97 11.97,98.92 11.97,98.91 11.96,98.83 11.97,98.75 11.97,98.74 11.97,98.59 12.1,98.46 12.73,98.46 12.86,98.33 12.86,94.55 12.74,94.43 12.13,94.43 12.06,94.5 12.06,94.88 11.93,95.01 11.88,95.01 11.87,95.02 11.67,95.07 11.48,95.01
+3.3V_RUN on BOTTOM: 90.6,132.3 89.66,133.24 89.66,133.25 89.48,133.44 89.48,133.46 89.46,133.58 89.4,133.69 89.4,136.3 89.54,136.59 89.4,136.87 89.4,137.04 89.25,137.19 86.91,137.19 86.91,137.74 86.91,137.74 86.36,137.74 86.36,138.04 86.91,138.04 86.91,138.54 86.36,138.54 86.36,138.84 86.91,138.84 86.91,139.42 86.91,139.42 86.88,139.48 87.5,140.09 91.76,140.09 91.84,140.05 91.84,139.95 91.83,139.71 92.01,139.46 92,139.39 92.08,138.98 92.5,138.93 92.61,138.93 92.66,138.83 92.7,138.48 92.89,138.18 93.35,137.95 93.86,138.05 93.96,138.06 94.01,137.97 94.01,135.83 93.99,135.82 93.99,132.97 93.32,132.3
+3.3V_RUN on VCC: outline of 839 points within 14.64,33.95 268.51,146.98 ; 1 cut-out
+3.3V_RUN on IN2: 37.88,138.59 36.99,137.7 36.99,135.46 36.52,134.99 35.26,134.99 34.83,135.42 34.83,142.66 36.1,143.93 36.99,143.93 37.88,144.82 39.15,144.82 39.4,144.56 39.4,139.12 38.87,138.59
+3.3V_RUN_TPM on BOTTOM (solid shape): 158.66,117 158.66,116.62 158.78,116.5 160.31,116.5 160.56,116.24 160.56,115.86 160.44,115.73 159.17,115.73 158.53,115.1 158.53,113.45 158.78,113.19 160.18,113.19 160.44,112.94 160.44,112.56 160.32,112.45 160.29,112.45 160.14,112.3 158.15,112.3 157.87,112.58 157.87,116.52 157.84,116.55 157.34,116.55 157.31,116.57 157.31,116.67 157.34,116.7 157.87,116.7 157.9,116.72 157.9,117.13 158.02,117.26 158.4,117.26
+3.3V_RUN_TPM on IN2 (solid shape): outline of 121 points within 158.15,112.44 170.55,117.77
+3.3V_RUN_U38 on BOTTOM (solid shape): 86.78,139.34 86.78,138.96 86.23,138.96 86.23,138.41 86.78,138.41 86.78,138.17 86.23,138.17 86.23,137.61 86.78,137.61 86.78,137.29 86.77,137.3 83.75,137.3 83.65,137.4 83.65,140.1 83.86,140.32 85.81,140.32
+3.3V_SUS on TOP (solid shape): 44.35,27.22 44.37,27.22 44.37,27.22 44.88,27.22 44.88,27.22 44.9,27.22 44.9,27.74 45.15,27.74 45.15,27.22 45.17,27.22 45.17,27.22 46.18,27.22 46.27,27.13 46.27,26.89 46.17,26.8 46.17,25.89 45.85,25.57 44.75,25.57 43.5,26.82 43.5,27.12 43.59,27.22 44.08,27.22 44.08,27.22 44.1,27.22 44.1,27.74 44.35,27.74
+3.3V_SUS on BOTTOM (solid shape): outline of 129 points within 49.56,2.32 53.88,8.93
+3.3V_SUS_U57 on TOP (solid shape): 47.78,34.06 47.78,30.58 47.19,29.98 46.87,29.98 46.52,29.63 46.52,27.62 46.25,27.35 45.28,27.35 45.28,27.87 44.77,27.87 44.77,27.35 44.48,27.35 44.48,27.87 43.97,27.87 43.97,27.35 43.56,27.35 43.5,27.41 43.5,28.16 43.63,28.28 43.96,28.28 45.71,30.03 45.9,30.23 45.9,31.5 45.7,31.7 45.65,31.7 45.65,32.76 45.08,32.76 44.97,32.87 44.97,34.21 45.13,34.37 47.48,34.37
+3.3V_WLAN on TOP (solid shape): 124.49,168.33 124.49,166.8 124.25,166.56 124.25,166 124.18,165.93 123.5,165.93 123.31,166.13 123.31,168.2 123.51,168.4 124.41,168.4
+3.3V_WLAN on TOP (solid shape): outline of 1201 points within 138.34,138.85 153.96,163.87
+3.3V_WLAN on BOTTOM (solid shape): 150.15,146.21 151.13,146.21 151.19,146.16 151.85,146.16 152.05,145.96 152.05,143.55 151.93,143.42 150.28,143.42 150.02,143.67 150.02,144.82 148.88,145.96 148.5,145.96 148.24,146.21 148.24,146.85 148.5,147.1 149.26,147.1
+3.3V_WLAN on BOTTOM (solid shape): 137.05,157.87 137.05,156.76 136.92,156.63 135.04,156.63 134.53,156.12 133.74,156.12 130.46,156.12 130.44,156.14 130.44,157.36 130.59,157.52 130.97,157.52 131.1,157.39 132.73,157.39 132.75,157.39 133.64,157.39 133.66,157.39 134.53,157.39 135.19,158.05 136.87,158.05
+3.3V_WLAN on IN2 (solid shape): outline of 118 points within 130.08,152.31 139.61,157.52
+3.3V_WLAN on IN2 (solid shape): outline of 253 points within 123.31,158.93 143.62,167.64
+3VALWP on BOTTOM (solid shape): 263.81,55.54 264.06,55.54 264.06,55.53 264.45,55.53 264.7,55.28 264.7,43.47 264.45,43.22 259.11,43.22 258.86,43.47 258.86,57.31 259.11,57.57 261.78,57.57
+5V_ALW on TOP (solid shape): 22.64,144.44 22.64,143.29 22.51,143.17 22.26,143.17 22.13,143.29 21.62,143.29 21.5,143.42 21.5,144.44 21.62,144.56 22.51,144.56
+5V_ALW on TOP (solid shape): 43.6,31.41 43.6,30.67 43.83,30.43 43.83,29.95 44.1,29.69 44.1,29.27 43.89,29.07 43.19,29.07 42.96,29.29 42.96,30.65 42.96,30.65 42.96,31.48 43.01,31.53 43.47,31.53
