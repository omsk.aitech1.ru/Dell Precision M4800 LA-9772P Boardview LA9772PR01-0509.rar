# Allegro board LA9772PR01-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML1_SMBDATA: length 162.8
  TOP w0.102: UH1.N11 29.64,94.1 v1(29.29,93.75)
  IN1 w0.109: v1(23.63,86.98) 23.8,87.15 24.09,87.15 25.44,88.51 25.44,89.37 25.74,89.67 27.04,89.67 28.67,91.3 28.67,93.26 29.16,93.75 v1(29.29,93.75) ; v1(109.91,158.35) 109.64,158.07 107.43,158.07 107.17,157.82 106.56,157.82 104.62,155.87 102.71,155.87 101.34,154.5 101.34,153.56 100.97,153.19 99.85,153.19 98.79,152.13 98.79,148.47 97.27,146.95 97.27,139.23 97.67,138.83 97.67,137.3 97.27,136.9 97.27,131.19 97.7,130.76 97.7,127.93 96.76,126.99 96.76,123.71 96.4,123.35 96.4,118.07 97.11,117.36 97.11,116.77 v1(97.32,116.57)
  IN3 w0.127: v1(97.32,116.57) 97.19,116.44 97.19,116.06 96.83,115.71 91.75,115.71 91.47,115.99 87.59,115.99 86.29,114.69 86.29,111.36 85.38,110.45 85.38,106.13 81.98,102.73 79.94,102.73 78.33,101.12 75.21,101.12 72.82,98.72 72.82,98.05 72.02,97.24 71.07,97.24 69.4,95.58 69.4,94.8 67.47,92.87 64.45,92.87 64,92.42 57.08,92.42 56.65,91.98 55.99,91.98 54.54,90.54 54.54,89.11 52.61,87.18 49.97,87.18 49.49,86.7 46.8,86.7 45.53,85.43 42.6,85.43 40.77,87.26 37.68,87.26 37.48,87.06 35.87,87.06 34.17,88.76 32.14,88.76 31.2,89.7 30.49,89.7 28.2,87.41 26.12,87.41 25.18,86.47 24.61,86.47 23.97,87.12 23.77,87.12 v1(23.63,86.98)
  BOTTOM w0.102: v1(109.91,158.35) 109.84,158.27 U51.A5 ; RPH5.4 21.79,86.15 21.93,86.29 22.74,86.29 23.15,86.7 23.15,86.99 23.32,87.16 23.45,87.16 v1(23.63,86.98)
SNB_CPU_P1: length 2.6
  TOP w0.102: v2(47.84,65.4) 48.48,64.76 PR554.1
SNB_CPU_P2: length 3.4
  TOP w0.102: PC523.2 v2(52.92,39.85)
  TOP w0.508: PR542.1 51.34,38.07 PC523.2
SNB_CPU_P3: length 1.4
  TOP w0.102: PC507.2 48.48,76.07 v2(48.78,76.36)
SNUB_1.5VSP: length 1.3
  BOTTOM w0.102: PR401.2 v2(255.63,27.53)
SNUB_1.35V: length 2.1
  BOTTOM w0.102: PR202.2 v2(187.17,76.68)
SNUB_3V: length 2.9
  BOTTOM w0.102: PC116.1 v2(249.47,57.54)
  BOTTOM w0.508: PR109.2 249.47,54.82 PC116.1
SNUB_5V: length 4.5
  BOTTOM w0.102: v2(240.64,56.84) 240.75,56.96 242.45,56.96 PC119.1
  BOTTOM w0.635: PR110.2 243.34,56.07 PC119.1
SNUB_CHG: length 2.8
  BOTTOM w0.102: PC717.1 187,53.93 v2(186.99,53.95)
  BOTTOM w0.635: PR724.2 189.12,53.93 PC717.1
SOFT_START_GC: length 165.3
  TOP w0.381: PR20.2 19.59,71.79 v1(20.35,72.55)
  IN3 w0.381: v1(20.35,72.55) 19.72,73.19 19.72,75.09 21.66,77.04 32.13,77.04 32.56,77.47 34.4,77.47 34.64,77.23 46.01,77.23 48.21,79.42 51.44,79.42 52.17,80.16 54.84,80.16 55.59,80.91 55.59,82.29 v1(59.9,86.6)
  IN4 w0.381: v1(146.82,115.78) 146.85,115.76 152.54,115.76 v1(153.2,116.42)
  BOTTOM w0.254: PU1001.2 v1(153.2,116.42)
  BOTTOM w0.381: v1(146.82,115.78) 145.67,115.78 141.75,111.86 132.3,111.86 127.75,116.41 123.1,116.41 117.75,111.06 117.75,108.91 115.57,106.73 113.58,106.73 110.91,104.05 100.29,104.05 v2(98.53,102.3) 94.22,97.98 94.22,97.72 93.1,96.61 92.69,96.61 87.98,91.9 87.98,91.23 87.51,90.76 83.02,90.76 79.76,94.02 75.45,94.02 68.03,86.6 v1(59.9,86.6)
SP_TPM_LPC_EN: length 83.7
  TOP w0.102: v1(221.22,83.73) 221.19,83.75 221.19,83.77 221.4,83.99 221.4,85.69 220.83,86.27 220.83,87.68 v1(221.26,88.11)
  IN3 w0.127: v1(165.07,119.9) 165.27,119.7 167.33,119.7 172.03,114.99 172.03,107.15 180.74,98.44 195.82,98.44 202.68,91.58 206.13,91.58 208.82,88.89 215.61,88.89 215.96,88.53 220.84,88.53 v1(221.26,88.11)
  BOTTOM w0.102: v1(221.22,83.73) 221.67,83.27 U46.B56 ; R2188.1 162.21,120.2 v2(163.42,120.2) 164.77,120.2 v1(165.07,119.9)
SP_TPM_LPC_EN_R: length 4.5
  BOTTOM w0.102: v2(161.01,120.95) R2188.2 161.01,119.73 R2189.2 160.38,118.55 U39.28
SPI_CLK32: length 12.7
  BOTTOM w0.102: U53.6 55.66,93.43 RE2.1 56.14,93.56 56.4,93.81 56.4,95.26 56.52,95.39 59.17,95.39 59.42,95.64 59.62,95.64 59.77,95.49 59.77,94.98 59.65,94.85 59.06,94.85 58.94,94.73 58.94,93.99 58.81,93.86 v2(58.49,93.86) 58.28,93.86 58.15,93.99 58.15,94.78 58.02,94.91 57.44,94.91 57.31,94.78 R897.1
SPI_CLK64: length 12.7
  BOTTOM w0.102: R899.1 49.72,94.47 50.76,95.51 51.05,95.51 52.05,96.52 52.05,96.67 51.79,96.94 51.63,96.94 50.79,96.1 v4(50.34,96.1) 49.97,96.1 49.87,96 49.87,95.74 50.02,95.59 50.02,95.46 49.69,95.13 49.51,95.13 49.23,95.41 48.88,95.41 48.78,95.31 48.78,95.16 49.13,94.8 49.13,94.02 RE1.1 48.98,93.56 49.13,93.41 49.13,93.03 48.98,92.87 48.83,92.87 48.73,92.77 48.73,92.52 48.8,92.44 U52.6
SPI_DIN32: length 12.8
  BOTTOM w0.102: U53.2 56.93,83.7 57.06,83.58 57.72,83.58 57.84,83.45 57.84,83.28 57.72,83.15 56.7,83.15 56.57,83.28 56.57,83.6 56.45,83.73 56.24,83.73 56.12,83.6 56.12,82.59 56.19,82.51 56.39,82.51 56.63,82.75 v2(56.97,82.75) 57.64,82.75 57.74,82.64 57.74,82.44 57.64,82.34 56.83,82.34 56.73,82.24 56.73,81.44 56.85,81.32 57.08,81.32 57.21,81.44 57.21,81.83 57.31,81.93 57.64,81.93 57.74,81.83 57.74,80.76 57.62,80.63 57.18,80.63 R895.2
SPI_DIN64: length 12.9
  BOTTOM w0.102: U52.2 50.07,83.58 50.53,83.12 50.53,81.67 50.94,81.27 51.8,81.27 51.93,81.39 51.93,82.1 52.05,82.23 52.41,82.23 52.54,82.1 52.54,81.58 52.48,81.52 v4(52.48,81.25) 52.48,80.8 52.41,80.73 49.49,80.73 49.34,80.88 49.34,82.31 49.69,82.66 R8.2
SPI_DO32: length 12.7
  BOTTOM w0.102: R900.1 53.88,93.89 53.76,94.02 53.32,94.02 53.06,93.75 53.06,93.65 53.22,93.49 53.22,92.01 53.35,91.88 53.65,91.88 53.78,92.01 53.78,93 53.91,93.13 54.24,93.13 54.36,93.25 54.36,94.99 54.48,95.11 55.03,95.11 55.25,94.88 55.25,94.73 55.13,94.6 54.9,94.6 54.77,94.47 54.77,94.32 v2(54.83,94.26) 54.9,94.19 55.15,94.19 55.28,94.07 55.28,93.91 55.15,93.79 54.9,93.79 54.77,93.66 54.77,93.46 54.95,93.28 54.95,93.15 54.39,92.59 U53.5
SPI_DO64: length 12.8
  BOTTOM w0.102: U52.5 47.53,91.3 46.29,90.05 45.22,90.05 45.09,89.93 v4(45.09,89.81) 45.09,89.6 45.22,89.47 46.9,89.47 48.12,90.69 48.12,92.62 47.86,92.87 46.52,92.87 46.21,93.18 46.21,93.69 46.54,94.02 R901.1
SPI_PCH_CLK: length 45.2
  TOP w0.102: v1(52.03,84.41) RH181.1 51.98,85.3 53.37,85.3 53.53,85.47 JSPI1.7
  IN4 w0.109: v1(55.66,89.88) 55.66,89.24 52.03,85.61 v1(52.03,84.41)
  BOTTOM w0.102: R899.2 49.82,93.56 50,93.38 50,92.9 49.41,92.31 49.41,91.12 48.27,89.98 48.27,89.49 48.5,89.27 49.28,89.27 49.67,88.89 49.67,88.33 49.77,88.22 50.07,88.22 50.2,88.35 50.2,88.81 50.33,88.94 50.58,88.94 50.71,88.81 50.71,88.35 50.83,88.22 51.16,88.22 51.27,88.33 51.27,88.86 51.42,89.01 52.78,89.01 53.21,88.58 54.36,88.58 54.46,88.68 54.46,90.31 54.59,90.43 54.82,90.43 54.95,90.31 54.95,88.71 55.08,88.58 55.3,88.58 55.43,88.71 55.43,88.96 55.56,89.09 55.79,89.09 55.91,88.96 55.91,88.71 56.04,88.58 56.3,88.58 56.42,88.71 56.42,89.52 56.07,89.88 v1(55.66,89.88) 56.27,90.49 56.27,92.64 56.4,92.77 v2(60.16,92.77) 60.59,92.77 60.71,92.9 60.71,93.13 60.59,93.25 57.44,93.25 57.31,93.38 R897.2
SPI_PCH_CS0#: length 13.7
  TOP w0.102: v1(50.45,86.24) 51.04,86.24 RH182.1 51.48,86.58 v2(53.31,86.58) 53.9,86.58 54.01,86.47 JSPI1.9
  BOTTOM w0.102: R7.1 51.22,81.62 51.08,81.62 50.88,81.82 50.88,83.27 50.58,83.57 50.58,85.2 50.88,85.51 52.7,85.51 52.79,85.6 52.79,85.72 52.7,85.81 50.88,85.81 50.76,85.94 50.76,86.12 50.63,86.24 v1(50.45,86.24)
SPI_PCH_CS0#_R: length 12.7
  BOTTOM w0.102: U52.1 51.34,83.81 51.47,83.68 52.31,83.68 52.43,83.81 52.43,84.19 52.56,84.31 52.79,84.31 52.92,84.19 52.92,83.72 53.04,83.6 53.2,83.6 53.32,83.72 53.32,84.52 53.45,84.64 53.68,84.64 53.81,84.52 53.81,83.83 54.14,83.5 54.14,83.25 54.03,83.14 53.3,83.14 53.17,83.02 53.17,82.4 53.05,82.28 52.88,82.28 52.76,82.4 52.76,83.12 52.64,83.25 v4(52.51,83.25) 52.41,83.25 52.28,83.12 52.28,82.73 52.16,82.61 51.99,82.61 51.88,82.73 51.88,83.17 51.75,83.3 51.34,83.3 51.24,83.2 51.24,82.76 R7.2
SPI_PCH_CS1#: length 11.8
  TOP w0.102: v1(52.57,79.2) 52.85,79.2 RH177.1 54.14,80.43 54.59,80.88 54.59,82.42 JSPI1.1
  BOTTOM w0.102: v1(52.57,79.2) v2(55.46,79.2) 56.98,79.2 58.2,80.42 R936.1
SPI_PCH_CS1#_R: length 12.8
  BOTTOM w0.102: U53.1 58.2,85.23 58.33,85.35 58.58,85.35 58.89,85.05 58.89,84.49 60,83.37 60,83.07 59.88,82.94 59.44,82.94 59.32,82.81 59.32,82.56 59.44,82.43 v2(59.7,82.43) 59.88,82.43 60,82.31 60,82.03 59.88,81.9 59.47,81.9 59.34,81.77 59.34,81.54 59.47,81.42 59.83,81.42 59.95,81.29 59.95,81.09 59.83,80.96 59.09,80.96 58.89,81.16 58.89,83.24 58.76,83.37 58.27,83.37 58.2,83.3 R936.2
SPI_PCH_DIN: length 16.8
  TOP w0.102: v1(56.07,80.55) v2(54.4,78.89) 53.93,78.42 52.26,78.42 49.87,80.81 v1(49.87,81.14) 49.87,81.94 50.5,82.57 RH179.1 51.44,82.93 51.87,82.93 53.27,84.33 53.76,84.33 53.9,84.47 JSPI1.5
  BOTTOM w0.102: v1(49.87,81.14) 50.07,81.34 R8.1 ; R895.1 56.65,79.97 v1(56.07,80.55)
SPI_PCH_DO: length 37.8
  TOP w0.102: v1(53.17,94.4) 54.87,92.7 55.39,92.7 56.42,91.66 56.42,82.77 55.43,81.78 55.43,80.96 53.25,78.78 52.41,78.78 v2(51.92,79.27) 51.92,81.65 RH178.1 53.74,83.47 JSPI1.3
  IN4 w0.109: v1(53.17,94.4) 53.04,94.27 52.5,94.27 50.96,92.73 47.57,92.73 46.88,92.03 v1(46.72,92.03)
  BOTTOM w0.102: R901.2 45.86,93.89 45.86,93.03 46.72,92.17 v1(46.72,92.03) ; R900.2 53.25,94.47 v1(53.17,94.4)
SPI_PCH_DO2: length 19.5
  TOP w0.102: v1(50.45,88.02) 50.5,87.97 RH183.1 51.3,87.76 v2(52.19,87.76) 53.64,87.76 53.92,87.47 JSPI1.11
  IN4 w0.109: v1(53.6,81.06) 51.29,83.37 51.29,87.13 50.45,87.97 v1(50.45,88.02)
  BOTTOM w0.102: R9.1 48.98,81.57 48.98,80.74 49.34,80.38 52.92,80.38 v1(53.6,81.06) 53.6,81.72 R3667.1
SPI_PCH_DO2_32: length 12.7
  BOTTOM w0.102: U53.3 55.66,85.38 55.79,85.51 57.92,85.51 58.05,85.63 58.05,85.89 57.92,86.02 55.03,86.02 54.85,85.84 54.85,85.53 55,85.38 55,83.35 55.13,83.22 55.53,83.22 55.66,83.09 R3665.2 RH186.1 R3667.2
SPI_PCH_DO2_64: length 12.8
  BOTTOM w0.102: R9.2 RH180.1 R3664.2 46.9,82.54 45.73,81.37 44.05,81.37 43.93,81.49 43.93,82.13 44.05,82.26 v4(44.6,82.26) 45.68,82.26 46.21,82.79 46.21,83.12 46.41,83.32 48.57,83.32 48.8,83.55 U52.3
SPI_PCH_DO3: length 23.3
  TOP w0.102: JSPI1.13 52.78,88.47 51.5,89.75 RH184.1 51.09,89.67 51.88,88.89 v1(51.88,88.61)
  IN3 w0.127: v1(52.41,95.08) 52.41,93.79 51.88,93.25 v1(51.88,88.61)
  BOTTOM w0.102: R3670.2 59.06,87.29 58.37,87.97 52.96,87.97 52.53,88.4 52.08,88.4 v1(51.88,88.61) ; R3669.2 51.01,94.91 51.32,94.91 v4(52.03,95.62) 52.23,95.62 52.41,95.44 v1(52.41,95.08)
SPI_PCH_DO3_32: length 12.8
  BOTTOM w0.102: U53.7 56.93,90.18 57.72,89.39 59.47,89.39 59.65,89.22 R3666.2 59.65,88.05 59.77,87.92 60.05,87.92 60.18,88.05 60.18,88.23 60.3,88.35 60.47,88.35 60.59,88.23 60.59,88.05 60.71,87.92 60.99,87.92 61.12,88.05 61.12,88.68 61.25,88.81 61.5,88.81 61.63,88.68 61.63,88.05 61.76,87.92 62.14,87.92 62.26,87.79 62.26,87.41 62.14,87.29 v2(61.76,87.29) R3670.1
SPI_PCH_DO3_64: length 12.8
  BOTTOM w0.102: R3669.1 R3668.2 50.76,92.85 50.76,90.82 50.91,90.66 51.49,90.66 52.13,90.03 52.13,89.73 52.02,89.62 51.75,89.62 51.62,89.75 51.62,89.93 51.5,90.05 51.33,90.05 51.22,89.93 51.22,89.65 51.11,89.55 50.88,89.55 50.78,89.65 50.78,90.26 50.68,90.36 50.45,90.36 50.35,90.26 50.35,89.85 50.25,89.75 49.79,89.75 49.44,90.1 49.44,90.23 49.59,90.38 49.97,90.38 50.07,90.49 U52.7
SPI_WP#_SEL: length 211.6
  IN2 w0.127: v1(54.19,81.06) 54.19,81.34 55.27,82.42 67.51,82.42 69.37,84.29 80.53,84.29 85.39,89.15 85.39,91.92 86.42,92.95 88.3,92.95 90.11,94.77 92.31,94.77 92.35,94.8 113.84,94.8 113.88,94.77 115.1,94.77 115.7,95.36 117.06,95.36 118.28,94.14 131.1,94.14 133.73,96.77 133.73,97.52 134.85,98.64 138.56,98.64 139.62,97.57 154.21,97.57 154.89,96.89 158.72,96.89 162.15,93.46 176.34,93.46 177.94,91.86 v1(177.94,91.91)
  BOTTOM w0.102: U46.A12 216.17,75.48 215.93,75.25 215.93,74.13 215.86,74.05 215.86,72.07 215.49,71.7 213.86,71.7 212.53,70.37 207.78,70.37 204.25,73.9 204.25,82.51 204,82.76 204,87.89 204.54,88.43 204.54,90.43 202.9,92.06 196.36,92.06 191.71,96.71 182.74,96.71 v1(177.94,91.91) ; RH180.2 47.94,81.75 48.62,81.06 48.62,80.59 v2(48.81,80.41) 49.19,80.02 53.22,80.02 54.19,80.99 v1(54.19,81.06) 54.19,81.29 RH186.2
SPKR: length 43
  TOP w0.102: JIO1.76 14.01,88.8 v1(14.28,88.53) ; UH1.AL10 37.49,93.51 v1(37.67,93.69)
  IN3 w0.127: v1(37.67,93.69) 38.16,93.2 38.16,91.25 37.52,90.61 30.23,90.61 27.87,88.25 23.53,88.25 22.94,87.67 22.94,86.85 22.69,86.6 22.28,86.6 21.27,87.62 19.57,87.62 17.26,89.93 16.57,89.93 15.96,89.32 15.1,89.32 14.31,88.53 v1(14.28,88.53)
  BOTTOM w0.102: RH34.2 39.68,85.08 v2(38.41,86.35) 37.75,87.01 37.75,88.02 36.81,88.96 36.81,91.4 37.26,91.85 37.26,93.27 37.67,93.68 v1(37.67,93.69)
SRTCRST#: length 9.4
  TOP w0.102: v1(22.82,93.52) 22.82,93.44 23.2,93.06 23.6,93.06 23.95,93.41 24.33,93.41 24.43,93.51 25,93.51 UH1.B9
  BOTTOM w0.102: ME1.2 RH42.2 17.76,93.64 18.14,94.02 19.41,94.02 CH6.2 19.93,93.5 v2(21.26,93.5) 22.79,93.5 v1(22.82,93.52)
STSTART_DCBLOCK_GC: length 2.5
  BOTTOM w0.254: PU1001.16 146.57,121.28 PR1002.1
SUS_ON: length 421.8
  TOP w0.102: v1(230.74,73.16) 230.29,73.16 225.15,78.29 225.15,79.69 224.9,79.94 223.4,79.94 222.03,81.32 221.65,81.32 221.19,81.77 v1(221.19,81.77) ; U57.5 44.68,30.62 44.85,30.45 44.85,29.45 43.89,28.48 43.48,28.48 43.24,28.24 43.24,26.79 44.51,25.52 44.51,18.1 45.1,17.51 v2(45.38,17.23) 45.53,17.08 46.19,17.08 v1(46.58,16.69)
  IN1 w0.109: v1(230.74,73.16) 231.02,72.88 233.71,72.88 234.37,73.54 244.83,73.54 245.77,74.48 251.33,74.48 255.28,78.44 260.5,78.44 269.67,69.27 269.67,47.33 264.58,42.25 253.93,42.25 250.28,38.6 236.57,38.6 222.62,24.65 221.52,24.65 220.88,24.01 201.74,24.01 201.13,24.62 195.56,24.62 194.23,23.29 132.96,23.29 132.39,23.86 108.04,23.86 104.64,27.26 96.11,27.26 95.39,27.99 89.43,27.99 88.66,27.21 83.07,27.21 75.07,19.21 75.07,15.75 71.61,12.3 60.55,12.3 55.16,17.69 52.45,17.69 v1(50.35,15.59)
  IN3 w0.127: v1(50.35,15.59) 49.97,15.97 47.8,15.97 47.09,16.69 v1(46.58,16.69)
  IN4 w0.109: v1(230.74,73.16) 230.74,72.69 228.9,70.85 228.9,69.98 227.36,68.44 227.36,66.76 223.37,62.77 220.51,62.77 220.15,63.13 209.41,63.13 203.04,69.51 v1(202.29,69.51)
  BOTTOM w0.102: v1(202.29,69.51) 202.29,70.15 200.33,72.12 200.33,73.49 196.71,77.11 189.55,77.11 181.93,84.73 179.79,84.73 177.96,82.91 PR240.2 ; v1(221.19,81.77) 221.69,81.27 U46.B60 ; v1(230.74,73.16) 230.72,73.16 229.9,72.35 229.9,70.39 229.46,69.95 RP4.4
SUS_STAT#/LPCPD#: length 8.4
  TOP w0.102: v1(31.12,92.05) 31.39,92.31 UH1.U7
  BOTTOM w0.102: v1(31.12,92.05) 31.12,89.95 31.4,89.67 31.4,86.73 31.38,86.7 31.38,85.02 T103.1
SUSACK#: length 238.4
  TOP w0.102: v1(224.09,80.6) 224.09,80.64 223.15,81.58 223.15,87.45 224.71,89.01 224.71,91.66 v1(223.67,92.7) ; RH101.1 21.9,81.19 v1(21.95,81.14)
  IN2 w0.127: v1(194.19,96.07) 192.77,96.07 191.83,97.01 189.11,97.01 182.84,103.29 142.91,103.29 141.29,104.91 131.71,104.91 130.11,103.31 129.49,103.31 127.26,101.08 122.24,101.08 120.73,102.59 109.67,102.59 108.78,101.7 91.87,101.7 91.72,101.85 81.79,101.85 79.7,99.76 76.94,99.76 76.37,99.19 74.7,99.19 71.6,96.09 71.6,95.93 70.62,94.95 70.62,94.24 66.49,90.1 63,90.1 62.82,89.93 61.73,89.93 v1(61.12,89.32)
  IN3 w0.127: v1(21.95,81.14) 21.95,81.07 23.15,79.88 27.77,79.88 28.59,79.06 31.81,79.06 32.4,79.65 34.33,79.65 34.98,79 37.69,79 38.73,80.05 45.36,80.05 47.21,81.89 51.65,81.89 56.4,86.64 56.66,86.64 59.34,89.32 v1(61.12,89.32)
  BOTTOM w0.102: v1(224.09,80.6) 224.02,80.52 U46.A58 ; v1(194.19,96.07) 194.22,96.1 205.01,96.1 207.81,93.3 223.43,93.3 223.67,93.06 v1(223.67,92.7) 225.62,92.7 v4(225.74,92.58)
SUSACK#_R: length 14.6
  TOP w0.089: v1(30.2,92.01) 30.49,91.72 UH1.R6
  TOP w0.102: v1(24.9,87.23) 24.9,86.74 24.05,85.89 23.59,85.89 v2(22.89,85.19) 22.17,84.47 RH91.2 21.9,83.94 RH101.2
  IN1 w0.109: v1(30.2,92.01) 30.19,92.01 29.57,91.4 29.57,89.96 27.03,87.42 25.09,87.42 v1(24.9,87.23)
SUSCLK: length 1.1
  TOP w0.102: v1(32.24,92.03) 32.55,91.72 UH1.Y6
  BOTTOM w0.089: T68.1 32.17,91.96 v1(32.24,92.03)
SW1: length 8.7
  IN1 w0.762: 239.3,52.49 239.3,55.79 239.58,56.07 239.58,56.98 242.45,59.85
  vias: v2(239.56,52.89) v3(239.3,51.73) v3(239.3,50.84) v3(243.06,60.44) v3(243.7,60.44)
SW2: length 12.3
  IN1 w0.762: 250.86,59.22 251.88,59.22 253.09,58 253.09,51.67 v3(253.83,50.94)
  BOTTOM w0.102: 254.14,46.07 254.14,44.36 v2(254.48,44.02)
  vias: v3(249.37,59.64) v3(250.01,59.64)
SW_1.35V: length 14.5
  IN3 w0.762: v3(187.99,67.09) v3(187.99,67.85) 182.94,67.85 182.18,68.62 182.18,71.69 v3(180.17,73.7) v3(180.17,74.46)
  BOTTOM w0.508: v3(180.17,73.7) 180.11,73.63 PC206.1
  vias: v2(182.91,76.06)
SW_+1.05VSP: length 9
  IN1 w0.762: 21.43,141.7 21.12,141.39 21.12,133.04 20.95,132.88
  vias: v2(24.82,131.4) v3(17.47,134.02) v3(17.45,133.32) v3(17.42,132.65) v3(17.69,132.01) v3(18.2,134.02) v3(18.16,133.27) v3(18.13,132.57) v3(18.45,131.98) v3(18.87,133.26) v3(18.83,132.56) v3(19.48,132.47) v3(19.54,133.17) v3(20.18,132.45) v3(20.23,133.17) v3(22.01,142.78) v3(22.01,142.15)
SW_LAN_TX0+: length 37.1
  TOP w0.089: v1(157.01,143.4) 157.27,143.66 157.27,144 156.82,144.45 T156.1
  BOTTOM w0.089: U32.24 131.43,136.36 131.33,136.26 131.33,135.85 133.18,134 151.47,134 157.46,139.99 157.46,141.48 157.39,141.56 157.39,141.87 157.46,141.95 157.46,142.22 157.39,142.29 157.39,142.61 157.46,142.69 157.46,143.67 157.41,143.72 157.26,143.72 157.01,143.47 v1(157.01,143.4)
SW_LAN_TX0-: length 37.3
  TOP w0.089: v1(157.88,143.41) 157.61,143.68 157.61,143.98 158.09,144.45 T156.2
  BOTTOM w0.089: U32.25 130.93,136.36 130.99,136.3 130.99,135.71 133.04,133.65 151.61,133.65 157.81,139.85 157.81,143.33 v1(157.88,143.41)
SW_LAN_TX1+: length 44.8
  TOP w0.089: T156.5 161.9,144.45 162.38,143.97 162.38,143.76 v1(162.11,143.5)
  BOTTOM w0.089: v1(162.11,143.5) 162.11,143.75 162.21,143.85 162.47,143.85 162.58,143.74 162.58,142.87 162.35,142.64 161.26,142.64 161.02,142.4 160.91,142.4 160.7,142.18 160.7,142.08 160.51,141.89 160.41,141.89 160.2,141.68 160.2,141.58 159.14,140.52 159.14,139.43 152.56,132.85 131.5,132.85 129.35,135 129.35,136.26 129.43,136.33 U32.28
SW_LAN_TX1-: length 44.8
  TOP w0.089: T156.6 163.17,144.45 162.72,144.01 162.72,143.8 v1(163.03,143.5)
  BOTTOM w0.089: v1(163.03,143.5) 162.92,143.39 162.92,142.73 162.49,142.3 161.4,142.3 159.48,140.38 159.48,139.29 152.7,132.51 131.36,132.51 129.01,134.86 129.01,136.26 128.93,136.33 U32.29
SW_LAN_TX2+: length 49.9
  TOP w0.089: T156.7 164.44,144.52 164.93,144.03 164.93,143.77 v1(164.68,143.52)
  BOTTOM w0.089: U32.33 126.93,136.34 126.88,136.28 126.88,135.83 131,131.71 154.16,131.71 161.2,138.75 161.2,139.36 163.37,141.53 163.37,141.66 163.59,141.87 163.71,141.87 163.9,142.06 163.9,142.18 164.11,142.4 164.24,142.4 164.69,142.85 164.94,142.85 165.17,143.08 165.17,143.66 164.93,143.9 164.78,143.9 164.68,143.8 v1(164.68,143.52)
SW_LAN_TX2-: length 49.9
  TOP w0.089: v1(165.59,143.52) 165.27,143.84 165.27,144.07 165.71,144.5 T156.8
  BOTTOM w0.089: U32.34 126.43,136.38 126.53,136.27 126.53,135.69 130.86,131.37 154.3,131.37 161.54,138.6 161.54,139.22 164.83,142.5 165.08,142.5 165.52,142.94 165.52,143.44 v1(165.59,143.52)
SW_LAN_TX3+: length 60.3
  TOP w0.089: v1(169.68,143.14) 169.71,143.14 169.96,143.39 169.96,144.01 169.52,144.45 T156.11
  BOTTOM w0.089: v1(169.68,143.14) 169.68,143.37 169.81,143.5 169.99,143.5 170.19,143.29 170.19,142.57 169.99,142.36 169.36,142.36 169.02,142.03 168.9,142.03 168.69,141.82 168.69,141.69 168.5,141.5 168.37,141.5 168.16,141.29 168.16,141.16 167.89,140.89 164.51,140.89 163.32,139.7 163.32,138.58 161.91,137.17 161.91,135.21 161.55,134.86 159.19,134.86 154.9,130.57 128.96,130.57 124.85,134.68 124.85,136.23 124.93,136.31 U32.37
SW_LAN_TX3-: length 60.3
  TOP w0.089: T156.12 170.79,144.47 170.3,143.99 170.3,143.43 v1(170.6,143.14)
  BOTTOM w0.089: U32.38 124.43,136.31 124.51,136.23 124.51,134.54 128.82,130.22 155.04,130.22 159.33,134.52 161.69,134.52 162.25,135.07 162.25,137.03 163.66,138.44 163.66,139.56 164.65,140.55 168.03,140.55 169.5,142.02 170.13,142.02 170.53,142.43 170.53,143.08 v1(170.6,143.14)
SYS_LED_MASK#: length 401.4
  TOP w0.102: v1(220.33,85.2) 220.33,86.68 219.72,87.29 219.72,89.8 219.66,89.86 v1(219.66,90.4) ; v1(133.04,151.85) 132.59,152.3 Q327.2 130.95,150.99 130.95,149.08 v2(131.5,148.53) 131.62,148.41 Q325.5 Q325.2 ; v1(15.16,150.72) 14.35,149.91 Q328.2 ; v1(17.28,80.4) 17.28,79.69 14.99,77.4 JIO1.114
  IN1 w0.109: v1(60.92,160.13) 61.1,159.95 62.75,159.95 64.41,161.62 66,161.62 67.21,162.82 72.2,162.82 72.91,163.54 85.71,163.54 86.31,162.93 95.33,162.93 97.87,165.47 97.87,166.08 100.65,168.85 102.22,168.85 104.49,171.12 110.72,171.12 114.32,167.52 118.32,167.52 126.51,159.33 129.94,159.33 132.99,156.28 132.99,151.9 v1(133.04,151.85)
  IN2 w0.127: v1(60.92,160.13) 60.92,159.93 60.71,159.73 54.53,159.73 51.79,156.98 49.98,156.98 49.31,156.31 47.84,156.31 46.58,155.05 43.6,155.05 40.85,152.31 40.85,148.74 38.6,146.49 24.52,146.49 20.29,150.72 v1(15.16,150.72) 12.56,153.33 10.17,153.33 8.31,151.47 8.31,150.66 8.54,150.43 8.54,149.16 7.81,148.42 7.81,145.12 8.43,144.5 8.81,144.5 12.35,140.96 12.35,135.56 9.36,132.57 9.36,127.85 10.55,126.66 10.55,126.07 13.39,123.23 13.39,117.03 10.6,114.23 9.31,114.23 7.88,112.81 7.88,93.05 10.12,90.82 10.12,89.72 9.86,89.47 9.13,89.47 8.52,88.86 8.52,84.94 13.99,79.46 16.34,79.46 v1(17.28,80.4) ; v1(133.04,151.85) 133.9,150.99 133.9,149.2 135.23,147.87 143.91,147.87 147.56,144.23 147.56,142.6 155.67,134.49 155.67,130.99 156.88,129.78 164.53,129.78 165.98,128.33 171.08,128.33 171.48,127.93 171.48,125.77 176.69,120.56 176.69,108.74 178.17,107.26 182.47,107.26 187.74,101.99 196.12,101.99 199.68,98.44 200.26,98.44 205.54,93.15 217.64,93.15 219.66,91.13 v1(219.66,90.4)
  BOTTOM w0.102: R775.2 219.74,90.49 v1(219.66,90.4) ; v1(220.33,85.2) 220.42,85.29 U46.B48 ; Q344.2 20.61,151.32 20.33,151.6 19.67,151.6 19.2,152.07 19.2,154.4 18.96,154.65 17.28,154.65 16.97,154.34 U58.1 16.97,153.63 15.63,152.28 15.63,151.19 v1(15.16,150.72) Q84.2
SYS_PWROK: length 407.5
  TOP w0.102: v1(74.66,14.56) 74.66,14.63 77.33,17.3 77.33,22.29 75.1,24.51 71.13,24.51 v1(70.65,24.03) ; UH1.AD7 34.65,91.92 34.69,91.92 v1(34.7,91.91) ; v1(232.42,73.57) 231.48,74.51 229.47,74.51 225.38,78.59 225.38,79.79 224.99,80.17 223.68,80.17 222.54,81.32 222.54,82.07 v1(221.83,82.77)
  IN1 w0.109: v1(74.66,14.56) 74.66,14.59 75.38,15.3 75.38,18.96 83.39,26.98 88.75,26.98 89.36,27.58 90.48,27.58 91.41,26.66 104.85,26.66 107.95,23.56 132.35,23.56 132.95,22.96 194.61,22.96 196.03,24.38 201.01,24.38 201.62,23.77 221.43,23.77 v1(221.65,23.99)
  IN3 w0.127: v1(221.65,23.99) 227.59,23.99 228.23,24.62 228.23,25.74 238.04,35.56 249.13,35.56 253.38,39.81 258.19,39.81 260,38.01 261.45,38.01 261.78,38.34 263.58,38.34 270.91,45.68 270.91,62.74 268.87,64.78 259.44,64.78 258.78,65.44 255.14,65.44 254.94,65.24 245.2,65.24 244.13,66.3 239.78,66.3 232.52,73.57 v1(232.42,73.57) ; v1(70.65,24.03) 70.65,24.8 63.2,32.24 63.2,36.66 61.83,38.03 61.83,46.7 57.56,50.97 57.56,70.1 56.64,71.02 56.64,74.69 56.52,74.81 56.52,77.46 55.48,78.5 v1(49.26,78.5)
  BOTTOM w0.102: v1(49.26,78.5) 48.65,79.11 48.53,79.11 46.96,80.68 37.73,80.68 37.25,81.16 37.25,82.28 38.29,83.32 38.29,83.75 37.88,84.16 37.88,85.53 37.02,86.4 36.67,86.4 34.83,88.23 34.83,88.59 v4(34.2,89.23) 33.51,89.91 33.51,91.15 34.27,91.91 v1(34.7,91.91) ; U46.B57 v1(221.83,82.77) ; RC9.1 74.84,14.39 v1(74.66,14.56)
SYS_PWROK_XDP: length 4.1
  TOP w0.102: v1(73.2,10.45) JXDP1.47
  BOTTOM w0.102: RC9.2 RC124.2 73.95,11.2 v2(73.6,10.86) v1(73.2,10.45)
SYS_RESET#: length 312.8
  TOP w0.102: v1(59.52,37.4) 79.15,37.4 83.43,33.12 83.43,31.46 83.89,31 84.42,31 84.93,30.49 87.99,30.49 88.48,30.01 JAPS1.13 ; JXDP1.48 73.2,19.58 v1(71.05,21.73) ; v1(17.94,120.03) 18.12,120.2 20.01,120.2 20.8,119.41 JXDP2.48 ; v1(45.98,77.99) 45.98,78.62 44.24,80.36 43.72,80.36 42.69,81.39 v1(41.54,81.39) 41.54,81.2 41.25,80.91 40.53,80.91 40.27,81.18 40.27,83.71 40.24,83.74 40.24,85.63 39.23,86.65 39.23,87.23 37.8,88.65 37.8,89.42 37.6,89.62 UH1.AM1
  IN4 w0.109: v1(59.52,37.4) 59.52,38.29 57.67,40.14 57.67,52.11 56.79,52.99 56.79,77.43 55.53,78.7 52.49,78.7 51.84,79.34 47.34,79.34 v1(45.98,77.99) ; v1(17.94,120.03) 17.53,120.03 16.14,118.63 16.14,116.98 14.46,115.31 14.46,114.92 13,113.46 13,112.39 12.65,112.03 12.65,111.67 12.2,111.23 12.2,108.68 10.84,107.33 10.84,103.84 11.65,103.04 11.65,101.1 12.38,100.37 12.38,93.47 13.94,91.91 15.46,91.91 17.51,89.86 17.51,89.27 21.76,85.01 25.13,85.01 26.09,84.05 30.99,84.05 31.33,83.71 31.33,83.34 31.53,83.14 33.85,83.14 35.5,81.49 36.2,81.49 36.86,82.15 40.98,82.15 41.54,81.6 v1(41.54,81.39) 41.54,81.38 41.12,80.96 39.76,80.96 37.68,78.88 37.68,78.67 35.74,76.73 35.74,68.22 38.28,65.68 38.28,56.21 40.65,53.84 40.65,51.09 37.93,48.36 37.93,40.15 40.37,37.71 40.37,33.56 41.36,32.57 41.36,28.57 44.64,25.29 44.64,22.06 50.05,16.65 60.46,16.65 65.54,21.73 v1(71.05,21.73)
  BOTTOM w0.102: RC26.1 70.06,76.06 67.22,78.9 61.88,78.9 61.07,79.72 58,79.72 57.06,78.78 52.41,78.78 51.77,79.41 48.55,79.41 47.05,80.91 42.02,80.91 v1(41.54,81.39) ; v1(45.98,77.99) 46.64,77.99 v4(46.67,78.01)
SYSPWR_PRES: length 8.3
  BOTTOM w0.102: R874.1 105.83,168.62 105.83,167.47 R876.1 105.96,166.6 v2(105.96,165.67) 105.96,164.25 104.76,163.04 104.76,162.55 105,162.31 U51.A59
SYSTEM_ID: length 6
  BOTTOM w0.102: R871.2 111.72,155.74 112.99,155.74 C742.1 ; R871.2 110.7,155.74 109.66,155.74 109.63,155.77 U51.A10 ; R871.2 111.21,156.77 v2(111.62,157.17)
TEMP_ALERT#: length 240.6
  TOP w0.102: UH1.H6 27.55,91.72 v1(27.31,91.96) ; v1(216.92,77.37) 216.92,76.48 216.26,75.83 216.26,74.92 v1(216.67,74.51)
  IN2 w0.127: v1(27.31,91.96) 27.31,91.52 27.24,91.45 27.24,91.29 27.21,91.27 27.21,90.99 28.12,90.09 31.1,90.09 31.67,89.52 36.94,89.52 38.48,87.98 42.91,87.98 43.15,88.22 45.19,88.22 49.56,92.59 63,92.59 66.86,96.45 67.86,96.45 69.37,97.96 69.55,97.96 72.89,101.3 76.28,101.3 76.95,101.97 79.48,101.97 81.48,103.96 84.04,103.96 84.5,103.51 85.57,103.51 86.23,104.16 111.35,104.16 112.06,103.45 114.6,103.45 115.1,103.95 120.58,103.95 121.82,102.7 123.88,102.7 125.36,104.18 129.68,104.18 131.17,105.67 141.6,105.67 143.23,104.05 183.16,104.05 188.39,98.82 194.98,98.82 197.64,96.16 199.31,96.16 203.62,91.86 203.62,89.32 205.37,87.57 205.37,81.85 205.77,81.44 205.77,74.99 209.02,71.74 211.06,71.74 211.34,72.02 212.63,72.02 212.87,71.78 215.74,71.78 v1(216.26,72.3)
  BOTTOM w0.102: v1(216.92,77.37) U46.B11 ; RH171.2 22.31,85.51 23.12,85.51 24.27,86.66 24.27,87.49 25.23,88.46 25.23,89.11 25.8,89.69 26.41,89.69 27.07,90.35 v2(27.07,90.88) 27.07,91.72 v1(27.31,91.96) ; v1(216.26,72.3) 216.67,72.71 v1(216.67,74.51)
THERM_STP#: length 121.3
  TOP w0.102: U29.19 168.32,130.3 167.98,129.96 167.98,129.06 R395.1 168.22,128.08 v2(168.52,127.77) 169.02,127.77 172.69,124.1 v1(172.69,123.91)
  IN1 w0.109: v1(202.32,90.66) 202.31,90.68 202.31,93.04 194.5,100.85 187.77,100.85 175.88,112.73 174.89,112.73 174.07,113.55 174.07,122.53 v1(172.69,123.91)
  BOTTOM w0.102: PR111.1 240.66,62.69 238.11,65.24 228.43,65.24 225.48,68.18 221.51,68.18 221.29,68.4 221.08,68.4 219.41,70.06 215.36,70.06 214.06,68.77 207.02,68.77 202.19,73.59 202.19,90.54 v1(202.32,90.66)
THERMATRIP2#: length 72.9
  TOP w0.102: v1(150.19,137.12) 150.17,137.11 v2(154.48,137.11) Q28.1 158.06,137.15 C327.1 R396.2
  IN3 w0.127: v1(99.22,151.97) 98.45,151.2 98.45,149.92 100.62,147.75 107.62,147.75 107.92,147.46 109.09,147.46 110.65,149.02 111.59,149.02 114.65,145.96 120.84,145.96 122.01,144.79 131.66,144.79 133.14,146.28 136.38,146.28 139.47,143.19 140.74,143.19 146.19,137.74 149.56,137.74 v1(150.19,137.12)
  BOTTOM w0.102: v1(99.22,151.97) 99.27,151.92 U51.B34
THSEL_STRAP: length 13.4
  TOP w0.102: v1(102.4,147.23) 102.4,147.44 v2(103.19,148.24) 103.64,148.68 103.64,151.42 102.8,152.26 102.8,153.63 103.03,153.86 104.12,153.86 v1(104.33,153.66)
  BOTTOM w0.102: v1(104.33,153.66) 104.14,153.84 102.88,153.84 102.25,153.21 U51.B29 ; R1069.1 102.33,147.17 v1(102.4,147.23)
TMDS_DDCBUF: length 7.2
  TOP w0.102: U9.2 24.46,161.61 25.84,162.99 25.84,163.22 26.2,163.57 26.2,164.32 R66.2 R68.2 26.63,166.24 v2(27.09,166.7)
TMDS_PRE: length 5.7
  TOP w0.102: v1(17.89,157.69) 17.93,157.74 U9.20
  BOTTOM w0.102: v1(17.89,157.69) 17.93,157.74 18.72,157.74 R67.2 18.7,158.23 17.18,158.23 R65.2 v2(15.57,157.97)
TMDS_RT: length 5.1
  TOP w0.102: U9.23 v1(17.89,156.54)
  BOTTOM w0.102: R71.2 17.28,154.93 18.6,154.93 R57.2 18.72,155.52 18.41,155.52 v2(17.92,156.02) 17.89,156.04 v1(17.89,156.54)
TMDSE_CON_CLK: length 16.6
  TOP w0.102: R451.2 19.29,164.17 L19.3 19.29,164.86 19.48,165.05 19.48,165.5 C1333.1 19.49,166 19.49,166.38 v5(19.28,166.59)
  IN4 w0.117: JHDMI1.10 17.93,169.6 17.93,169.95 18.51,170.54 21.88,170.54 23.05,169.36 23.05,167.63 21.06,165.64 19.55,165.64 19.28,165.9 v5(19.28,166.59)
TMDSE_CON_CLK#: length 16.6
  TOP w0.102: v1(20.04,166.62) 19.84,166.62 19.71,166.48 19.71,166.11 19.8,166.02 19.92,166.02 20.17,165.78 C1334.1 19.83,165.77 19.7,165.64 19.7,165.26 20.14,164.81 L19.2 20.14,164.17 R452.2
  IN4 w0.117: v1(20.04,166.62) 19.82,166.62 19.76,166.55 19.76,166.43 19.52,166.2 19.52,166 19.65,165.87 20.96,165.87 22.82,167.73 22.82,169.26 21.78,170.3 18.61,170.3 18.16,169.86 18.16,169.16 18.24,169.08 18.41,169.08 JHDMI1.12
TMDSE_CON_N0: length 6.2
  TOP w0.089: 16.54,167.55 16.54,167.42
  TOP w0.102: JHDMI1.9 16.54,167.72 16.54,167.55 ; R454.2 17.4,162.97 L23.2 17.4,163.57 17.07,163.9 17.07,164.23 C1335.1 17.22,164.74 v3(17.22,165.69) 17.22,166.74 16.54,167.42
TMDSE_CON_N1: length 16.8
  TOP w0.102: R456.2 15.44,162.9 L24.2 15.44,163.57 15.12,163.89 15.12,165.69 C1337.1 15.11,166.12 15.11,166.44 15.05,166.51 15.05,167.16 v1(15.23,167.35)
  IN4 w0.117: JHDMI1.6 15.39,169.41 15.39,169.96 15.14,170.21 12.87,170.21 12.01,169.35 12.01,166.54 12.48,166.06 14.73,166.06 15.19,166.52 15.19,167.3 v1(15.23,167.35)
TMDSE_CON_N2: length 9
  TOP w0.102: JHDMI1.3 13.66,167.84 13.66,167.56 12.97,166.86 11.79,166.86 11.48,166.55 11.48,165.97 C1339.1 11.46,165.37 11.46,165.16 11.58,165.03 12.26,165.03 12.62,164.68 v3(12.62,164.37) 12.62,164.15 12.24,163.76 11.83,163.76 11.51,163.44 L25.2 10.89,163.44 R458.2
TMDSE_CON_P0: length 6.2
  TOP w0.089: 16.54,167.11 16.33,167.33 16.33,167.55
  TOP w0.102: 16.54,167.11 17.01,166.65 17.01,166.01 16.99,166 16.99,165.32 17.01,165.31 17.01,165.05 C1336.1 16.86,164.23 16.86,163.92 16.55,163.62 L23.3 16.55,163 R453.2 ; 16.33,167.55 16.33,167.98 JHDMI1.7
TMDSE_CON_P1: length 16.8
  TOP w0.102: v1(14.47,167.3) 14.76,167.3 14.83,167.23 14.83,166.42 14.89,166.35 14.89,165.97 14.83,165.91 C1338.1 14.69,165.67 14.79,165.67 14.91,165.56 14.91,163.88 14.6,163.57 L24.3 14.6,162.9 R455.2
  IN4 w0.117: v1(14.47,167.3) 14.56,167.4 14.72,167.4 14.82,167.3 14.82,167.17 14.95,167.04 14.95,166.62 14.63,166.3 12.58,166.3 12.24,166.64 12.24,169.25 12.97,169.97 15.04,169.97 15.15,169.86 15.15,169.69 14.97,169.5 14.97,169.25 14.85,169.14 14.67,169.14 JHDMI1.4
TMDSE_CON_P2: length 8.9
  TOP w0.102: R459.2 10.89,164.29 L25.3 11.59,164.29 11.9,163.98 12.15,163.98 12.39,164.22 12.39,164.6 12.17,164.82 11.49,164.82 11.24,165.07 11.24,165.54 11.08,165.69 C1340.1 11.26,166.03 11.26,166.63 11.71,167.08 12.88,167.08 13.45,167.65 13.45,168.15 13.35,168.24 JHDMI1.1
TMDSE_RP_CLK: length 5.8
  TOP w0.102: U9.16 17.9,159.33 17.64,159.6 17.64,160.57 18.77,161.69 18.77,161.71 19.18,162.13 19.2,162.13 19.22,162.15 19.38,162.15 19.44,162.22 19.44,162.44 19.29,162.59 L19.4 19.29,163.22 R451.1
TMDSE_RP_CLK#: length 5.8
  TOP w0.102: R452.1 20.14,163.22 L19.1 20.14,162.56 20,162.42 19.74,162.42 19.66,162.33 19.66,162.13 19.47,161.94 19.31,161.94 v3(19.13,161.76) 17.85,160.48 17.85,159.69 17.99,159.55 18.1,159.55 18.11,159.56 18.29,159.74 U9.15
TMDSE_RP_N0: length 5.5
  TOP w0.102: U9.18 18.3,158.54 18.12,158.35 17.74,158.35 v3(17.34,158.75) 16.91,159.18 16.91,160.21 16.93,160.22 16.93,160.75 16.91,160.77 16.91,161.14 17,161.22 17.28,161.22 17.4,161.34 L23.1 17.36,161.68 R454.1
TMDSE_RP_N1: length 7.2
  TOP w0.102: L24.1 15.44,161.32 15.3,161.17 15.07,161.17 14.96,161.06 14.96,160.49 14.97,160.47 14.97,159.94 14.96,159.93 14.96,159.67 v3(15.76,158.86) 17.47,157.15 18.06,157.15 18.25,157.33 U9.21
TMDSE_RP_N2: length 21.8
  TOP w0.102: R458.1 9.94,163.44 L25.1 9.07,163.44 8.95,163.56 8.95,164.08 8.8,164.23 8.38,164.23 8.07,163.92 8.07,162.11 8.86,161.33 v3(8.86,158.47) 8.86,156.74 10.88,154.72 12.57,154.72 12.58,154.73 13.11,154.73 13.13,154.72 13.14,154.72 14.74,156.32 17.22,156.32 17.59,155.95 18.1,155.95 18.29,156.14 U9.24
TMDSE_RP_P0: length 5.5
  TOP w0.102: U9.19 17.65,158.14 17.39,158.39 17.38,158.39 16.99,158.78 16.99,158.8 16.7,159.09 v3(16.7,160.49) 16.7,161.22 16.55,161.36 L23.4 16.55,161.92 R453.1
TMDSE_RP_P1: length 7.2
  TOP w0.102: L24.4 14.6,161.29 14.74,161.15 v3(14.74,160.21) 14.74,159.58 15.4,158.92 15.4,158.9 15.79,158.51 15.81,158.51 17.38,156.93 U9.22
TMDSE_RP_P2: length 21.9
  TOP w0.102: U9.25 17.5,155.74 17.13,156.11 14.83,156.11 13.23,154.51 v3(12.85,154.51) 10.79,154.51 8.64,156.65 8.64,158.19 8.63,158.2 8.63,158.74 8.64,158.75 8.64,161.24 7.86,162.02 7.86,164.01 8.3,164.45 8.89,164.45 9.05,164.29 L25.4 9.94,164.29 R459.1
TOUCH_SCREEN_PD#: length 8.5
  IN4 w0.109: v1(228.48,84.11) 228.23,84.36 226.25,84.36 226.02,84.14 225.05,84.14 224.49,83.58 221.95,83.58 v1(221.83,83.7)
  BOTTOM w0.102: U46.B55 221.9,83.77 v1(221.83,83.7) ; v1(228.48,84.11) 228.2,83.83 T155.1
TP_LAN_JTAG_TCK: length 2.5
  BOTTOM w0.102: U31.35 120.54,147.23 119.45,146.15 T172.1
TP_LAN_JTAG_TDI: length 3.8
  BOTTOM w0.102: U31.32 121.74,147.65 121.5,147.41 121.5,146.35 120.75,145.6 T142.1
TP_LAN_JTAG_TDO: length 1.5
  BOTTOM w0.102: T143.1 120.94,147.11 U31.34
TP_LAN_JTAG_TMS: length 4.1
  BOTTOM w0.102: U31.33 121.34,147.63 121.19,147.48 121.19,146.78 119.44,145.03 T171.1
TP_VSS_NCTF: length 5.9
  TOP w0.102: RH219.2 46.72,88.4 44.99,88.4 43.87,89.52 43.87,90.76 43.26,91.38 UH1.BE5
TPM_ID0: length 10.7
  TOP w0.102: v1(39.6,92.56) 39.59,92.56 39.59,92.56 39.54,92.56 39.3,92.31 UH1.AT7
  BOTTOM w0.102: RPH10.6 43.47,85.76 42.99,86.24 42.43,86.24 40.45,88.22 39.6,88.22 38.97,88.85 38.97,90.66 39.19,90.88 v2(39.19,92.21) 39.19,92.26 39.49,92.56 v1(39.6,92.56)
TPM_ID1: length 7
  TOP w0.102: UH1.AM3 37.5,90.59 37.5,90.13 37.48,90.1 37.29,89.92 37.29,89.66 37.58,89.37 37.58,88.56 38.38,87.76 38.38,86.6 38.72,86.25 39.07,86.25 v2(39.29,86.03) 39.79,85.53 RH200.2
TRIP_+1.05VSP: length 2.5
  TOP w0.254: v1(20.86,147.99) 20.86,147.86 21.37,147.36 PR302.2
  BOTTOM w0.102: v2(20.24,148.18) 20.43,147.99 v1(20.86,147.99)
  BOTTOM w0.254: v1(20.86,147.99) 20.98,147.87 PU300.2
UG_3V: length 10.8
  IN4 w0.762: 249.44,57.47 250.22,56.68 250.22,52.03 v3(253.15,49.11) v3(253.15,48.19)
  vias: v3(248.46,58.16) v3(249.09,58.16)
UG_5V: length 10.2
  IN4 w0.762: 242.65,49.72 241.72,50.66 241.72,57.31 242.65,58.25 243.49,58.25
  vias: v3(243.39,49.44) v3(243.39,48.73) v3(244.26,58.16) v3(244.89,58.16)
UG_+1.05VSP: length 8.7
  TOP w0.102: v2(20.75,142.34) 20.1,142.99 v3(20.1,143.42)
  IN1 w0.762: 19.26,135.48 19.27,135.49 19.27,142.59 19.47,142.78
  vias: v3(19.27,134.72) v3(19.26,134.08) v3(20.74,143.42)
UGATE1: length 33
  TOP w0.762: 41.94,55.54 42.45,56.04 PQ504.2
  TOP w1.016: 41.94,55.54 41.69,55.28 v2(41.69,54.07) 41.69,52.94 v3(43.93,50.71) v3(43.93,49.57)
  IN1 w1.016: 54.52,30.39 54.52,31.66 50.15,36.03 50.15,43.34 v3(43.93,49.57) v3(43.93,50.71)
  vias: v3(53.78,29.88) v3(53.78,29.25)
UGATE2: length 17.3
  TOP w0.762: PQ502.2 v3(43.62,41.29)
  IN4 w0.762: v3(43.62,41.29) v3(43.62,40.42) 43.62,37.98 44.1,37.5 46.39,37.5 47.41,36.49 47.41,29.5 48.55,28.36
  vias: v2(43.1,40.8) v3(49.44,27.98) v3(49.95,27.47)
UGATE3: length 5.3
  TOP w0.635: v3(42.25,71.41) 42.71,70.95 PQ500.2
  IN4 w0.762: v3(42.25,71.41) 42.25,72.15 41.21,73.19 39.91,73.19
  BOTTOM w0.102: v2(42.36,70.69) 42.25,70.8 v3(42.25,71.41)
  vias: v3(38.9,73.19) v3(38.9,72.53)
UIM_CLK: length 82.5
  TOP w0.102: v1(254.26,84.97) 253.25,83.96 253.25,82.43 254.85,80.84 254.85,73.79 260.36,68.27 260.36,67 269.45,57.9 269.45,45.58 263.15,39.28 259.62,39.28 258.43,38.09 252.65,38.09 251.63,37.07 244.51,37.07 v1(244.1,37.48)
  BOTTOM w0.102: JSIM1.3 244.19,34.67 v2(244.19,34.77) 244.19,35.45 C628.1 244.1,36.43 v1(244.1,37.48) ; JMINI2.12 253.49,84.2 v1(254.26,84.97)
UIM_DATA: length 79.4
  TOP w0.102: v1(253.68,85) 253.02,84.35 253.02,82.34 254.62,80.74 254.62,73.69 260.13,68.18 260.13,66.9 269.22,57.81 269.22,45.71 263.03,39.51 251.36,39.51 249.33,37.48 v1(246.13,37.48)
  BOTTOM w0.102: v1(253.68,85) JMINI2.10 ; JSIM1.7 244.89,34.05 244.89,35.26 C631.1 246.13,36.51 v1(246.13,37.48) v2(246.68,37.48)
UIM_RESET: length 83.7
  TOP w0.102: v1(241.61,37.48) 242.48,36.61 251.82,36.61 252.84,37.63 261.24,37.63 262.41,38.8 264.5,38.8 269.91,44.21 269.91,58.09 260.82,67.19 260.82,68.46 255.47,73.81 255.47,81.45 v1(254.32,82.6)
  BOTTOM w0.102: v1(241.61,37.48) 241.61,36.51 C629.1 242.79,35.34 v2(242.79,34.67) 242.79,34.24 JSIM1.2 ; JMINI2.14 253.52,83.4 v1(254.32,82.6)
UIM_VPP: length 80.9
  TOP w0.102: v1(253.68,82.6) 255.08,81.21 255.08,73.88 260.59,68.37 260.59,67.09 269.68,58 269.68,45.48 263.23,39.03 262.31,39.03 261.15,37.86 252.75,37.86 251.73,36.84 243.52,36.84 v1(242.88,37.48)
  BOTTOM w0.102: v2(242.88,38.14) v1(242.88,37.48) 242.88,36.51 C630.1 243.49,35.89 243.49,34.8 JSIM1.6 ; JMINI2.16 v1(253.68,82.6)
USB3_A_DE0: length 2.4
  BOTTOM w0.102: R23.2 226.85,86.78 226.85,86.58 227.42,86.01 U638.29
USB3_A_DE1: length 2.1
  BOTTOM w0.102: R25.2 226.46,86.46 227.31,85.61 U638.28
USB3_A_EQ0: length 3.8
  BOTTOM w0.102: R24.2 v2(227.26,89.04) 227.54,88.76 227.54,87.34 227.67,87.21 U638.32
USB3_A_EQ1: length 3.3
  BOTTOM w0.102: R22.2 227.31,88.1 227.31,87.09 227.59,86.81 U638.31
USB3_B_DE0: length 14.9
  IN3 w0.127: v1(234.36,84.92) 234.48,84.81 234.48,77.57 233.71,76.81 233.71,76.31 v1(233.27,75.86)
  BOTTOM w0.102: U638.15 234.54,86.01 234.84,85.71 234.84,85.4 v1(234.36,84.92) ; R28.2 232.85,77.61 232.85,76.28 v1(233.27,75.86) 233.27,75.69 v2(233.68,75.28)
USB3_B_DE1: length 14.8
  IN3 w0.127: v1(233.64,84.93) 233.64,80.99 231.94,79.28 231.94,76.31 v1(232.39,75.86)
  BOTTOM w0.102: v1(233.64,84.93) 234.05,85.34 U638.16 ; v2(231.77,79.16) 232.38,78.55 R30.2 232.34,78.07 231.86,77.59 231.86,76.39 v1(232.39,75.86)
USB3_B_EQ0: length 19.3
  IN3 w0.127: v1(235.28,75.86) 236.13,76.71 236.13,81.8 237.09,82.76 237.09,86.45 236.25,87.29 235.31,87.29 v1(234.86,87.74)
  BOTTOM w0.102: v1(234.86,87.74) 234.86,87.13 234.53,86.81 U638.13 ; R18.2 235.7,77.63 235.7,76.28 v1(235.28,75.86) v2(236.28,75.86)
USB3_B_EQ1: length 18.1
  IN3 w0.127: v1(234.34,75.88) 234.78,76.32 234.78,77.23 235.77,78.22 235.77,82.03 236.77,83.03 236.77,86.24 236.33,86.68 235.14,86.68 v1(234.91,86.45)
  BOTTOM w0.102: v1(234.91,86.45) 234.87,86.41 U638.14 ; v1(234.34,75.88) 233.87,76.35 233.87,77.61 R27.2 234.35,78.84 v2(234.59,79.08)
USB3_RX1_N_D-: length 8.6
  TOP w0.102: JUSB1.5 262.9,116.6 262.66,116.36 262.41,116.36 261.6,115.55 261.6,114.77 260.85,114.02 259.81,114.02 259.7,114.13 D14.5 D14.6 258.17,114.13 258.03,113.99 257.82,113.99 257.67,114.14 257.38,114.14 257.04,114.48 L40.1
USB3_RX1_P_D+: length 8.6
  TOP w0.102: L40.4 257.09,113.63 257.38,113.92 257.58,113.92 257.73,113.77 258.05,113.77 258.19,113.63 D14.7 D14.4 259.64,113.63 259.81,113.8 260.94,113.8 261.82,114.68 261.82,115.46 262.5,116.14 262.67,116.14 262.9,115.91 JUSB1.6
USB3_RX2_N_D-: length 15.2
  TOP w0.102: L43.1 257.82,126.84 258.14,127.16 258.14,127.41 258.32,127.59 258.32,127.77 258.18,127.91 D16.6 D16.5 258.18,129.81 258.32,129.95 v3(258.32,130.86) 258.32,133.16 258.31,133.17 258.31,133.7 258.32,133.72 258.32,134.37 262.31,138.36 262.8,138.36 262.9,138.47 JUSB2.5
USB3_RX2_P_D+: length 15.2
  TOP w0.102: JUSB2.6 262.9,138.01 262.76,138.15 262.4,138.15 258.54,134.28 v3(258.54,133.44) 258.54,131.15 258.56,131.13 258.56,130.57 258.54,130.55 258.54,129.98 258.68,129.83 D16.4 D16.7 258.68,127.87 258.54,127.73 258.54,127.5 258.36,127.32 258.36,127.16 258.67,126.84 L43.4
USB3_TEST: length 13.1
  IN3 w0.127: v1(231.44,75.84) 230.95,76.33 230.95,83.79 231.05,83.89 v1(231.05,83.93)
  BOTTOM w0.102: 231.05,84.9 v1(231.05,83.93) ; R26.2 230.84,77.63 230.84,76.82 230.95,76.72 230.95,76.33 v1(231.44,75.84) 231.44,75.52 231.22,75.31 v2(231.22,74.86)
USB3_TX1_N_D-: length 8.9
  TOP w0.102: L42.1 257.04,112.7 257.36,112.39 257.52,112.39 257.63,112.49 258.01,112.49 258.14,112.63 D14.8 D14.2 259.68,112.63 259.81,112.49 261.1,112.49 261.49,112.1 261.49,110.67 261.8,110.36 262.63,110.36 262.9,110.63 JUSB1.8
USB3_TX1_P_D+: length 8.9
  TOP w0.102: JUSB1.9 262.9,109.86 262.62,110.14 261.71,110.14 261.27,110.58 261.27,112.01 261.01,112.28 259.81,112.28 259.66,112.13 D14.1 D14.9 258.15,112.13 258,112.28 257.72,112.28 257.61,112.17 257.35,112.17 257.03,111.85 L42.4
USB3_TX2_N_D-: length 9
  TOP w0.102: L44.1 259.73,126.83 260.01,127.11 260.01,127.27 259.81,127.48 259.81,127.73 259.68,127.87 D16.8 D16.2 259.68,129.81 259.83,129.96 259.83,130.62 261.55,132.34 262.75,132.34 262.9,132.5 JUSB2.8
USB3_TX2_P_D+: length 9
  TOP w0.102: JUSB2.9 262.9,131.94 262.71,132.13 261.64,132.13 260.04,130.53 260.04,129.94 260.18,129.81 D16.1 D16.9 260.18,127.86 260.03,127.71 260.03,127.57 260.23,127.36 260.23,127.18 260.58,126.83 L44.4
USB3RN1: length 229.4
  TOP w0.102: UH1.AR26 38.93,100.56 v1(39.2,100.83)
  IN4 w0.089: v1(39.2,100.83) 38.76,100.39 38.39,100.39 38.31,100.31 38.31,99.47 38.44,99.35 38.68,99.35 38.71,99.38 38.73,99.38
  IN4 w0.117: v1(229.67,76.32) 229.67,76.32 230.07,75.92 230.07,75.64 229.95,75.53 229.95,75.13 230.07,75.02 230.07,74.67 229.95,74.56 229.95,74.16 230.07,74.05 230.07,73.72 229.75,73.4 229.75,72.91 228.04,71.2 228.04,70.34 225.68,67.98 221.8,67.98 220.61,66.79 214.11,66.79 213.43,67.47 212.97,67.47 212.61,67.83 209.12,67.83 199.99,76.96 199.99,78.14 194.65,83.48 188.34,83.48 184.59,87.23 183.35,87.23 182.21,88.37 182.21,92.18 175.77,98.62 161.6,98.62 159.44,100.77 151.92,100.77 150.07,98.93 134.55,98.93 133.13,100.35 118.9,100.35 117.27,101.98 110.19,101.98 109.97,102.19 84.31,102.19 83.45,103.06 72.85,103.06 71.84,102.05 67.91,102.05 67.22,101.36 60.25,101.36 59.89,101.01 56.85,101.01 56.19,101.67 52.36,101.67 51.9,101.21 51.9,100.42 48.78,97.29 47.46,97.29 47.11,96.94 43.77,96.94 41.33,99.38 38.73,99.38
  BOTTOM w0.102: C487.2 230.56,79.91 230.56,79.44 229.88,78.75 v3(229.88,78.01) 229.88,76.53 v1(229.67,76.32)
USB3RN1_C: length 4
  BOTTOM w0.102: C487.1 230.58,81.51 v3(230.58,82.13) 230.58,82.71 230.34,82.95 230.34,83.2 230.33,83.21 230.33,83.74 230.34,83.75 230.34,84.31 230.25,84.41 U638.24
USB3RN1_RP: length 48.8
  TOP w0.102: v1(254.32,106.58) 254.14,106.75 253.74,106.75 253.16,107.34 253.16,108.5 252.47,109.19 252.47,111.11 252.46,111.12 252.46,111.66 252.47,111.67 252.47,112.19 253.49,113.2 v3(253.49,113.78) 253.49,114.16 253.81,114.48 L40.2
  IN3 w0.127: v1(254.32,106.58) 254.32,106.62 254.52,106.82 254.88,106.82 255,106.69 255,106.18 254.6,105.78 254.45,105.78 254.15,105.49 254.15,105.33 253.79,104.96 253.79,104.67 253.68,104.57 253.68,104.14 253.79,104.03 253.79,99.33 248.23,93.77 236.8,93.77 233.64,90.61 232.95,90.61 232.65,90.3 231.38,90.3 230.51,89.44 230.51,89.11 230.15,88.75 v1(230.12,88.75)
  BOTTOM w0.102: v1(230.12,88.75) 230.33,88.54 230.33,88.41 230.25,88.32 U638.4
USB3RN2: length 225.5
  TOP w0.102: v1(41.14,100.85) 40.72,100.44 UH1.AW26
  IN4 w0.089: 42.09,99.88 42.08,99.89 42.04,99.89 41.48,100.44 40.95,100.44 40.88,100.52 40.88,100.65 41.09,100.85 v1(41.14,100.85)
  IN4 w0.117: 42.09,99.88 43.93,98.04 48.48,98.04 51.03,100.59 51.03,101.38 52.07,102.42 61.94,102.42 62.16,102.2 66.18,102.2 67.02,103.04 71.11,103.04 72.22,104.16 76.11,104.16 76.49,104.54 77.04,104.54 77.34,104.23 83.92,104.23 85.04,103.12 88.86,103.12 89.18,103.44 109.91,103.44 110.64,102.71 117.64,102.71 118.53,101.82 121.01,101.82 121.67,101.16 127.32,101.16 127.98,101.82 131.91,101.82 132.25,101.48 138.01,101.48 138.56,100.93 149.56,100.93 150.14,101.51 160.94,101.51 162.21,100.25 175.44,100.25 185.36,90.33 185.36,87.91 189.05,84.22 195.2,84.22 201.18,78.25 201.18,76.81 209.42,68.57 213.47,68.57 214.52,67.52 219.69,67.52 220.94,68.77 224.03,68.77 226.33,71.06 226.83,71.06 228.93,73.16 228.93,76.63 229.51,77.21 230.09,77.21 230.4,77.52 230.4,77.67 230.67,77.95 230.83,77.95 231.08,78.19 231.08,78.35 231.35,78.62 231.5,78.62 232.02,79.14 232.53,79.14 232.77,79.39 v1(232.77,79.44)
  BOTTOM w0.102: C490.2 233.24,80.24 233.42,80.06 233.42,79.4 233.18,79.16 232.98,79.16 232.77,79.36 v1(232.77,79.44)
USB3RN2_C: length 4.2
  BOTTOM w0.102: U638.18 232.65,84.43 232.74,84.34 232.74,84.04 232.94,83.84 232.94,83.83 233.36,83.4 v3(233.36,82.43) 233.36,81.5 C490.1
USB3RN2_RP: length 56.1
  TOP w0.102: L43.2 257.82,124.45 258.14,124.13 258.14,123.2 258.13,123.19 258.13,122.66 258.14,122.64 258.14,122.01 v1(257.93,121.8)
  IN3 w0.127: v1(257.93,121.8) 257.97,121.8 258.15,121.62 258.15,119.44 255.77,117.06 255.77,104.69 254.95,103.87 254.95,97.32 250.01,92.38 236.75,92.38 234.22,89.85 233.28,89.85 232.96,89.53 232.96,89.24 v1(232.81,89.08)
  BOTTOM w0.102: U638.10 232.65,88.28 232.75,88.39 232.75,88.53 232.99,88.76 232.99,88.9 v1(232.81,89.08)
USB3RN3: length 104.1
  TOP w0.102: UH1.AW31 40.72,102.62 v1(40.48,102.86)
  IN3 w0.089: 42.12,103.45 42.1,103.45 42.06,103.41 40.95,103.41 40.78,103.24 40.78,103.03 40.6,102.86 v1(40.48,102.86)
  IN3 w0.127: 42.12,103.45 43.44,103.45 43.96,102.93 49.23,102.93 51.24,104.94 64.35,104.94 65.57,106.16 65.57,112.36 64.52,113.4 64.52,125.72 64.69,125.89 64.69,127.19 69.1,131.6 69.1,139.64 71.13,141.66 83.96,141.66 88.66,136.96 88.66,128.68 92.99,124.34 94.69,124.34 94.84,124.5 94.84,124.68 v1(94.65,124.88)
  BOTTOM w0.102: JDOCK1.84 94.7,125.41 94.84,125.27 94.84,125.07 v1(94.65,124.88)
USB3RN5: length 43.7
  TOP w0.102: JIO1.45 8.72,97.8 8.9,97.62 11.13,97.62 v1(11.34,97.83) ; v1(40.54,101.85) 40.47,101.78 40.47,101.61 UH1.AW29
  IN3 w0.089: 41.28,101.47 41.26,101.47 41.23,101.43 40.24,101.43 40.16,101.51 40.16,101.66 40.35,101.85 v1(40.54,101.85)
  IN3 w0.127: 41.28,101.47 42.06,101.47 42.64,100.89 42.64,100.35 41.41,99.13 36.81,99.13 36.59,99.35 33.79,99.35 32.75,98.31 30.59,98.31 30.01,97.73 26.68,97.73 26.54,97.87 24.8,97.87 24.54,98.13 24.09,98.13 23.45,98.77 23.45,99 23.2,99.25 17.36,99.25 17.18,99.43 13.17,99.43 12.15,98.42 10.98,98.42 10.83,98.26 10.83,97.77 10.98,97.62 11.13,97.62 v1(11.34,97.83)
USB3RN6: length 41.6
  TOP w0.102: v1(9.31,94.19) 9.12,94.01 8.93,94.01 8.74,94.2 JIO1.57 ; UH1.AR29 38.93,101.5 v1(38.58,101.85)
  IN3 w0.089: v1(38.58,101.85) 38.52,101.85 38.16,101.48 38.16,101.31 38,101.14 37.7,101.14 37.66,101.11 37.65,101.11
  IN3 w0.127: v1(9.31,94.19) 9.07,93.96 8.85,93.96 8.75,94.06 8.75,94.83 9.15,95.24 10.14,95.24 10.57,95.67 10.57,96.94 10.07,97.44 10.07,98.59 10.83,99.35 10.83,99.96 12.15,101.28 18.43,101.28 18.5,101.2 21.78,101.2 21.83,101.26 23.89,101.26 24.39,100.75 24.39,100.52 25.41,99.5 26.28,99.5 26.63,99.15 29.85,99.15 30.64,99.94 31.43,99.94 32.06,100.57 32.06,100.75 32.42,101.11 35.68,101.11 35.82,100.98 36.2,100.98 36.33,101.11 36.71,101.11 36.84,100.98 37.22,100.98 37.35,101.11 37.65,101.11
USB3RP1: length 229.4
  TOP w0.102: v1(38.58,100.83) 38.57,100.83 38.34,100.59 UH1.AP26
  IN4 w0.089: v1(38.58,100.83) 38.58,100.66 38.49,100.57 38.32,100.57 38.13,100.39 38.13,99.4 38.36,99.17 38.68,99.17 38.71,99.14 38.73,99.14
  IN4 w0.117: v5(230.3,76.32) 230.3,73.62 229.99,73.31 229.99,72.81 228.28,71.11 228.28,70.24 225.78,67.74 221.9,67.74 220.71,66.55 214.01,66.55 213.33,67.23 212.87,67.23 212.51,67.59 209.02,67.59 199.75,76.86 199.75,78.04 194.55,83.25 188.24,83.25 184.49,87 183.25,87 181.97,88.28 181.97,92.09 175.68,98.38 161.5,98.38 159.35,100.54 152.02,100.54 150.17,98.69 134.45,98.69 133.03,100.11 118.8,100.11 117.17,101.74 110.09,101.74 109.87,101.96 84.21,101.96 83.35,102.82 72.95,102.82 71.94,101.81 68.01,101.81 67.32,101.13 60.35,101.13 59.99,100.77 56.75,100.77 56.09,101.43 52.46,101.43 52.14,101.11 52.14,100.32 48.87,97.06 47.55,97.06 47.21,96.71 43.67,96.71 41.24,99.14 38.73,99.14
  BOTTOM w0.102: C465.2 230.77,79.91 230.77,79.35 230.09,78.66 230.09,78.29 230.1,78.28 230.1,77.75 230.09,77.74 230.09,76.53 v5(230.3,76.32)
USB3RP1_C: length 4
  BOTTOM w0.102: C465.1 230.79,81.47 230.79,81.85 230.81,81.86 230.81,82.39 230.79,82.41 230.79,82.8 230.55,83.04 v3(230.55,83.48) 230.55,84.31 230.65,84.41 U638.23
USB3RP1_RP: length 48.8
  TOP w0.102: L40.3 254.46,113.63 254.39,113.7 254.39,114.21 254.33,114.27 253.9,114.27 253.7,114.07 253.7,114.06 253.71,114.04 253.71,113.32 253.69,113.3 253.69,113.1 252.69,112.1 v3(252.69,111.39) 252.69,109.28 253.37,108.59 253.37,107.43 253.83,106.97 254.21,106.97 254.32,107.08 v1(254.32,107.25)
  IN3 w0.127: v1(230.76,88.75) 230.76,89.33 231.48,90.05 232.75,90.05 233.05,90.36 233.74,90.36 236.91,93.53 248.34,93.53 254.03,99.22 254.03,104.86 255.25,106.08 255.25,106.8 254.98,107.07 254.51,107.07 v1(254.32,107.25)
  BOTTOM w0.102: v1(230.76,88.75) 230.55,88.54 230.55,88.41 230.65,88.32 U638.5
USB3RP2: length 225.5
  TOP w0.102: UH1.AV26 40.13,100.5 v1(40.48,100.85)
  IN4 w0.089: v1(40.48,100.85) 40.7,100.64 40.7,100.44 40.88,100.26 41.41,100.26 41.92,99.76 41.92,99.72 41.92,99.71
  IN4 w0.117: 41.92,99.71 43.83,97.8 48.57,97.8 51.27,100.49 51.27,101.28 52.17,102.19 61.84,102.19 62.06,101.97 66.28,101.97 67.12,102.8 71.2,102.8 72.32,103.92 76.21,103.92 76.59,104.3 76.94,104.3 77.25,104 83.82,104 84.94,102.88 88.96,102.88 89.28,103.2 109.81,103.2 110.54,102.47 117.55,102.47 118.44,101.59 120.91,101.59 121.57,100.92 127.42,100.92 128.08,101.59 131.81,101.59 132.15,101.25 137.91,101.25 138.46,100.7 149.66,100.7 150.24,101.27 160.84,101.27 162.11,100.01 175.34,100.01 185.12,90.23 185.12,87.81 188.96,83.98 195.11,83.98 200.94,78.15 200.94,76.71 209.32,68.33 213.38,68.33 214.42,67.29 219.79,67.29 221.04,68.53 224.13,68.53 226.42,70.83 226.93,70.83 229.17,73.06 229.17,76.54 229.6,76.97 230.19,76.97 232.12,78.9 232.67,78.9 v1(232.77,78.8)
  BOTTOM w0.102: v1(232.77,78.8) 232.91,78.94 233.27,78.94 233.64,79.31 233.64,79.98 C491.2
USB3RP2_C: length 4.2
  BOTTOM w0.102: U638.17 233.05,84.41 232.96,84.32 232.96,84.13 v3(233.38,83.71) 233.58,83.51 233.58,82.72 233.59,82.71 233.59,82.16 233.58,82.14 233.58,81.48 C491.1
USB3RP2_RP: length 56.1
  TOP w0.102: v1(258.57,121.8) 258.36,122.01 258.36,124.12 258.67,124.44 L43.3
  IN3 w0.127: v1(233.44,89.08) 233.21,89.32 233.21,89.42 233.38,89.6 234.32,89.6 236.86,92.13 250.11,92.13 255.2,97.21 255.2,103.77 256.02,104.58 256.02,116.95 258.4,119.34 258.4,121.64 v1(258.57,121.8)
  BOTTOM w0.102: v1(233.44,89.08) 233.21,88.85 233.21,88.67 232.97,88.44 232.97,88.38 233.05,88.3 U638.11
